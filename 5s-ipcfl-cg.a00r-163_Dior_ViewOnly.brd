# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_TXN1: length 80.4
  TOP w0.102: XU1.AD2 105.46,109.24 105.59,109.11 105.59,109.01 105.44,108.87 104.17,108.87 104.16,108.85 103.14,108.85
  TOP w0.127: 103.14,108.85 100.98,108.85 98.94,106.82 98.94,91.84 88.85,81.75 v1(87.97,81.75) ; U1.K32 56.74,88.98 56.63,88.98 56.54,89.07 56.54,89.6 v1(56.62,89.67)
  BOTTOM w0.127: 87.45,84.62 87.45,81.88 87.58,81.75 v1(87.97,81.75) ; 87.45,84.62 v2(87.72,84.62) ; 87.45,84.62 87.45,85.46 85.98,86.93 83.77,86.93 82.57,85.74 81.81,85.74 81.46,85.38 77.55,85.38 74.58,88.35 71.93,88.35 69.67,90.62 68.65,90.62 68.22,91.05 61.27,91.05 60.35,91.96 58.08,91.96 57.75,91.63 57.1,91.63 56.71,91.24 56.71,90.4 56.89,90.21 56.89,89.95 v1(56.62,89.67)
DMI_TXN2: length 75.9
  TOP w0.127: U1.G33 58.3,88.5 58.12,88.5 58.02,88.6 58.02,88.85 58.14,88.97 58.14,89.27 v1(57.94,89.47) ; v1(85.06,79.85) 85.27,79.64 88.29,79.64 99.7,91.06 99.7,106.48 101.42,108.2 104.32,108.2 XU1.AE1
  BOTTOM w0.127: 82.32,80.1 83.92,80.1 84.12,80.3 84.58,80.3 85.04,79.85 v1(85.06,79.85) ; 82.32,80.1 v2(82.32,80.38) ; 82.32,80.1 73.69,80.1 70.97,82.82 68.83,82.82 68.2,83.45 66.35,83.45 65.72,82.82 64.62,82.82 61.64,85.79 61.64,87.52 61.24,87.92 61.24,88.72 59.98,89.98 58.9,89.98 58.67,89.75 58.22,89.75 v1(57.94,89.47)
DMI_TXN3: length 78.5
  TOP w0.102: XU1.AF3 105.71,106.84 102.22,106.84
  TOP w0.127: 102.22,106.84 101.52,106.84 100.72,106.04 100.72,90.16 88.58,78.02 85.61,78.02 85.29,78.35 85.29,78.69 v1(85.15,78.83) ; v1(56.64,88.45) 56.99,88.1 U1.K34
  BOTTOM w0.127: 77.11,78.98 v2(77.11,79.26) ; 77.11,78.98 73.69,78.98 70.61,82.06 64.31,82.06 61.03,85.33 61.03,87.31 59.63,88.72 58.97,88.72 58.8,88.89 57.07,88.89 v1(56.64,88.45) ; 77.11,78.98 80.37,78.98 80.7,78.65 83.72,78.65 83.87,78.5 84.89,78.5 85.15,78.77 v1(85.15,78.83)
DMI_TXP0: length 75.8
  TOP w0.102: 102.58,109.58 102.59,109.58 102.61,109.57 102.73,109.57 102.83,109.67 103.12,109.67 103.95,110.49 104.7,110.49 105.04,110.15 XU1.AC2
  TOP w0.127: 102.58,109.58 100.61,109.58 98.09,107.07 98.09,94.02 85.55,81.47 v1(85.55,80.71) ; v1(59.09,90.59) 58.82,90.32 58.82,90.06 59.02,89.86 U1.F30
  BOTTOM w0.127: 84.94,81.75 85.32,81.75 85.55,81.52 v1(85.55,80.71) ; 84.94,81.75 82.5,81.75 81.38,80.63 74.06,80.63 71.32,83.38 69.06,83.38 68.47,83.96 66.14,83.96 65.56,83.38 64.76,83.38 63.5,84.64 63.5,85.66 62.18,86.98 62.18,87.61 61.75,88.05 61.75,88.87 59.81,90.8 59.31,90.8 v1(59.09,90.59) ; 84.94,81.75 v2(84.94,81.47)
DMI_TXP1: length 80.5
  TOP w0.102: 103.14,108.6 103.15,108.6 103.19,108.64 103.23,108.64 103.24,108.65 104.24,108.65 104.26,108.67 105.53,108.67 106.1,109.24 XU1.AD3
  TOP w0.127: U1.J32 57.33,89.32 v1(57.33,89.65) ; v1(87.97,81.12) 88.35,81.5 88.95,81.5 99.19,91.74 99.19,106.71 101.08,108.6 103.14,108.6
  BOTTOM w0.127: 87.2,82.92 87.2,81.77 87.47,81.5 87.59,81.5 v1(87.97,81.12) ; 87.2,82.92 87.2,85.36 85.88,86.68 83.87,86.68 82.68,85.49 81.92,85.49 81.56,85.13 77.45,85.13 74.48,88.1 71.83,88.1 69.57,90.36 68.55,90.36 68.12,90.79 61.16,90.79 60.25,91.71 58.19,91.71 57.86,91.38 57.2,91.38 56.96,91.14 56.96,90.5 57.15,90.32 57.15,89.84 v1(57.33,89.65) ; 87.2,82.92 v2(86.93,82.92)
DMI_TXP2: length 75.8
  TOP w0.127: XU1.AE2 104.99,107.94 101.52,107.94 99.96,106.38 99.96,90.96 88.39,79.39 84.86,79.39 v1(84.4,79.85) ; U1.F34 59.07,88.64 58.6,89.12 v1(58.6,89.32)
  BOTTOM w0.127: v2(80.67,79.57) 80.67,79.85 ; 80.67,79.85 v1(84.4,79.85) ; 80.67,79.85 73.58,79.85 70.86,82.57 68.73,82.57 68.09,83.2 66.46,83.2 65.82,82.57 64.51,82.57 61.39,85.69 61.39,87.41 60.98,87.82 60.98,88.62 59.88,89.72 59,89.72 v1(58.6,89.32)
DMI_TXP3: length 78.4
  TOP w0.102: XU1.AF2 105.66,107.41 105.76,107.3 105.76,107.18 105.62,107.04 102.32,107.04 102.31,107.05 102.27,107.05 102.23,107.09 102.22,107.09
  TOP w0.127: v1(85.81,78.83) 85.75,78.83 85.55,78.63 85.55,78.45 85.72,78.28 88.47,78.28 100.46,90.27 100.46,106.14 101.41,107.09 102.22,107.09 ; v1(57.31,88.43) 57.31,87.95 57.32,87.93 57.32,87.75 57.51,87.56 U1.J35
  BOTTOM w0.127: 78.66,78.73 v2(78.66,78.45) ; 78.66,78.73 73.59,78.73 70.51,81.8 64.41,81.8 64.2,81.8 60.78,85.23 60.78,87.21 59.52,88.47 58.86,88.47 58.7,88.63 57.51,88.63 v1(57.31,88.43) ; 78.66,78.73 80.27,78.73 80.59,78.4 83.62,78.4 83.77,78.25 85.23,78.25 v1(85.81,78.83)
DP_CABLE_DETECT: length 138.4
  TOP w0.102: v1(15.85,124.75) 16.05,124.75 16.36,125.06 v2(16.36,129.17) 16.36,130.16 17.36,131.17 21.31,131.17 23.56,128.92 34.15,128.92 34.51,129.28 35.32,129.28 35.86,128.74 38.3,128.74 38.95,129.39 42.4,129.39 43.11,130.1 44.99,130.1 45.46,129.63 53.85,129.63 54.91,130.68 54.91,132.12 54.56,132.47 54.56,134.37 54.93,134.74 55.05,134.74 55.35,135.03 55.35,135.92 55.14,136.12 J69.30
  IN1 w0.102: v1(49.29,73.42) 47.45,73.42 46.76,74.11 45.32,74.11 43.46,75.97 40.73,75.97 40.41,75.66 38.01,75.66 36.97,74.62 36.11,74.62 35.35,75.38 32.12,75.38 31.6,74.86 30.81,74.86 30.08,75.59 28.75,75.59 27.58,76.76 24.82,76.76 21.75,79.82 21.75,86.16 21.13,86.79 21.13,88.09 20,89.22 20,90.52 19.24,91.28 19.24,93.39 18.43,94.2 18.43,98.38 18.38,98.43 18.38,99.57 18.25,99.7 18.25,101.32 18.33,101.41 18.33,107.16 16.08,109.41 16.08,111.32 16.7,111.94 16.7,112.95 17.54,113.8 17.54,115.28 18.27,116.01 18.27,116.31 18.67,116.71 18.67,118.91 18.98,119.22 18.98,120.42 16.25,123.15 16.25,124.35 v1(15.85,124.75)
  BOTTOM w0.102: SR7976.1 50.71,71.92 50.65,71.92 50.37,72.21 50.37,72.9 49.85,73.42 v1(49.29,73.42)
DP_CABLE_DETECT_R: length 15.2
  TOP w0.102: v1(45.18,79.3) 45.13,79.35 45.13,80.26 44.65,80.74 44.65,80.86 44.6,80.9 44.6,81.18 U1.AR48
  IN2 w0.102: v1(49.93,74.8) 49.5,75.23 49.5,75.57 48.81,76.27 48.32,76.27 47.98,76.61 47.98,77.53 46.49,79.01 45.47,79.01 v1(45.18,79.3)
  BOTTOM w0.102: SR40.2 52.36,71.81 52.22,71.67 SR7976.2 51.8,71.99 51.66,72.13 50.76,72.13 50.57,72.31 50.57,73.01 50.76,73.21 50.76,74.04 v2(50.54,74.26) 50,74.8 v1(49.93,74.8)
DP_PW_EN: length 63.4
  TOP w0.102: v1(117.32,165.37) 117.8,165.85 120.06,165.85 121.17,166.96 130.33,166.96 130.91,167.54 130.91,168.1 131.97,169.15 134.09,169.15 134.68,169.75 R93101.2 135.1,169.13 136.1,168.13 137.38,168.13 139.38,170.13 147.53,170.13 149.54,168.13 151.88,168.13 152.5,168.75 152.5,170.6 152.9,171 154.36,171 155.03,170.33 Q93025.1 155.58,170.68 C941629.1 156.78,170.1 R93100.1 ; Q93041.1 104.41,165.38 104.25,165.53 v1(104.09,165.53)
  IN2 w0.102: v1(117.32,165.37) 117.11,165.16 115.12,165.16 114.87,164.91 104.71,164.91 v1(104.09,165.53)
  BOTTOM w0.102: v2(116.53,165.52) 117.17,165.52 v1(117.32,165.37)
DPB_CTRL_CLK: length 164.9
  TOP w0.127: U1.AL13 47.49,98.11 v1(47.67,98.29) ; v1(145.95,156.86) 145.79,157.01 M1R24.2 145.79,158.03 145.16,158.66 143.53,158.66 143.34,158.47 Q9432.4
  IN2 w0.127: v1(70.59,124.48) 70.59,124.99 70.71,125.11 80.22,125.11 80.62,124.7 82.81,124.7 83.55,125.45 83.55,126.8 83.74,126.99 83.74,130.05 84.67,130.99 84.67,144.91 85.76,145.99 85.76,147.88 85.3,148.34 85.3,152.99 85.81,153.49 85.81,157.28 88.17,159.64 89.85,159.64 90.24,160.04 93.17,160.04 93.46,159.74 95.38,159.74 96.2,158.92 102.84,158.92 104,157.76 107.38,157.76 108.31,156.83 112.49,156.83 113.01,157.36 118.58,157.36 118.82,157.11 126.09,157.11 127,158.03 132.87,158.03 133.82,157.08 141.76,157.08 141.95,157.27 145.54,157.27 v1(145.95,156.86)
  BOTTOM w0.127: v1(70.59,124.48) v2(69.42,125.64) 68.4,124.63 68.4,124.25 65.5,121.35 63.51,121.35 58.1,115.94 56.62,115.94 56.19,115.51 54.46,115.51 54.03,115.08 48.52,115.08 47.24,113.81 47.24,111.84 46.99,111.59 46.46,111.59 45.64,110.77 45.22,110.77 44.37,109.93 44.37,108.12 45.37,107.12 45.37,106.18 46.28,105.28 46.28,104.66 46.9,104.03 47.46,104.03 48.24,103.25 48.24,98.85 v1(47.67,98.29)
DPB_CTRL_DATA: length 172
  TOP w0.127: U1.AR8 44.99,100.78 45.46,100.78 45.67,100.57 46.46,100.57 46.95,101.07 47.18,101.07 47.6,101.49 48.31,101.49 49.11,100.69 50.39,100.69 v1(50.43,100.73) ; Q9432.1 146.33,160.18 147.06,159.45 147.06,158.56 147.28,158.35 147.28,158.21 147.38,158.11 147.95,158.11 148.26,157.8 M1R23.2 148.26,157.17 147.95,156.86 v1(147.29,156.86)
  IN2 w0.127: v1(69.8,124.53) 70.61,125.34 80.31,125.34 80.72,124.93 82.66,124.93 83.31,125.58 83.31,126.88 83.51,127.09 83.51,130.2 84.41,131.1 84.41,145.02 85.49,146.1 85.49,147.77 85.04,148.22 85.04,153.13 85.55,153.63 85.55,157.39 88.06,159.91 89.74,159.91 90.13,160.3 93.28,160.3 93.57,160.01 95.49,160.01 96.31,159.18 102.95,159.18 104.15,157.99 107.47,157.99 108.4,157.06 112.34,157.06 112.86,157.58 118.76,157.58 119,157.34 125.99,157.34 126.91,158.26 132.97,158.26 133.92,157.3 141.67,157.3 141.86,157.5 146.66,157.5 v1(147.29,156.86)
  BOTTOM w0.127: v1(50.43,100.73) 48.97,100.73 48.47,101.23 48.47,103.35 47.55,104.26 47,104.26 46.51,104.75 46.51,105.38 45.6,106.28 45.6,107.22 44.6,108.22 44.6,109.83 45.32,110.55 45.74,110.55 46.56,111.36 47.08,111.36 47.47,111.75 47.47,113.71 47.85,114.09 v2(48.31,114.09) 48.31,114.55 48.61,114.86 54.13,114.86 54.55,115.28 56.34,115.28 56.77,115.71 58.2,115.71 63.61,121.12 65.6,121.12 69,124.53 v1(69.8,124.53)
DPB_HPD: length 218.5
  TOP w0.089: U1.BD8 40.34,100.86 39.96,100.48 39.36,100.48 39.19,100.3
  TOP w0.102: U1.AT6 45,101.36 v1(45.29,101.36) ; v1(35.06,106.62) 35.06,106.18 v2(35.38,105.86) 35.66,105.58 35.66,104.2 36,103.85 36,101.9 37.62,100.28 39.14,100.28 39.19,100.3 ; v1(146.07,166.51) 146.87,166.51 147.7,165.68 147.7,164.99 149.18,163.51 149.18,159.05 149.36,158.87 M1Q7.2
  IN1 w0.102: v1(45.29,101.36) 45.28,101.36 44.81,101.83 44.81,102.12 42.75,104.18 42.75,104.99 41.23,106.51 36.16,106.51 35.87,106.22 35.45,106.22 v1(35.06,106.62) 34.21,107.46 34.21,108.98 32.32,110.88 32.32,111.64 32.16,111.79 32.16,113.39 32.37,113.6 32.37,115.2 31,116.57 31,117.21 28.87,119.34 28.87,125.22 27.53,126.57 26.07,126.57 25.49,127.14 25.49,127.85 25.94,128.3 27.72,128.3 32.93,133.51 32.93,138.65 36.33,142.05 v1(36.78,142.05) ; v1(79.14,156) 80.47,157.32 80.47,160.97 85.82,166.33 93.18,166.33 94.82,167.96 96.05,167.96 96.62,167.39 96.62,166.78 97.97,165.43 98.44,165.43 98.71,165.71 101.36,165.71 102.87,164.2 110.2,164.2 112.09,166.09 112.09,166.7 112.86,167.47 112.86,168.89 114.03,170.06 130.16,170.06 131.8,168.42 134.92,168.42 137.2,166.14 145.7,166.14 v1(146.07,166.51)
  IN2 w0.102: v1(79.14,156) 79.14,155.29 78.75,154.89 78.16,154.89 76.88,153.61 76.88,151.96 76.13,151.21 72.5,151.21 71.36,152.35 68.35,152.35 66.83,150.82 66.83,150.56 65.77,149.5 65.77,149 64.65,147.88 63.77,147.88 63.11,148.54 58.69,148.54 56.88,146.73 54.09,146.73 53.61,146.24 51.93,146.24 51.52,145.83 47.72,145.83 46.58,146.97 46.58,147.55 46.17,147.96 43.13,147.96 41.14,145.96 40.69,145.96 v1(36.78,142.05)
  BOTTOM w0.102: v1(45.29,101.36) 44.96,101.36 44.81,101.51 44.81,102.17 44.19,102.78 R2353.2
DPB_HPD_R: length 6.6
  TOP w0.102: M2R1.2 151.38,156.61 151.64,156.86 151.64,158.31 151.41,158.54 v1(151.41,158.84) 151.59,159.02 152.22,159.02 152.46,159.26 M1Q7.3
  BOTTOM w0.102: v1(151.41,158.84) 150.61,158.84 v2(149.74,159.71)
DPB_TXN0: length 64.6
  TOP w0.127: v1(139.95,155.93) 140.13,156.11 M1C118.1 ; v1(123.18,127.97) XU1.D21
  IN2 w0.127: v1(123.18,127.97) 123.8,128.59 123.8,129.33 123.2,129.92 120.79,129.92 120.3,130.42 118.38,130.42 118.03,130.77 118.03,131.93 118.16,132.06 118.65,132.06 119.15,131.56 119.78,131.56 120.17,131.94 120.39,131.94 120.65,131.68 120.65,131.03 121.06,130.62 123.03,130.62 124.36,131.95 124.36,134.86 121.55,137.67 121.55,140.52 120.83,141.24 120.83,143.76 121.18,144.11 121.18,145.68 120.8,146.07 120.18,146.07 120.05,146.19 120.05,146.57 120.18,146.7 120.8,146.7 121.08,146.98 121.08,153.15 123.01,155.08 126.38,155.08 127.76,156.45 132.18,156.45 133.73,154.9 139.19,154.9 139.7,155.41 139.7,155.68 v1(139.95,155.93)
DPB_TXN1: length 65.8
  TOP w0.127: v1(134.64,156.64) 134.34,156.64 134.21,156.77 134.21,157.16 134.3,157.25 M1C120.1 ; v1(123.22,127.04) 123.29,127.12 123.57,127.12 123.65,127.03 XU1.E22
  IN2 w0.127: v1(123.22,127.04) 123.09,126.91 122.93,126.91 122.8,127.05 122.8,127.28 122.68,127.4 121.85,127.4 119.86,129.38 117.95,129.38 117.15,130.18 116.08,130.18 115.8,130.46 115.8,130.86 116.8,131.86 116.8,132.69 117.22,133.11 119.13,133.11 119.26,132.98 119.76,132.98 120.02,133.24 120.97,133.24 121.31,132.9 121.31,132.49 122.01,131.79 122.73,131.79 123.32,132.38 123.32,134.41 120.51,137.21 120.51,140.06 119.66,140.91 119.66,144.64 119.14,145.16 118.12,145.16 116.1,147.19 116.1,148.17 117.61,149.68 117.61,152.25 118.57,153.2 119.66,153.2 122.58,156.12 125.85,156.12 127.24,157.51 132.6,157.51 133.75,156.35 134.35,156.35 v1(134.64,156.64)
DPB_TXN2: length 49.7
  TOP w0.127: v1(141.98,155.93) 141.85,156.07 141.85,156.32 M1C122.1 ; XU1.A23 124.79,130.27 124.99,130.47 v1(124.99,130.7)
  IN2 w0.127: v1(141.98,155.93) 141.87,155.93 141.64,155.7 141.64,155.27 141.37,155.01 140.46,155.01 139.58,154.13 133.41,154.13 131.87,155.67 128.29,155.67 126.93,154.3 123.33,154.3 121.85,152.83 121.85,146.93 121.97,146.82 121.97,143.78 121.6,143.42 121.6,141.66 122.39,140.87 122.39,138.02 125.13,135.28 125.13,131.63 124.37,130.86 124.37,130.56 124.59,130.34 124.92,130.34 124.99,130.42 v1(124.99,130.7)
DPB_TXN3: length 40.8
  TOP w0.102: v1(124.08,128.01) 124.28,128.01 124.57,127.72 XU1.D23
  TOP w0.127: v1(130.88,155.13) 131.06,155.31 131.06,155.72 132,156.66 132,156.95 M1C124.1
  IN2 w0.127: v1(124.08,128.01) 124.18,128.01 124.46,128.28 124.46,128.64 125.65,129.83 125.65,135.55 123.02,138.18 123.02,141 122.11,141.92 122.11,143.16 122.49,143.54 122.49,147.02 122.39,147.12 122.39,152.64 123.54,153.79 130.54,153.79 131.1,154.35 131.1,154.92 v1(130.88,155.13)
DPB_TXP0: length 64.4
  TOP w0.127: v1(139.19,155.93) 139.22,155.96 M1C117.1 ; XU1.C21 123.09,128.79 v1(123.09,129.05)
  IN2 w0.127: v1(123.09,129.05) 123.09,128.79 123.24,128.64 123.44,128.64 123.53,128.73 123.53,129.22 123.09,129.66 120.68,129.66 120.19,130.15 118.27,130.15 117.76,130.66 117.76,132.04 118.05,132.32 118.76,132.32 119.26,131.83 119.67,131.83 120.06,132.21 120.5,132.21 120.92,131.79 120.92,131.14 121.17,130.89 122.92,130.89 124.09,132.06 124.09,134.75 121.28,137.56 121.28,140.4 120.56,141.13 120.56,143.87 120.92,144.22 120.92,145.57 120.69,145.8 120.07,145.8 119.78,146.08 119.78,146.68 120.07,146.97 120.69,146.97 120.81,147.09 120.81,153.26 122.9,155.34 126.27,155.34 127.65,156.72 132.29,156.72 133.84,155.17 139.08,155.17 139.43,155.52 139.43,155.69 v1(139.19,155.93)
DPB_TXP1: length 65.8
  TOP w0.127: v1(124.11,127.12) 124.06,127.12 XU1.D22 ; M1C119.1 135.56,156.77 v1(135.43,156.64)
  IN2 w0.127: v1(135.43,156.64) 135.43,156.28 135.24,156.09 133.64,156.09 132.49,157.24 127.35,157.24 125.96,155.85 122.69,155.85 119.77,152.94 118.68,152.94 117.88,152.14 117.88,149.57 116.37,148.06 116.37,147.3 118.23,145.43 119.25,145.43 119.92,144.75 119.92,141.02 120.78,140.17 120.78,137.32 123.58,134.52 123.58,132.27 122.84,131.52 121.9,131.52 121.04,132.38 121.04,132.79 120.86,132.97 120.13,132.97 119.87,132.72 119.15,132.72 119.02,132.84 117.33,132.84 117.07,132.58 117.07,131.75 116.07,130.75 116.07,130.57 116.19,130.44 117.26,130.44 118.06,129.64 119.98,129.64 121.96,127.66 122.79,127.66 122.96,127.5 123.73,127.5 v1(124.11,127.12)
DPB_TXP2: length 49.8
  TOP w0.127: v1(124.98,129.79) 124.72,129.79 124.57,129.64 XU1.B23 ; M1C121.1 141.16,156 v1(141.22,155.93)
  IN2 w0.127: v1(124.98,129.79) 124.98,129.92 124.83,130.08 124.48,130.08 124.1,130.45 124.1,130.97 124.86,131.74 124.86,135.17 122.12,137.91 122.12,140.76 121.33,141.55 121.33,143.53 121.7,143.89 121.7,146.71 121.59,146.82 121.59,152.94 123.22,154.57 126.82,154.57 128.18,155.93 131.98,155.93 133.52,154.4 139.47,154.4 140.35,155.27 141.26,155.27 141.37,155.38 141.37,155.78 v1(141.22,155.93)
DPB_TXP3: length 40.8
  TOP w0.102: v1(125.03,128) 124.65,128 124.57,128.08 XU1.C23
  TOP w0.127: v1(131.52,155.13) 131.32,155.34 131.32,155.62 132.26,156.55 132.26,156.9 M1C123.1
  IN2 w0.127: v1(131.52,155.13) 131.37,154.98 131.37,154.24 130.65,153.53 123.65,153.53 122.66,152.53 122.66,147.23 122.76,147.13 122.76,143.43 122.38,143.05 122.38,142.03 123.29,141.11 123.29,138.29 125.92,135.67 125.92,129.72 124.73,128.53 124.73,128.3 v1(125.03,128)
DPC_AUXN: length 96.1
  TOP w0.102: XU1.B12 113.94,129.92 113.94,130.9 113.78,131.06
  TOP w0.127: v1(104.21,133.67) 104.49,133.39 104.49,133.13 105.13,132.5 110.06,132.5 111.04,131.51 113.32,131.51 113.78,131.06
  IN2 w0.127: v1(102.24,156.61) 102.24,157.62 101.47,158.38 93.62,158.38 92.48,159.53 90.55,159.53 88.07,157.05 87.34,157.05 86.32,156.03 86.32,153.24 85.81,152.73 85.81,148.55 86.27,148.09 86.27,145.74 85.38,144.85 85.38,141.79 86.32,140.85 86.32,138.38 89.81,134.89 89.81,133.85 91.18,132.49 91.18,130.33 92.32,129.19 93.26,129.19 96.17,132.1 96.17,133.25 96.61,133.69 102.37,133.69 102.85,134.18 103.81,134.18 104.21,133.77 v1(104.21,133.67)
  BOTTOM w0.127: 104.11,158.49 104.11,156.41 103.64,155.95 102.57,155.95 102.24,156.27 v1(102.24,156.61) ; 104.11,158.49 104.11,164.56 104.75,165.2 104.75,167.1 103.71,168.14 102.95,168.14 102.6,168.5 102.6,168.91 102.87,169.18 102.87,170.07 102.97,170.17 M1C101.2 ; 104.11,158.49 v2(103.85,158.49)
DPC_AUXN_C: length 3.8
  BOTTOM w0.127: AQ17.1 107.36,169.92 106.93,170.35 104.38,170.35 M1C101.1
DPC_AUXN_I: length 83.3
  TOP w0.127: v1(115.1,167.51) 115.18,167.43 115.18,167.2 115.05,167.08 114.56,167.08 113.09,165.6 111.5,165.6 M1R21.2 110.67,165.47 110.67,165.6 110.54,165.72 107.29,165.72 106.7,166.31 v1(106.7,167.07) 107.38,167.74 108.27,167.74 108.52,168 108.52,168.43 108.84,168.74 109.14,168.74 109.4,168.99 109.4,169 109.94,169.55 AQ18.3
  IN1 w0.127: v1(115.1,167.51) 114.83,167.51 114.7,167.38 114.7,167.17 114.83,167.05 115.28,167.05 115.4,166.92 115.4,166.13 115.28,166 114.65,166 114.24,166.42 113.27,166.42 112.69,165.84 112.69,164.62 113.49,163.82 118.18,163.82 118.98,164.62 118.98,165.68 118.57,166.09 117.33,166.09 116.77,166.65 116.77,167.49 117.28,168 117.8,168 117.93,167.87 117.93,167.02 118.21,166.74 119.07,166.74 119.36,167.02 119.36,168.56 119.48,168.68 119.99,168.68 120.12,168.56 120.12,167.52 120.4,167.24 120.9,167.24 121.02,167.24 121.32,167.54 121.32,168.56 121.45,168.68 122.01,168.68 122.19,168.51 122.19,165.92 122.01,165.75 120.51,165.75 120.23,165.47 120.23,164.62 120.51,164.34 122.01,164.34 122.14,164.21 122.14,163.82 122.42,163.54 123.03,163.54 123.31,163.82 123.31,164.38 123.44,164.51 124.42,164.51 124.7,164.79 124.7,165.59 124.42,165.87 123.62,165.87 123.49,166 123.49,168.43 123.62,168.56 124.37,168.56 126.78,166.15 126.78,165.86 125.98,165.06 125.98,164.3 126.53,163.75 126.93,163.75 127.95,164.77 128.54,164.77 129.17,164.14 129.17,161.44 127.94,160.21 126.16,160.21 125.86,160.52 125.86,161.01 125.98,161.13 J302.17
  BOTTOM w0.127: v1(106.7,167.07) 106.7,169.41 106.2,169.92 AQ17.6
DPC_AUXP: length 96.1
  TOP w0.102: 114.14,131.06 114.14,130.01 114.4,129.75 114.56,129.75 114.66,129.85 114.66,130.11 XU1.A12
  TOP w0.127: 114.14,131.06 113.43,131.77 111.15,131.77 110.17,132.75 105.24,132.75 104.75,133.24 104.75,133.52 v1(104.88,133.64)
  IN2 w0.127: v1(101.51,156.61) 101.6,156.61 101.97,156.98 101.97,157.51 101.36,158.12 93.51,158.12 92.37,159.26 90.66,159.26 88.18,156.78 87.45,156.78 86.59,155.92 86.59,153.13 86.08,152.62 86.08,148.66 86.53,148.2 86.53,145.63 85.65,144.74 85.65,141.9 86.59,140.96 86.59,138.49 90.08,135 90.08,133.96 91.45,132.6 91.45,130.44 92.43,129.46 93.15,129.46 95.9,132.21 95.9,133.36 96.5,133.96 102.26,133.96 102.74,134.44 103.92,134.44 104.19,134.18 104.97,134.18 105.1,134.05 105.1,133.87 v1(104.88,133.64)
  BOTTOM w0.127: M1C111.2 102.94,168.9 102.85,168.8 102.85,168.6 103.06,168.39 103.81,168.39 105,167.2 105,165.09 104.37,164.45 104.37,156.78 ; 104.37,156.78 104.37,156.31 103.75,155.69 102.46,155.69 101.55,156.61 v1(101.51,156.61) ; 104.37,156.78 v2(104.63,156.78)
DPC_AUXP_C: length 3.8
  BOTTOM w0.127: AQ17.4 104.8,168.62 104.7,168.72 104.7,169.64 104.6,169.74 103.71,169.74 103.61,169.64 103.61,169.47 M1C111.1
DPC_AUXP_I: length 83.3
  TOP w0.127: v1(115.06,168.16) 114.64,167.74 114.64,167.52 112.98,165.86 111.43,165.86 M1R22.1 110.68,165.98 107.39,165.98 106.96,166.41 106.96,166.69 v1(107.34,167.07) 107.28,167.13 107.28,167.28 107.48,167.49 108.37,167.49 108.78,167.89 108.78,168.32 108.94,168.49 109.22,168.49 109.35,168.36 109.35,168.17 109.27,168.1 109.27,167.92 109.35,167.85 109.54,167.85 109.94,168.25 AQ18.1
  IN1 w0.127: v1(115.06,168.16) 115.67,167.55 115.67,166.02 115.39,165.74 114.54,165.74 114.12,166.16 113.38,166.16 112.95,165.72 112.95,164.73 113.6,164.09 118.07,164.09 118.71,164.73 118.71,165.57 118.46,165.83 117.22,165.83 116.51,166.54 116.51,167.6 117.17,168.26 117.91,168.26 118.2,167.98 118.2,167.13 118.32,167.01 118.96,167.01 119.09,167.13 119.09,168.67 119.37,168.95 120.1,168.95 120.39,168.67 120.39,167.63 120.51,167.5 120.79,167.5 120.91,167.5 121.05,167.65 121.05,168.67 121.34,168.95 122.12,168.95 122.45,168.62 122.45,165.81 122.12,165.48 120.62,165.48 120.5,165.36 120.5,164.73 120.62,164.61 122.12,164.61 122.41,164.32 122.41,163.93 122.53,163.81 122.92,163.81 123.04,163.93 123.04,164.49 123.33,164.77 124.31,164.77 124.43,164.9 124.43,165.48 124.31,165.6 123.51,165.6 123.23,165.89 123.23,168.54 123.51,168.82 124.48,168.82 127.05,166.26 127.05,165.75 126.25,164.95 126.25,164.41 126.64,164.02 126.82,164.02 127.84,165.04 128.65,165.04 129.44,164.25 129.44,161.33 128.05,159.95 126.05,159.95 125.59,160.41 125.59,160.66 J302.15
  BOTTOM w0.127: v1(107.34,167.07) 106.96,167.45 106.96,167.58 107.06,167.68 107.75,167.68 107.85,167.78 107.85,168.04 107.72,168.16 107.11,168.16 106.96,168.32 106.96,168.49 107.08,168.62 AQ17.3
DPC_CON_PIN13: length 4.8
  TOP w0.102: FR12.2 125.03,157.98 SR7904.1 M1C113.1 124.73,159.58 v1(124.67,159.63)
  IN1 w0.102: v1(124.67,159.63) 123.81,160.49 J302.13
DPC_CON_PIN13_R: length 35.4
  TOP w0.102: FR12.1 126.45,157.81 v2(127.02,157.24) 127.25,157.47 128.24,157.47 128.93,158.16 128.93,159.43 129.44,159.93 130.05,159.93 130.91,160.8 130.91,163.11 128.74,165.28 120.96,165.28 119.85,164.16 115.72,164.16 115.07,163.52 113.42,163.52 112.37,162.47 112.37,161.64 112.14,161.41 112.14,161.15 111.93,160.94 M1C112.1 111.5,159.6 111.13,159.23 AQ19.5
DPC_CON_PIN14: length 15.4
  TOP w0.102: R99508.1 122.71,158.35 v1(122.71,159.71)
  IN2 w0.102: v1(122.71,159.71) 123.37,160.37 128.09,160.37 128.93,161.21 128.93,162.83 128.51,163.26 125.03,163.26 J302.14
DPC_CTRL_CLK: length 120.4
  TOP w0.127: v1(46.46,99) 46.46,98.66 U1.AN13 ; SR7905.2 SR7906.2 104.91,168.84 104.79,168.96 103.61,168.96 102.61,167.96 102.61,167.68 102.73,167.55 103,167.55 103.12,167.68 103.38,167.68 103.5,167.55 103.5,167.3 v1(103.3,167.1)
  BOTTOM w0.127: v1(46.46,99) 46.84,99 47.21,99.38 47.21,99.84 47.44,100.07 47.48,100.07 47.73,100.32 47.73,103.04 47.24,103.53 46.69,103.53 45.77,104.45 45.77,105.07 44.84,106 44.84,106.94 43.86,107.91 43.86,110.15 44.47,110.76 44.49,110.76 45.01,111.28 45.43,111.28 45.87,111.72 45.87,113.53 47.93,115.59 53.82,115.59 54.25,116.02 55.91,116.02 56.34,116.45 57.89,116.45 63.3,121.86 65.29,121.86 67.63,124.19 67.63,127.36 70.23,129.96 70.23,134.51 73.51,137.79 73.51,140.34 74.47,141.3 74.47,141.85 74.88,142.26 74.88,145.07 74.57,145.38 74.57,146.76 75.58,147.77 77.65,147.77 77.94,148.06 79.69,148.06 79.87,148.24 83.37,148.24 83.97,148.83 84.74,148.83 85.32,149.41 85.32,149.42 86.54,150.64 86.54,151.68 87.58,152.72 88.26,152.72 88.96,153.42 88.96,153.75 v2(89.33,154.12) 93.24,154.12 95.11,155.99 95.11,156.63 96.12,157.65 101.7,157.65 103.3,159.25 103.3,165.86 103.6,166.16 103.6,166.79 v1(103.3,167.1)
DPC_CTRL_CLK_R: length 2.4
  TOP w0.127: v2(106.2,167.63) 106.69,168.13 SR7905.1 107.03,168.52 107.3,168.25 AQ18.6
DPC_CTRL_DATA: length 120.7
  TOP w0.127: v1(102,167.07) 102,167.72 103.5,169.22 104.79,169.22 104.94,169.37 SR7902.2 SR7901.2 ; U1.AL10 47.26,99.87 47.44,99.87 v1(47.65,99.67)
  BOTTOM w0.127: v1(47.65,99.67) 47.98,100 47.98,103.15 47.35,103.78 46.8,103.78 46.02,104.55 46.02,105.18 45.12,106.08 45.12,107.02 44.12,108.02 44.12,110.03 44.14,110.05 45.12,111.03 45.54,111.03 46.12,111.61 46.12,113.42 48.04,115.34 53.93,115.34 54.35,115.77 56.06,115.77 56.49,116.19 58,116.19 63.41,121.61 65.4,121.61 67.92,124.13 67.92,127.29 70.48,129.85 70.48,134.41 73.76,137.69 73.76,140.22 74.73,141.18 74.73,141.72 75.13,142.13 75.13,145.18 74.83,145.48 74.83,146.65 75.69,147.51 77.76,147.51 78.05,147.81 79.8,147.81 79.98,147.98 83.86,147.98 v2(84.2,148.33) 84.63,148.33 86.79,150.48 86.79,151.57 87.63,152.42 88.37,152.42 89.48,153.53 93.01,153.53 95.36,155.88 95.36,156.53 96.23,157.39 101.8,157.39 103.55,159.15 103.55,165.75 103.86,166.05 103.86,167.15 103.47,167.53 102.13,167.53 102,167.4 v1(102,167.07)
DPC_CTRL_DATA_R: length 6.4
  TOP w0.127: v2(102.36,169.38) 103.3,170.32 106.58,170.32 106.72,170.18 SR7901.1 106.98,169.55 AQ18.4
DPC_HPD: length 194.3
  TOP w0.102: U1.AV13 v1(45.11,99.79) 45.46,99.79 U1.AN10 ; v1(121.75,166.54) 129.18,166.54 131.52,164.2 131.52,161.1 130.45,160.04 130.45,159.65 129.99,159.19 M1Q8.2
  IN1 w0.102: v1(78.72,155.46) 79.2,155.46 80.8,157.05 80.8,161.01 85.91,166.12 93.27,166.12 94.9,167.76 95.96,167.76 95.97,167.75 95.98,167.75 96.4,167.33 96.4,166.71 97.89,165.23 98.56,165.23 98.84,165.51 101.18,165.51 102.69,164 112.22,164 112.89,163.33 118.38,163.33 119.63,164.58 119.63,165.57 120.31,166.25 121.46,166.25 v1(121.75,166.54) ; v1(36.58,143.29) 32.52,139.23 32.52,133.67 27.79,128.94 25.9,128.94 25.09,128.12 25.09,126.83 25.76,126.16 27.36,126.16 28.46,125.05 28.46,119.17 29.78,117.86 29.78,116.96 30.8,115.94 31.06,115.94 31.96,115.03 31.96,113.77 31.76,113.56 31.76,111.63 31.91,111.47 31.91,110.71 33.81,108.81 33.81,106.99 34.98,105.82 36.08,105.82 36.37,106.11 41.06,106.11 42.31,104.85 42.31,104.04 44.12,102.23 44.12,101.87 44.58,101.41 44.58,100.32 v1(45.11,99.79)
  IN2 w0.102: v1(36.58,143.29) 37.71,143.29 40.59,146.17 41.06,146.17 43.05,148.16 46.26,148.16 46.79,147.63 46.79,147.05 47.8,146.03 51.44,146.03 51.9,146.5 53.57,146.5 54.01,146.93 56.79,146.93 58.61,148.75 63.2,148.75 63.86,148.08 64.57,148.08 65.57,149.08 65.57,149.59 66.62,150.65 66.62,150.91 68.27,152.55 71.61,152.55 72.76,151.41 76.04,151.41 76.67,152.04 76.67,153.7 78.44,155.46 v1(78.72,155.46)
  BOTTOM w0.102: R2354.2 43.76,102.72 43.97,102.72 44.6,102.08 44.6,100.77 44.83,100.55 44.83,100.04 45.08,99.79 v1(45.11,99.79) ; v2(121.21,166) v1(121.75,166.54)
DPC_HPD_CON: length 16.4
  TOP w0.102: v1(129.31,160.49) 128.32,159.5 M1R20.1 127.21,159.18 M1Q8.3
  BOTTOM w0.102: J302.18 126.91,163.81 127.84,164.73 130.99,164.73 131.48,164.24 131.48,161.25 130.47,160.24 129.56,160.24 v1(129.31,160.49)
DPC_PIN13_INV: length 30.6
  TOP w0.254: M1C114.1 SR7907.2 111.44,158.57 112.1,159.23 AQ19.2 113.37,159.23 113.57,159.43 113.57,159.7 113.39,159.88 AQ19.3 112.73,161.11 v1(112.83,161.2)
  TOP w0.508: v1(112.44,168.85) 113.35,169.76 115.27,169.76 v1(116.28,168.75)
  IN2 w0.381: v1(106.22,169.17) v1(108.96,169.17) 112.12,169.17 v1(112.44,168.85)
  BOTTOM w0.254: v1(112.83,161.2) 112.33,161.7 112.33,162.75 113.85,164.28 114.25,164.28 v2(117.16,167.19) 117.19,167.22 117.19,168.06 116.51,168.75 v1(116.28,168.75)
  BOTTOM w0.356: AQ17.2 108.87,169.27 v1(108.96,169.17) ; AQ17.5 106.13,169.27 v1(106.22,169.17)
DPC_PIN13_MOS: length 31.1
  TOP w0.102: M1C102.1 110.88,168.94 110.84,168.9 AQ18.2 ; M1C102.1 112.02,168.22 v1(112.39,168.22) ; M1C102.1 SR7903.2 111.01,170.05 108.92,170.05 108.51,169.64 108.51,169.3 108.11,168.9 AQ18.5 ; AQ19.6 111.01,158.58 112.06,159.63 112.06,160.14 112.34,160.42 112.34,161.33 112.83,161.81 v1(112.83,162.12)
  IN2 w0.102: v1(112.39,168.22) 113.49,167.12 114.09,167.12 114.48,167.51 114.48,168.18 115.47,169.17 116.95,169.17 117.32,168.8 v1(118.54,168.8)
  BOTTOM w0.102: v1(118.54,168.8) 118.64,168.7 v2(118.64,167.91) 118.64,166 116.23,163.59 113.56,163.59 112.83,162.85 v1(112.83,162.12)
DPC_TXN0: length 72.6
  TOP w0.102: XU1.A18 119.99,129.89 119.93,129.83 119.81,129.83 119.63,130.01 119.63,130.48 119.82,130.67 119.82,131.29 119.73,131.38 119.73,131.43 119.71,131.45 119.71,131.5 119.7,131.52
  TOP w0.127: v1(117.14,156.07) 116.81,156.4 116.81,156.63 M1C104.2 ; v1(117.94,135.68) 118.1,135.52 118.18,135.44 118.44,135.44 118.72,135.17 118.72,133.52 119.2,133.04 119.42,132.82 119.46,132.78 119.46,131.75 119.59,131.62 119.7,131.52
  IN2 w0.127: v1(117.94,135.68) 117.71,135.45 117.47,135.45 117.35,135.58 117.35,136.01 116.6,136.76 115.86,136.76 115.25,136.15 115.25,134.88 115.63,134.5 115.63,134.28 115.25,133.9 115.25,133.08 114.58,132.41 106.64,132.41 106.51,132.53 106.51,132.81 106.92,133.23 107.25,133.23 107.52,132.96 107.98,132.96 108.27,133.24 108.27,135.86 107.86,136.27 104.87,136.27 104.61,136.02 103.68,136.02 103.18,136.53 103.18,136.74 103.28,136.85 108.53,136.85 108.74,136.64 109.47,136.64 109.67,136.85 110.17,136.85 110.3,136.72 110.3,136.25 110.58,135.97 111.07,135.97 111.35,136.25 111.35,136.72 111.48,136.85 111.71,136.85 112.09,136.47 112.1,136.48 112.6,136.48 112.89,136.77 112.89,137.34 113.61,138.07 113.61,138.22 113.61,138.5 113.71,138.59 114.7,138.59 115.1,139 115.1,139.42 114.82,139.7 113.8,139.7 113.65,139.86 113.65,148.93 114.94,150.21 114.94,150.92 115.56,151.54 115.56,153.3 115.91,153.65 115.91,154.18 115.48,154.61 115.48,154.79 115.6,154.92 116.02,154.92 116.39,154.55 116.85,154.55 117.21,154.91 117.21,155.31 116.88,155.65 116.88,155.81 v1(117.14,156.07)
DPC_TXN0_C: length 3.9
  TOP w0.127: M1C104.1 116.69,158.21 116.69,158.31 116.58,158.42 M1U3.10 M1U3.1 116.46,159.58 116.46,159.83 116.74,160.11 116.74,160.66 J302.3
DPC_TXN1: length 79.7
  TOP w0.102: XU1.E18 119.99,126.89 120.57,127.46 120.57,128.63 120.69,128.76 120.69,129.22
  TOP w0.127: 120.69,129.22 120.69,130.66 120.57,130.77 120.57,133.51 120.08,134 120.08,134.19 119.79,134.48 119.49,134.48 v1(119.3,134.66) ; M1C106.2 114.65,156.5 114.65,156.23 v1(114.45,156.02)
  IN2 w0.127: v1(114.45,156.02) 114.73,156.3 114.73,156.45 114.6,156.58 113.38,156.58 113.14,156.34 113.14,155.6 114.78,153.96 114.78,151.86 114.12,151.2 114.12,150.58 112.84,149.29 112.84,138.54 111.92,137.62 100.49,137.62 100.07,137.2 100.07,136.2 100.28,135.99 102.56,135.99 103.32,135.23 105.17,135.23 105.37,135.44 106.62,135.44 106.97,135.08 106.97,134.37 105.5,132.9 102.41,132.9 102.23,132.72 102.23,131.76 102.35,131.63 114.93,131.63 116.03,132.73 116.03,133.57 116.34,133.89 118.13,133.89 118.64,134.41 119.05,134.41 v1(119.3,134.66)
DPC_TXN1_C: length 10.5
  TOP w0.127: J302.6 118.67,162.88 118.67,163.39 118.39,163.67 115.92,163.67 115.2,162.94 115.2,162.31 114.58,161.69 M1U3.5 M1U3.6 114.58,158.36 114.53,158.31 114.53,158.08 M1C106.1
DPC_TXN2: length 74
  TOP w0.102: 121.37,129.2 121.37,129.18 121.48,129.07 121.48,128.1 XU1.D19
  TOP w0.127: v1(119.23,156.12) 118.97,156.38 118.97,156.56 M1C108.2 ; v1(121.63,134) 121.63,133.07 121.37,132.82 121.37,131.82 121.5,131.69 121.64,131.69 121.92,131.42 121.92,130.83 121.64,130.55 121.5,130.55 121.37,130.42 121.37,129.2
  IN2 w0.127: v1(119.23,156.12) 119.04,155.93 119.04,155.07 118.77,154.8 118.33,154.8 116.33,152.8 116.33,151.21 115.78,150.66 115.78,149.88 114.51,148.62 114.51,146.94 115.02,146.43 115.02,145.13 115.15,145.01 116.35,145.01 116.77,144.58 116.77,142.65 116.62,142.5 116.62,141.67 116.29,141.34 115.64,141.34 115.35,141.62 115.35,142.27 115.23,142.39 114.64,142.39 114.5,142.26 114.5,140.64 114.64,140.5 115.59,140.5 115.98,140.11 115.98,138.78 114.91,137.71 114.48,137.71 113.66,136.9 113.66,136.06 113.43,135.83 113.43,135.8 113.33,135.7 112.42,135.7 112.29,135.57 112.29,135.24 113.06,134.48 113.06,134.03 112.78,133.75 112,133.75 111.72,134.03 111.72,134.29 111.54,134.46 111.22,134.46 111.08,134.33 111.08,134.08 110.79,133.8 109.97,133.8 109.69,134.08 109.69,135.74 109.56,135.86 109.17,135.86 109.04,135.74 109.04,133.31 109.17,133.18 114.26,133.18 114.47,133.39 114.47,133.57 114.13,133.91 114.13,134.47 114.46,134.8 114.46,136.86 114.76,137.15 115.16,137.15 115.82,137.81 116.99,137.81 117.27,137.53 117.27,137.18 117.4,137.05 118.02,137.05 118.15,137.18 118.15,138.53 118.43,138.81 118.94,138.81 119.23,138.53 119.23,136.36 119.96,135.63 119.96,135.09 120.09,134.96 120.93,134.96 121.45,134.44 121.45,134.18 v1(121.63,134)
DPC_TXN2_C: length 4.8
  TOP w0.127: M1C108.1 119.12,158 119.12,158.23 119.26,158.36 119.88,158.36 120.26,158.74 M1U4.2 M1U4.9 120.26,160.31 120.62,160.67 120.75,160.67 J302.9
DPC_TXN3: length 52.1
  TOP w0.102: 122.27,129.63 122.27,129.62 122.56,129.33 122.56,128.81 122.47,128.71 122.47,128.7 122.39,128.63 122.39,127.18 XU1.E20
  TOP w0.127: v1(120.6,156.3) 120.8,156.5 120.8,156.63 M1C110.2 ; v1(122.25,132.93) 122.5,132.68 122.81,132.68 123.26,132.23 123.26,131.76 122.96,131.46 122.79,131.46 122.66,131.32 122.66,131.09 122.79,130.95 123.22,130.95 123.49,130.68 123.49,130.17 123.21,129.89 122.4,129.89 122.27,129.76 122.27,129.63
  IN2 w0.127: v1(122.25,132.93) 122.41,132.93 122.54,133.06 122.54,134.06 121.14,135.47 120.84,135.47 120.33,135.98 120.33,136.25 119.73,136.85 119.73,139.69 119.57,139.85 119.42,139.85 119.14,139.58 117.78,139.58 117.64,139.44 117.64,138.59 117.37,138.32 116.77,138.32 116.49,138.6 116.49,140.35 116.77,140.63 118.71,140.63 118.86,140.78 118.86,141.09 118.73,141.21 117.41,141.21 117.13,141.5 117.13,142 117.41,142.28 118.07,142.28 118.2,142.41 118.2,142.67 118.07,142.8 117.57,142.8 117.28,143.08 117.28,143.58 117.57,143.87 118.07,143.87 118.2,144 118.2,144.27 118.07,144.39 117.52,144.39 117.28,144.63 117.28,144.79 117.28,144.79 117.28,144.91 116.55,145.64 116.44,145.64 116.31,145.51 115.81,145.51 115.53,145.8 115.53,146.3 115.62,146.39 115.62,146.57 115.25,146.94 115.02,147.17 115.02,148.41 116.32,149.71 116.32,150.49 116.84,151 116.84,152.59 118.49,154.24 119.61,154.24 120.97,155.6 120.97,155.93 v1(120.6,156.3)
DPC_TXN3_C: length 24.2
  TOP w0.127: M1C110.1 121.26,158.54 M1U4.4 M1U4.7 121.26,159.78 121.54,160.06 121.71,160.06 122.04,160.39 128.12,160.39 129.13,161.41 129.13,163.82 128.84,164.11 128.33,164.11 127.84,163.62 127.27,163.62 126.66,164.23 126.34,164.23 125.86,163.74 125.34,163.74 124.89,164.2 124.46,164.2 123.95,163.69 123.52,163.69 122.91,164.3 122.28,164.3 121.86,163.89 121.86,163.32 122.26,162.93 122.61,162.93 J302.12
DPC_TXP0: length 72.6
  TOP w0.102: 119.52,131.34 119.52,131.3 119.62,131.2 119.62,130.76 119.42,130.56 119.42,129.92 XU1.B18
  TOP w0.127: v1(116.37,156.05) 116.56,156.24 116.56,156.58 M1C103.2 ; v1(117.97,135) 118.16,135.19 118.34,135.19 118.46,135.06 118.46,133.42 118.85,133.04 119.16,132.72 119.16,132.7 119.21,132.66 119.21,131.65 119.52,131.34
  IN2 w0.127: v1(117.97,135) 117.78,135.18 117.36,135.18 117.08,135.46 117.08,135.89 116.48,136.49 115.97,136.49 115.52,136.04 115.52,134.99 115.9,134.61 115.9,134.17 115.52,133.79 115.52,132.97 114.69,132.14 106.53,132.14 106.24,132.42 106.24,132.92 106.81,133.49 107.36,133.49 107.63,133.23 107.87,133.23 108,133.35 108,135.75 107.75,136.01 104.98,136.01 104.72,135.75 103.57,135.75 102.91,136.42 102.91,136.85 103.17,137.11 108.64,137.11 108.85,136.91 109.36,136.91 109.56,137.11 110.28,137.11 110.56,136.83 110.56,136.36 110.69,136.24 110.96,136.24 111.09,136.36 111.09,136.83 111.37,137.11 111.82,137.11 112.19,136.74 112.49,136.74 112.62,136.88 112.62,137.45 113.35,138.18 113.35,138.33 113.35,138.61 113.6,138.86 114.59,138.86 114.84,139.11 114.84,139.31 114.71,139.44 113.69,139.44 113.38,139.75 113.38,149.04 114.67,150.32 114.67,151.03 115.29,151.65 115.29,153.41 115.65,153.76 115.65,154.07 115.21,154.5 115.21,154.9 115.49,155.18 116.13,155.18 116.5,154.82 116.74,154.82 116.95,155.02 116.95,155.2 116.61,155.54 116.61,155.82 v1(116.37,156.05)
DPC_TXP0_C: length 4
  TOP w0.127: M1C103.1 116.43,158 116.43,158.21 116.08,158.56 M1U3.9 M1U3.2 116.2,159.59 116.2,159.94 116.48,160.22 116.48,160.46 J302.1
DPC_TXP1: length 79.7
  TOP w0.102: 120.44,129.22 120.44,129.17 120.49,129.12 120.49,128.84 120.36,128.72 120.36,127.55 120.24,127.42 120.1,127.42 XU1.D18
  TOP w0.127: v1(119.28,134) 119.5,134.22 119.69,134.22 119.83,134.08 119.83,133.89 120.32,133.4 120.32,130.67 120.44,130.55 120.44,129.22 ; M1C105.2 114.91,156.71 114.91,156.38 v1(115.21,156.07)
  IN2 w0.127: v1(119.28,134) 119.14,134.14 118.75,134.14 118.24,133.62 116.45,133.62 116.29,133.46 116.29,132.62 115.04,131.37 102.24,131.37 101.96,131.65 101.96,132.83 102.29,133.16 105.39,133.16 106.7,134.48 106.7,134.97 106.5,135.17 105.48,135.17 105.28,134.97 103.21,134.97 102.45,135.72 100.17,135.72 99.81,136.09 99.81,137.31 100.38,137.89 111.81,137.89 112.57,138.65 112.57,149.4 113.86,150.69 113.86,151.31 114.51,151.97 114.51,153.85 112.88,155.49 112.88,156.45 113.27,156.85 114.71,156.85 115,156.56 115,156.29 v1(115.21,156.07)
DPC_TXP1_C: length 10.4
  TOP w0.127: J302.4 118.17,162.53 118.28,162.65 118.28,162.84 118.41,162.97 118.41,163.29 118.29,163.41 116.03,163.41 115.45,162.84 115.45,162.21 114.83,161.58 114.83,160.01 114.93,159.91 115.01,159.91 115.08,159.84 M1U3.4 M1U3.7 115.08,158.42 114.95,158.3 114.87,158.3 114.78,158.21 114.78,158.13 M1C105.1
DPC_TXP2: length 74
  TOP w0.102: XU1.C19 120.91,128.17 121.01,128.07 121.17,128.07 121.28,128.18 121.28,128.98 121.12,129.14 121.12,129.2
  TOP w0.127: v1(118.46,156.12) 118.72,156.38 118.72,156.66 M1C107.2 ; 121.12,129.2 121.12,130.53 121.39,130.8 121.54,130.8 121.66,130.93 121.66,131.31 121.54,131.44 121.39,131.44 121.12,131.71 121.12,132.92 121.37,133.18 121.37,133.42 v1(120.99,133.8)
  IN2 w0.127: v1(118.46,156.12) 118.77,155.82 118.77,155.18 118.66,155.07 118.22,155.07 116.06,152.91 116.06,151.32 115.51,150.77 115.51,149.99 114.25,148.73 114.25,146.83 114.76,146.32 114.76,145.02 115.04,144.74 116.24,144.74 116.51,144.47 116.51,142.76 116.36,142.61 116.36,141.79 116.18,141.61 115.75,141.61 115.62,141.73 115.62,142.38 115.34,142.66 114.53,142.66 114.23,142.37 114.23,140.53 114.53,140.24 115.48,140.24 115.71,140 115.71,138.89 114.8,137.98 114.37,137.98 113.4,137.01 113.4,136.17 113.2,135.97 112.31,135.97 112.03,135.69 112.03,135.13 112.79,134.37 112.79,134.14 112.67,134.01 112.11,134.01 111.99,134.14 111.99,134.4 111.65,134.73 111.11,134.73 110.81,134.44 110.81,134.19 110.68,134.06 110.08,134.06 109.96,134.19 109.96,135.85 109.67,136.13 109.06,136.13 108.77,135.85 108.77,133.2 109.06,132.92 114.37,132.92 114.74,133.28 114.74,133.68 114.4,134.02 114.4,134.36 114.73,134.69 114.73,136.75 114.87,136.88 115.27,136.88 115.93,137.54 116.88,137.54 117,137.42 117,137.07 117.29,136.78 118.13,136.78 118.41,137.07 118.41,138.42 118.54,138.55 118.83,138.55 118.96,138.42 118.96,136.25 119.69,135.52 119.69,134.98 119.98,134.69 120.82,134.69 121.18,134.33 121.18,133.99 v1(120.99,133.8)
DPC_TXP2_C: length 4.8
  TOP w0.127: M1C107.1 118.62,157.95 118.74,157.95 118.87,158.08 118.87,158.33 119.15,158.61 119.61,158.61 119.76,158.77 M1U4.1 M1U4.10 119.76,159.96 120.01,160.21 120.01,160.41 120.23,160.64 120.23,160.96 120.06,161.13 J302.7
DPC_TXP3: length 52.1
  TOP w0.102: 122.02,129.63 122.02,129.62 122.06,129.58 122.06,129.54 122.18,129.42 122.36,129.24 122.36,128.89 122.26,128.79 122.26,128.79 122.19,128.72 122.19,127.27 122.02,127.09 121.92,127.09 121.82,127.19 XU1.D20
  TOP w0.127: 122.02,129.63 122.02,129.86 122.3,130.14 123.11,130.14 123.24,130.27 123.24,130.57 123.11,130.7 122.69,130.7 122.4,130.98 122.4,131.43 122.69,131.71 122.86,131.71 123.01,131.87 123.01,132.12 122.71,132.43 122.35,132.43 v1(122.22,132.3) ; v1(121.23,156.3) 121.05,156.48 121.05,156.58 M1C109.2
  IN2 w0.127: v1(121.23,156.3) 121.23,155.49 119.72,153.98 118.6,153.98 117.11,152.48 117.11,150.89 116.59,150.38 116.59,149.6 115.29,148.3 115.29,147.28 115.36,147.21 115.89,146.68 115.89,146.28 115.8,146.19 115.8,145.91 115.92,145.78 116.2,145.78 116.33,145.91 116.66,145.91 117.55,145.02 117.55,144.9 117.55,144.74 117.63,144.66 118.19,144.66 118.46,144.38 118.46,143.88 118.18,143.6 117.68,143.6 117.55,143.47 117.55,143.2 117.68,143.07 118.18,143.07 118.46,142.78 118.46,142.3 118.18,142.01 117.52,142.01 117.4,141.89 117.4,141.61 117.52,141.48 118.84,141.48 119.12,141.2 119.12,140.67 118.82,140.36 116.88,140.36 116.75,140.24 116.75,138.71 116.88,138.59 117.26,138.59 117.37,138.7 117.37,139.55 117.67,139.84 119.03,139.84 119.31,140.12 119.68,140.12 120,139.8 120,136.96 120.6,136.36 120.6,136.09 120.95,135.73 121.25,135.73 122.81,134.17 122.81,132.83 122.27,132.3 v1(122.22,132.3)
DPC_TXP3_C: length 24.2
  TOP w0.127: M1C109.1 121.18,158 121.18,158.1 121.49,158.41 121.59,158.41 121.76,158.58 M1U4.5 M1U4.6 121.76,159.75 122.15,160.14 128.22,160.14 129.39,161.3 129.39,163.92 128.94,164.36 128.22,164.36 127.73,163.87 127.38,163.87 126.77,164.48 126.23,164.48 125.75,164 125.45,164 124.99,164.45 124.35,164.45 123.85,163.95 123.62,163.95 123.01,164.56 122.17,164.56 121.61,163.99 J302.10
DPD_AUXN: length 71.3
  TOP w0.127: J69.15 55.17,143.62 55.29,143.75 56.16,143.75 56.81,143.09 59.36,143.09 59.88,143.62 61.7,143.62 61.85,143.46 v5(61.85,143.25) ; XU1.C11 113.59,128.7 113.22,129.08 113.22,129.37 112.66,129.93 112.5,129.93 112.18,130.24 110.52,130.24 109.57,131.19 104.39,131.19 102.22,133.36 101.91,133.67 101.91,134.2 v1(101.47,134.64)
  IN1 w0.127: v5(61.85,143.25) 62.03,143.07 62.03,142.54 62.31,142.26 64.27,142.26 65.23,143.22 75.11,143.22 75.41,142.92 77.26,142.92 78.77,144.42 81.1,144.42 81.32,144.2 82.1,144.2 82.52,143.78 82.52,141.87 85.25,139.14 85.97,139.14 88.5,136.62 89.79,136.62 91.65,134.75 91.89,134.75 92.95,133.68 95.64,133.68 96.27,134.32 99.73,134.32 100.47,135.06 101.05,135.06 v1(101.47,134.64)
DPD_AUXP: length 71.3
  TOP w0.127: v1(102.17,134.61) 102.17,133.77 102.4,133.54 102.9,133.04 104.5,131.44 109.68,131.44 110.62,130.5 112.29,130.5 112.61,130.18 112.77,130.18 XU1.B11 ; v1(62.63,143.25) 62.63,143.25 62.01,143.87 59.78,143.87 59.25,143.35 56.92,143.35 56.26,144 55.29,144 55.17,144.12 J69.14
  IN1 w0.127: v1(62.63,143.25) 62.29,142.9 62.29,142.65 62.42,142.52 64.16,142.52 65.12,143.49 75.22,143.49 75.52,143.18 77.15,143.18 78.66,144.69 81.21,144.69 81.43,144.47 82.21,144.47 82.79,143.89 82.79,141.98 85.36,139.41 86.08,139.41 88.61,136.88 89.9,136.88 91.76,135.02 92,135.02 93.06,133.95 95.53,133.95 96.16,134.58 99.62,134.58 100.36,135.33 101.45,135.33 v1(102.17,134.61)
DPD_CTRL_CLK: length 72.1
  TOP w0.127: U1.AL9 47.16,100.36 v1(47.3,100.5) ; J69.17 55.89,142.62 v1(56.79,141.72)
  BOTTOM w0.127: v1(56.79,141.72) 57.05,141.47 60.17,141.47 61.52,140.11 61.52,138.32 64.03,135.81 64.03,135.8 v2(64.29,135.55) 64.29,134.38 64.97,133.69 64.97,132.4 67.11,130.27 67.11,124.36 65.09,122.34 63.1,122.34 57.74,116.98 56.11,116.98 55.63,116.5 54.05,116.5 53.62,116.07 47.73,116.07 44.7,113.04 44.7,111.66 44.28,111.24 42.92,111.24 41.88,110.2 41.88,107.85 42.48,107.26 42.95,107.26 43.21,107 43.21,106.64 43.14,106.58 R39.2 43.93,105.76 44.29,105.4 44.29,104.65 44.63,104.31 44.63,103.14 44.86,102.9 46.04,102.9 46.33,102.6 46.33,101.46 v1(47.3,100.5)
DPD_CTRL_DATA: length 69.1
  TOP w0.089: U1.AR3 44.93,103.38 44.93,103.79 45.01,103.87 45.01,104.63 44.82,104.82 44.82,105.56 44.69,105.69 44.69,106 44.68,106.01
  TOP w0.127: v1(56.16,141.72) 55.73,142.15 55.2,142.15 55.17,142.12 J69.18 ; R40.2 41.6,108.03 41.6,107.81 42.14,107.28 42.18,107.28 42.32,107.28 v1(42.77,106.82) 44.08,106.82 44.68,106.23 44.68,106.01
  BOTTOM w0.127: v1(42.77,106.82) 42.55,106.82 41.63,107.75 41.63,110.31 42.82,111.5 44.18,111.5 44.44,111.76 44.44,113.14 47.63,116.33 53.52,116.33 53.94,116.76 55.45,116.76 55.95,117.26 57.66,117.26 63,122.6 64.99,122.6 66.85,124.46 66.85,130.14 64.69,132.3 64.69,133.16 v2(64.13,133.72) 63.78,134.08 63.78,135.7 61.26,138.22 61.26,140.01 60.06,141.21 56.67,141.21 v1(56.16,141.72)
DPD_HPD: length 114.8
  TOP w0.102: U1.AP9 45.62,100.36 v1(45.85,100.14) ; v1(36.79,142.69) 37.42,142.69 37.98,143.25 40.66,143.25 41.63,142.28 46.55,142.28 47.18,142.92 50.03,142.92 50.35,142.6 52.05,142.6 53.03,141.61 53.03,140.96 53.87,140.12 J69.22
  IN1 w0.102: v1(51.41,80.15) 51.41,82.03 51.67,82.3 51.67,83.95 52.34,84.61 52.34,86.79 52.5,86.96 52.5,87.52 51.92,88.1 50.31,88.1 48.08,90.34 48.08,93.43 46.7,94.81 46.7,96.72 46.9,96.92 46.9,97.57 45.85,98.62 v1(45.85,100.14) 45.45,100.14 44.79,100.79 44.79,101.56 44.6,101.75 44.6,102.04 42.52,104.12 42.52,104.93 41.14,106.31 36.27,106.31 35.98,106.02 35.06,106.02 34.01,107.07 34.01,108.9 32.12,110.79 32.12,111.55 31.96,111.71 31.96,113.47 32.17,113.68 32.17,115.12 30.8,116.49 30.8,117.13 28.67,119.26 28.67,125.14 27.44,126.36 25.94,126.36 25.29,127.01 25.29,128.04 25.99,128.74 27.87,128.74 32.73,133.59 32.73,138.73 36.68,142.69 v1(36.79,142.69)
  BOTTOM w0.102: v2(38.5,148.5) 38.5,144 37.2,142.69 v1(36.79,142.69) ; SR7981.2 51.22,80.34 v1(51.41,80.15)
DPD_TXN0: length 78.7
  TOP w0.102: XU1.A14 116.34,129.86 116.23,129.76 116.07,129.76 115.97,129.86 115.97,130.75 116.19,130.97 116.19,131.5 116.03,131.66 116.03,131.73 116.01,131.74
  TOP w0.127: J69.11 55.17,145.62 55.29,145.5 55.99,145.5 56.86,144.63 60.51,144.63 60.68,144.8 60.68,144.99 v1(60.57,145.1) ; v1(107.57,135.58) 107.75,135.4 108.86,135.4 109.99,134.27 110.8,134.27 111.86,133.21 114.54,133.21 116.01,131.74
  IN1 w0.127: v1(107.57,135.58) 107.44,135.45 103.17,135.45 102.5,136.12 99.45,136.12 98.98,135.65 95.73,135.65 94.84,134.76 93.42,134.76 92.39,135.79 92.08,135.79 90.22,137.66 88.95,137.66 86.54,140.07 86.54,140.6 85.77,141.37 85.29,141.37 83.67,142.99 83.67,144.39 82.38,145.67 80.6,145.67 80.45,145.82 78.55,145.82 78.18,145.46 76.86,145.46 75.66,144.26 73.54,144.26 73.41,144.39 73.41,144.6 73.13,144.88 72.65,144.88 72.37,144.6 72.37,144.39 72.24,144.26 71.99,144.26 71.86,144.39 71.86,144.6 71.58,144.88 71.1,144.88 70.82,144.6 70.82,144.39 70.69,144.26 68.86,144.26 68.73,144.39 68.73,144.6 68.44,144.88 67.97,144.88 67.69,144.6 67.69,144.53 67.56,144.4 63.36,144.4 62.48,145.28 62.23,145.53 62.23,145.53 62.03,145.74 62.03,146.22 61.67,146.57 61.18,146.57 60.89,146.29 60.89,145.43 v1(60.57,145.1)
DPD_TXN1: length 76.4
  TOP w0.102: 116.57,132.27 116.89,131.95 116.89,129 116.99,128.89 117.15,128.89 117.25,129 XU1.B15
  TOP w0.127: J69.8 56.12,147.12 57.83,145.4 58.85,145.4 59.28,145.84 59.87,145.84 60.4,146.37 62.7,146.37 v1(62.8,146.47) ; 116.57,132.27 114.86,133.98 112.18,133.98 111.06,135.09 110.69,135.09 v1(110.44,135.34)
  IN1 w0.127: v1(62.8,146.47) 63.93,145.34 65.06,145.34 65.38,145.66 73,145.66 73.89,146.55 75.95,146.55 76.31,146.9 77.42,146.9 77.49,146.83 77.77,146.83 78.01,147.07 78.41,147.07 78.89,146.6 80.47,146.6 80.69,146.83 83.39,146.83 84.81,145.4 84.81,143.47 86.84,141.44 87.58,141.44 92.35,136.67 92.9,136.67 98.79,136.67 99.03,136.91 102.83,136.91 103.39,136.35 109.17,136.35 110.18,135.34 v1(110.44,135.34)
DPD_TXN2: length 78.4
  TOP w0.102: 117.63,132.44 117.96,132.11 117.96,130.71 117.8,130.54 117.8,130.11 117.9,130.01 118.08,130.01 118.17,130.1 XU1.A16
  TOP w0.127: v1(113.87,135.65) 113.99,135.52 114.55,135.52 117.63,132.44 ; v1(60.14,148.12) 59.74,147.72 59.74,147.48 58.86,146.6 58.06,146.6 57.95,146.71 57.45,147.21 57.45,148.1 56.93,148.62 J69.5
  IN1 w0.127: v1(113.87,135.65) 113.1,135.65 111.41,137.34 103.49,137.34 103.14,137.7 98.72,137.7 98.46,137.44 92.69,137.44 85.95,144.18 85.95,147.23 84.98,148.2 77.42,148.2 77.33,148.11 76.08,148.11 75.4,147.44 73.68,147.44 72.68,146.43 69.86,146.43 69.09,147.21 63.65,147.21 62.98,147.88 60.43,147.88 60.19,148.12 v1(60.14,148.12)
DPD_TXN3: length 88.2
  TOP w0.102: XU1.B17 119.08,129.02 119.02,128.97 118.84,128.97 118.71,129.09 118.71,132.45 118.65,132.51
  TOP w0.127: v1(55.98,150.05) 55.9,149.98 55.32,149.98 55.17,150.12 J69.2 ; 118.65,132.51 117.42,133.74 117.42,134.46 116.99,134.89 116.99,135.14 116.71,135.42 116.69,135.42 v1(116.51,135.6)
  IN1 w0.127: v1(116.51,135.6) 116.81,135.6 116.95,135.74 116.95,136.07 115.18,137.85 103.95,137.85 103.58,138.22 98.52,138.22 98.25,137.95 92.92,137.95 91.48,139.4 91.48,140.57 89.17,142.88 89.17,145.37 85.51,149.03 83.6,149.03 83.17,149.46 77.96,149.46 77.12,148.62 75.86,148.62 75.21,147.97 69.94,147.97 69.59,148.31 68.48,148.31 68.03,147.86 63.95,147.86 63.15,148.66 59.51,148.66 58.98,148.12 58.98,147 58.57,146.59 55.33,146.59 54.35,147.56 54.35,149.55 54.86,150.05 v1(55.98,150.05)
DPD_TXP0: length 78.7
  TOP w0.102: 115.83,131.57 115.99,131.41 115.99,131.05 115.77,130.83 115.77,129.78 115.99,129.56 116.13,129.56 XU1.B14
  TOP w0.127: 115.83,131.57 114.44,132.96 111.75,132.96 110.69,134.02 109.88,134.02 108.76,135.14 107.75,135.14 v1(107.54,134.94) ; J69.12 55.17,145.12 55.29,145.25 55.89,145.25 56.75,144.38 60.62,144.38 61.29,145.05 v1(61.47,145.05)
  IN1 w0.127: v1(107.54,134.94) 107.3,135.18 103.06,135.18 102.39,135.85 99.56,135.85 99.09,135.38 95.84,135.38 94.95,134.5 93.31,134.5 92.28,135.52 91.97,135.52 90.11,137.39 88.84,137.39 86.27,139.96 86.27,140.49 85.66,141.1 85.18,141.1 83.4,142.88 83.4,144.28 82.27,145.4 80.49,145.4 80.34,145.56 78.66,145.56 78.3,145.19 76.97,145.19 75.77,144 73.43,144 73.15,144.28 73.15,144.49 73.02,144.62 72.76,144.62 72.64,144.49 72.64,144.28 72.35,144 71.88,144 71.6,144.28 71.6,144.49 71.47,144.62 71.22,144.62 71.09,144.49 71.09,144.28 70.81,144 68.74,144 68.46,144.28 68.46,144.49 68.33,144.62 68.08,144.62 67.95,144.49 67.95,144.42 67.67,144.13 63.25,144.13 62.37,145.01 62.37,145.01 61.96,145.42 61.96,145.42 61.76,145.62 61.76,146.11 61.56,146.31 61.29,146.31 61.16,146.18 61.16,145.2 61.31,145.05 v1(61.47,145.05)
DPD_TXP1: length 76.4
  TOP w0.102: 116.54,131.94 116.57,131.94 116.68,131.83 116.68,128.91 116.9,128.69 117,128.69 XU1.C15
  TOP w0.127: v1(62.66,145.71) 62.66,145.81 62.36,146.12 60.51,146.12 59.97,145.58 59.39,145.58 58.96,145.15 57.73,145.15 56.01,146.87 55.46,146.87 55.22,146.62 J69.9 ; 116.54,131.94 114.76,133.72 112.07,133.72 110.95,134.84 110.6,134.84 110.55,134.79 110.53,134.79 v1(110.44,134.71)
  IN1 w0.127: v1(62.66,145.71) 62.85,145.9 62.99,145.9 63.82,145.07 65.17,145.07 65.49,145.39 73.11,145.39 74,146.28 76.06,146.28 76.42,146.63 77.31,146.63 77.38,146.56 77.88,146.56 78.12,146.81 78.3,146.81 78.78,146.33 80.58,146.33 80.8,146.56 83.28,146.56 84.54,145.29 84.54,143.36 86.73,141.18 87.47,141.18 92.24,136.4 92.9,136.4 98.9,136.4 99.14,136.64 102.72,136.64 103.28,136.08 109.06,136.08 v1(110.44,134.71)
DPD_TXP2: length 78.4
  TOP w0.102: 117.46,132.25 117.76,131.96 117.76,130.79 117.59,130.62 117.59,130.03 117.81,129.81 117.87,129.81 117.97,129.71 117.97,129.54 XU1.B16
  TOP w0.127: 117.46,132.25 117.45,132.26 114.45,135.27 114.17,135.27 v1(113.87,134.97) ; J69.6 55.17,148.12 55.41,148.37 56.83,148.37 57.2,148 57.2,147.1 57.84,146.46 57.96,146.34 58.96,146.34 59.91,147.29 59.98,147.36 v1(60.16,147.36)
  IN1 w0.127: v1(60.16,147.36) 60.41,147.61 62.87,147.61 63.54,146.94 68.98,146.94 69.75,146.17 72.79,146.17 73.79,147.17 75.51,147.17 76.19,147.84 77.44,147.84 77.53,147.93 84.87,147.93 85.69,147.12 85.69,144.07 92.58,137.18 98.58,137.18 98.83,137.43 103.02,137.43 103.38,137.07 111.3,137.07 112.99,135.38 113.45,135.38 v1(113.87,134.97)
