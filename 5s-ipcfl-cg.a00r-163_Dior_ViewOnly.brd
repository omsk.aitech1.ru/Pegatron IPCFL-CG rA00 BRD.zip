# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A9: length 48.2
  TOP w0.198: v1(128.86,54.66) 128.07,55.46 128.07,56.07 127.88,56.25 DIMM1.121 ; v1(129.97,94.15) XU1.AW27
  IN1 w0.102: v1(129.97,94.15) 129.05,93.23 129.05,92.62 128.65,92.21 128.65,91.22
  IN1 w0.211: v1(128.86,54.66) 128.4,55.12 128.4,56.33 130.24,58.17 130.24,59.62 130.65,60.03 130.65,63.5 130.99,63.84 130.99,68.19 130.69,68.49 130.17,68.49 129.93,68.73 129.93,69.43 130.14,69.65 130.72,69.65 130.99,69.92 130.99,75.38 130.42,75.94 130.42,83.71 128.65,85.49 128.65,91.22
  BOTTOM w0.198: v2(128.15,54.66) v1(128.86,54.66)
M_B_A10: length 56.5
  TOP w0.198: v1(120,51.06) 120,50.59 119.63,50.23 DIMM1.146 ; XU1.AP18 121.76,99.61 v1(121.76,99.67)
  IN1 w0.102: v1(121.76,99.67) 122.18,99.25 122.18,92.81 121.81,92.45 121.81,91.72
  IN1 w0.211: v1(120,51.06) 120,51.62 119.53,52.09 119.53,52.57 119.83,52.87 120.82,52.87 121.11,53.16 121.11,62.13 120.95,62.3 120.95,63.39 121.49,63.92 121.49,69.51 121.13,69.86 121.13,74.28 121.85,75 121.85,78.14 119.91,80.08 119.91,84.8 121.81,86.7 121.81,91.72
  BOTTOM w0.198: v2(119.38,51.83) 120,51.21 v1(120,51.06)
M_B_A11: length 52.8
  TOP w0.198: v1(130.9,95.96) XU1.AU27 ; v1(128.64,51.66) 128.13,51.16 DIMM1.120
  IN1 w0.102: 130.64,91.93 130.64,92.67 130.41,92.9 130.41,93.28 130.72,93.59 130.91,93.59 131.34,94.02 131.34,94.86 131.37,94.89 131.37,95.49 v1(130.9,95.96)
  IN1 w0.211: 130.64,91.93 130.64,86.22 133.37,83.5 133.37,66.17 133.12,65.92 133.12,60.57 133.49,60.2 133.49,58.65 130.63,55.79 130.63,54.84 130.42,54.63 130.42,53.33 128.75,51.66 v1(128.64,51.66)
  BOTTOM w0.198: v1(128.64,51.66) 128.95,51.66 v2(129.31,52.02)
M_B_A12: length 50.1
  TOP w0.198: v1(128.94,55.96) 128.6,55.96 128.38,56.17 DIMM1.119 ; v1(129.93,95.03) XU1.AV27
  IN1 w0.102: v1(129.93,95.03) 129.93,94.82 130.45,94.3 130.45,93.76 130.11,93.42 129.73,93.42 129.36,93.05 129.36,92.49 129.11,92.24 129.11,91.72
  IN1 w0.211: v1(128.94,55.96) 128.94,56.28 130.66,58 130.66,59.45 131.06,59.86 131.06,63.33 131.4,63.67 131.4,74.21 131.86,74.67 131.86,75.55 131.58,75.82 131.13,75.82 130.84,76.11 130.84,76.98 131.08,77.23 131.59,77.23 131.85,77.48 131.85,78.04 131.61,78.28 131.06,78.28 130.84,78.5 130.84,79.04 131.13,79.33 131.56,79.33 131.85,79.62 131.85,80.13 131.59,80.39 131.11,80.39 130.84,80.66 130.84,81.2 131.08,81.44 131.62,81.44 131.85,81.68 131.85,82.26 131.61,82.5 131.11,82.5 130.84,82.76 130.84,83.89 129.11,85.62 129.11,91.72
  BOTTOM w0.198: v1(128.94,55.96) v2(129.45,56.47)
M_B_A13: length 53.6
  TOP w0.198: v1(119.03,97.81) 119.03,97.84 XU1.AR15 ; v1(116.18,51.53) 116.63,51.07 DIMM1.158
  IN1 w0.102: v1(119.03,97.81) 119.56,97.27 119.56,92.96 118.83,92.23 118.83,91.72
  IN1 w0.211: 118.83,91.72 118.83,89.08 116.75,87 116.75,69.36 117.47,68.63 117.47,66.13 117.58,66.02 117.58,56.68 117.13,56.23 117.13,54.67 118,53.79 118,52.84 117.35,52.19 116.85,52.19 v1(116.18,51.53)
  BOTTOM w0.198: v1(116.18,51.53) v2(116.18,52.24)
M_B_A14: length 58.6
  TOP w0.198: DIMM1.151 118.38,55.67 118.58,55.48 118.58,54.43 v1(117.53,53.38) ; XU1.AL17 v1(120.84,101.49)
  IN1 w0.102: v1(120.84,101.49) 120.45,101.09 119.92,101.09 119.46,100.62 119.46,99.58 119.1,99.22 118.93,99.22 118.58,98.86 118.58,93.98 118.2,93.6 117.97,93.6 117.72,93.36 117.72,93.01 117.9,92.84 117.9,92.57 118.07,92.4 118.07,91.56
  IN1 w0.211: v1(117.53,53.38) 116.71,54.2 116.71,56.4 117.17,56.85 117.17,65.85 117.06,65.96 117.06,68.46 116.33,69.19 116.33,87.41 118.09,89.17 118.09,91.39 118.07,91.41 118.07,91.56
  BOTTOM w0.198: v1(120.84,101.49) 120.84,102.7 v2(120.33,103.21)
M_B_A15: length 55.4
  TOP w0.198: DIMM1.156 117.13,50.6 117.52,50.99 v1(117.63,50.99) ; XU1.AP16 119.91,98.72 v1(119.03,98.72)
  IN1 w0.102: v1(119.03,98.72) 119.77,97.99 119.77,92.66 119.25,92.15 119.25,91.72
  IN1 w0.211: 119.25,91.72 119.25,88.92 117.16,86.83 117.16,69.53 117.89,68.8 117.89,66.3 117.99,66.2 117.99,60.58 118.62,59.96 118.62,57.13 117.7,56.22 117.59,56.11 117.59,54.91 118.46,54.04 118.46,52.49 117.96,51.98 117.96,51.32 v1(117.63,50.99)
  BOTTOM w0.198: v1(117.63,50.99) 117.24,50.99 v2(116.91,50.66)
M_B_A16: length 57.7
  TOP w0.198: XU1.AN18 v1(122.63,99.66) ; v1(120.58,51.89) 118.85,51.89 118.13,51.17 DIMM1.152
  IN1 w0.102: 122.24,91.72 122.24,92.33 123.19,93.29 123.19,96.99 123.05,97.13 123.05,99.23 v1(122.63,99.66)
  IN1 w0.211: v1(120.58,51.89) 121.63,52.94 121.63,59.72 122.06,60.16 122.06,61.75 121.47,62.35 121.47,63.32 121.9,63.75 121.9,69.68 121.55,70.03 121.55,74.11 122.27,74.83 122.27,78.31 120.33,80.25 120.33,84.62 122.24,86.54 122.24,91.72
  BOTTOM w0.198: v2(120.85,52.56) 120.85,52.16 v1(120.58,51.89)
M_B_ACT#: length 52.1
  TOP w0.198: DIMM1.114 129.63,50.7 v1(130.17,51.23) ; v1(131.79,95.92) 131.79,95.98 XU1.AU28
  IN1 w0.102: 131.99,91.73 131.95,91.77 131.95,93.43 132.25,93.73 132.25,95.46 v1(131.79,95.92)
  IN1 w0.211: 131.99,91.73 131.99,86.63 134.62,84 134.62,63.72 134.36,63.46 134.36,61.13 134.76,60.73 134.76,57.26 133.1,55.6 133.1,54.1 130.24,51.23 v1(130.17,51.23)
  BOTTOM w0.198: v2(130.69,51.75) v1(130.17,51.23)
M_B_ALERT#: length 48.5
  TOP w0.102: v1(129.66,91.6) 128.99,92.27 128.99,93.3 XU1.AY25
  TOP w0.127: v1(128.66,50.37) 129.13,49.89 DIMM1.116
  IN1 w0.127: v1(128.66,50.37) 128.2,50.83 128.2,53.12 128.68,53.6 129.01,53.6 129.39,53.98 129.39,55.2 129.67,55.47 129.67,56.23 131.64,58.21 131.64,60.65 131.97,60.98 131.97,63.31 131.95,63.33 131.95,72.69 132.41,73.15 132.41,83.1 129.66,85.84 v1(129.66,91.6)
M_B_BA0: length 59.7
  TOP w0.198: v1(118.73,50.93) 118.63,50.84 DIMM1.150 ; XU1.AL18 121.76,101.48 v1(121.72,101.48)
  IN1 w0.102: 121.39,91.72 121.29,91.82 121.29,99.79 121.61,100.11 121.83,100.11 122.12,100.41 122.12,101.08 v1(121.72,101.48)
  IN1 w0.211: v1(118.73,50.93) 118.4,51.26 118.4,51.84 119.12,52.56 119.12,52.94 119.46,53.28 120.5,53.28 120.68,53.46 120.68,61.98 120.54,62.12 120.54,63.56 121.07,64.09 121.07,69.33 120.72,69.69 120.72,74.45 121.44,75.17 121.44,77.97 119.5,79.91 119.5,84.97 121.39,86.86 121.39,91.72
  BOTTOM w0.198: v1(121.72,101.48) 122.2,101.96 122.2,103.17 v2(122.19,103.18)
M_B_BA1: length 57.8
  TOP w0.198: XU1.AM18 121.77,100.58 v1(121.7,100.58) ; v1(119.71,54.07) 120.22,54.57 120.22,56.02 119.88,56.35 DIMM1.145
  IN1 w0.102: 120.33,91.78 120.19,91.92 120.19,99.67 120.63,100.11 121.23,100.11 v1(121.7,100.58)
  IN1 w0.211: v1(119.71,54.07) 119.43,54.07 118.97,54.52 118.97,56.03 119.65,56.7 119.65,60.39 119.47,60.57 119.47,63.95 119.88,64.36 119.88,65.34 119.44,65.78 119.44,67.03 120.04,67.64 120.04,68.91 118.69,70.26 118.69,72.18 119.69,73.17 119.69,74.88 120.41,75.6 120.41,76.78 120.02,77.17 119.17,77.17 118.42,77.92 118.42,86.55 119.26,87.39 119.96,87.39 120.33,87.76 120.33,91.78
  BOTTOM w0.198: v2(120.55,54.07) v1(119.71,54.07)
M_B_BG0: length 50.7
  TOP w0.198: v1(131.79,94.14) 131.79,94.16 XU1.AW28 ; v1(130.89,53.13) 130.72,53.3 129.49,54.53 129.49,56.15 129.38,56.25 DIMM1.115
  IN1 w0.102: 131.54,91.72 131.54,93.89 v1(131.79,94.14)
  IN1 w0.211: v1(130.89,53.13) 131.55,53.13 132.69,54.27 132.69,55.77 134.35,57.43 134.35,60.56 133.95,60.96 133.95,63.63 134.21,63.89 134.21,83.83 131.54,86.5 131.54,91.72
  BOTTOM w0.198: v2(131.71,53.39) 131.44,53.13 v1(130.89,53.13)
M_B_BG1: length 47.7
  TOP w0.198: DIMM1.113 129.88,55.44 v1(130.93,54.4) ; v1(130.83,93.11) 131.34,93.61 XU1.AY28
  IN1 w0.211: v1(130.93,54.4) 131.15,54.18 131.91,54.18 132.13,54.4 132.13,56.71 132.51,57.09 133.42,57.09 133.91,57.58 133.91,60.37 133.53,60.74 133.53,63.8 133.8,64.06 133.8,83.66 131.11,86.34 131.11,92.83 v1(130.83,93.11)
  BOTTOM w0.198: v2(130.21,54.4) v1(130.93,54.4)
M_B_CKE0: length 48.6
  TOP w0.198: v1(133.64,54.9) 133.12,55.41 131.44,55.41 130.88,55.97 DIMM1.109 ; v1(132.47,91.5) 132.06,91.5 131.89,91.67 131.89,93.33 XU1.AY29
  IN1 w0.211: v1(132.47,91.5) 132.66,91.31 132.66,86.69 135.14,84.21 135.14,68.64 135.6,68.17 135.6,62.21 135.31,61.92 135.31,57.08 134.41,56.18 134.41,55.69 135,55.11 135,54.79 134.55,54.35 134.19,54.35 v1(133.64,54.9)
  BOTTOM w0.198: v1(133.64,54.9) v2(134.35,54.9)
M_B_CKE1: length 51.7
  TOP w0.198: DIMM1.110 130.63,50.08 v1(130.96,50.41) ; v1(132.91,92.52) 132.91,93.25 132.74,93.42 132.74,95.03 XU1.AV29
  IN1 w0.211: v1(132.91,92.52) 133.08,92.35 133.08,86.86 135.55,84.39 135.55,68.81 136.01,68.35 136.01,61.94 135.72,61.65 135.72,56.49 135.41,56.18 135.41,54.39 131.99,50.97 131.62,50.97 131.06,50.41 v1(130.96,50.41)
  BOTTOM w0.198: v2(131.82,51.15) 131.8,51.15 131.06,50.41 v1(130.96,50.41)
M_B_CLK0: length 57.1
  TOP w0.173: v1(124.45,100.59) 124.04,101.01 XU1.AM20
  TOP w0.191: v1(123.32,54.27) 123.25,54.34 123.25,54.78 123.68,55.21 123.68,56.03 123.88,56.24 DIMM1.137
  IN1 w0.102: 123.96,91.34 123.96,91.35 123.92,91.39 123.92,91.44 123.78,91.58 123.77,91.58 123.62,91.73 123.62,91.93 123.71,92.01 124.14,92.01 124.36,92.23 124.36,92.57 124.01,92.92 124.01,97.32 123.86,97.47 123.86,97.77 124.07,97.97 124.07,98.41 123.86,98.61 123.86,98.91 124.08,99.13 124.08,99.46 123.86,99.68 123.86,100.82 123.97,100.93 124.35,100.93 124.45,100.82 v1(124.45,100.59)
  IN1 w0.185: v1(123.32,54.27) 123.25,54.34 123.25,54.67 123.71,55.13 123.71,56.67 123.45,56.93 123.45,57.86 123.98,58.38 123.98,60.09 124.47,60.58 124.47,61.35 123.98,61.84 123.98,62.56 124.1,62.68 124.1,64.68 124.46,65.04 124.46,68.72 123.96,69.22 123.96,80.34 123.58,80.72 122.26,80.72 122.07,80.91 122.07,81.36 122.28,81.57 123.58,81.57 123.96,81.95 123.96,91.34
M_B_CLK0#: length 57
  TOP w0.173: v1(124.48,101.39) 124.48,101.19 124.66,101.01 XU1.AM21
  TOP w0.191: DIMM1.139 123.38,55.33 v1(122.6,54.55)
  IN1 w0.102: v1(124.48,101.39) 124.21,101.13 123.88,101.13 123.66,100.91 123.66,99.59 123.87,99.38 123.87,99.21 123.66,99 123.66,98.53 123.86,98.32 123.86,98.06 123.66,97.85 123.66,97.39 123.81,97.24 123.81,92.83 124.16,92.49 124.16,92.32 124.06,92.22 123.62,92.22 123.42,92.01 123.42,91.65 123.67,91.39 123.67,91.34
  IN1 w0.185: v1(122.6,54.55) 122.96,54.91 123.08,54.91 123.42,55.25 123.42,56.55 123.17,56.81 123.17,57.98 123.69,58.5 123.69,60.21 124.18,60.7 124.18,61.23 123.69,61.72 123.69,62.68 123.81,62.8 123.81,64.8 124.17,65.16 124.17,68.6 123.67,69.1 123.67,80.22 123.46,80.43 122.14,80.43 121.78,80.79 121.78,81.48 122.16,81.85 123.46,81.85 123.67,82.07 123.67,91.34
M_B_CLK1: length 54.6
  TOP w0.173: XU1.AP22 125.85,99.18 v1(125.43,99.6)
  TOP w0.191: v1(123.9,50.43) 123.63,50.17 DIMM1.138
  IN1 w0.102: v1(125.43,99.6) 124.99,99.6 124.89,99.5 124.89,99.25 125.09,99.05 125.09,97.95 125.35,97.7 125.35,97.16 125.09,96.9 125.09,96.53 125.35,96.27 125.35,95.74 125.09,95.48 125.09,95.11 125.35,94.85 125.35,94.31 125.09,94.06 125.09,92.71 124.79,92.41 124.79,92.2 125.09,91.9 125.09,91.42 124.97,91.3
  IN1 w0.185: v1(123.9,50.43) 124.92,51.45 124.92,52 124.69,52.22 124.69,52.47 124.97,52.75 124.97,53.42 124.34,54.04 124.34,54.55 124.57,54.78 124.57,57.76 124.83,58.03 124.83,58.98 125.32,59.47 125.32,63.44 124.95,63.81 124.95,64.32 125.32,64.7 125.32,69.06 124.82,69.56 124.82,91.16 124.97,91.3 124.97,91.3
M_B_CLK1#: length 54.6
  TOP w0.173: v1(124.47,99.63) 124.92,99.18 XU1.AP21
  TOP w0.191: DIMM1.140 123.13,50.43 v1(123.9,51.2)
  IN1 w0.102: v1(124.47,99.63) 124.69,99.42 124.69,99.17 124.89,98.97 124.89,97.87 125.14,97.61 125.14,97.24 124.89,96.99 124.89,96.45 125.14,96.19 125.14,95.82 124.89,95.56 124.89,95.02 125.14,94.77 125.14,94.4 124.89,94.14 124.89,92.8 124.59,92.5 124.59,92.12 124.89,91.82 124.89,91.67 124.72,91.51
  IN1 w0.185: v1(123.9,51.2) 124.26,51.2 124.63,51.57 124.63,51.88 124.41,52.1 124.41,52.59 124.68,52.87 124.68,53.3 124.05,53.92 124.05,54.67 124.28,54.9 124.28,57.88 124.54,58.14 124.54,59.1 125.04,59.59 125.04,63.32 124.66,63.69 124.66,64.44 125.04,64.81 125.04,68.94 124.53,69.44 124.53,91.32 124.58,91.37 124.58,91.37 124.61,91.4 124.7,91.49 124.7,91.49 124.72,91.51
M_B_CS#0: length 56.1
  TOP w0.198: v1(119.49,55.2) 118.88,55.8 DIMM1.149 ; v1(120.75,99.64) 120.82,99.64 XU1.AP17
  IN1 w0.102: v1(120.75,99.64) 120.39,99.28 120.39,93.89 120.7,93.59 120.7,93.21 120.39,92.9 120.39,92.18 120.86,91.72
  IN1 w0.211: 120.86,91.72 120.86,87.06 120.38,86.58 120.06,86.58 119.81,86.83 119.43,86.83 119.07,86.48 119.07,86.08 119.3,85.85 119.3,85.5 118.98,85.18 118.98,79.7 119.38,79.3 119.38,78.88 118.97,78.48 118.97,78.1 119.33,77.74 119.73,77.74 120.08,78.09 120.59,78.09 120.92,77.76 120.92,75.39 120.2,74.67 120.2,72.15 119.88,71.83 119.49,71.83 119.21,71.55 119.21,70.47 119.45,70.23 119.88,70.23 120.2,69.9 120.2,69.47 120.56,69.12 120.56,64.31 119.99,63.74 119.99,60.78 120.16,60.6 120.16,55.46 119.9,55.2 v1(119.49,55.2)
  BOTTOM w0.198: v1(119.49,55.2) 119.77,55.2 v2(120.37,55.79)
M_B_CS#1: length 57.8
  TOP w0.198: v1(118.96,99.67) 119.03,99.67 XU1.AN15 ; v1(116.19,55.97) 116.56,55.97 116.88,56.3 DIMM1.157
  IN1 w0.102: 117.58,91.56 117.58,92.86 117.39,93.05 117.39,93.48 117.73,93.83 117.73,98.07 117.72,98.08 117.72,98.9 118.02,99.2 118.49,99.2 v1(118.96,99.67)
  IN1 w0.211: 117.58,91.56 117.58,89.38 115.82,87.62 115.82,86.98 115.53,86.69 114.95,86.69 114.68,86.43 114.68,85.92 114.96,85.64 115.54,85.64 115.82,85.37 115.82,84.85 115.56,84.58 114.95,84.58 114.68,84.32 114.68,83.78 114.93,83.53 115.54,83.53 115.82,83.26 115.82,82.74 115.56,82.48 114.92,82.48 114.68,82.24 114.68,81.7 114.96,81.42 115.57,81.42 115.82,81.17 115.82,80.63 115.56,80.37 114.97,80.37 114.68,80.08 114.68,79.59 114.96,79.31 115.54,79.31 115.82,79.04 115.82,78.55 115.53,78.26 114.92,78.26 114.68,78.02 114.68,77.46 114.93,77.21 115.54,77.21 115.82,76.93 115.82,68.97 116.55,68.25 116.55,65.74 116.65,65.64 116.65,61.98 116.15,61.48 116.15,60.62 116.65,60.12 116.65,57.13 116.19,56.67 v1(116.19,55.97)
  BOTTOM w0.198: v2(116.19,56.69) v1(116.19,55.97)
M_B_DQ0: length 77.3
  TOP w0.102: v1(137.25,108.82) 137.25,108.75 XU1.AD34
  TOP w0.127: DIMM1.8 v1(156.13,50.35)
  IN1 w0.102: v1(137.25,108.82) 137.64,108.43 138.51,108.43 138.8,108.72 139.47,108.72
  IN1 w0.127: 139.47,108.72 144.52,108.72 158.44,94.8 158.44,74.6 159.64,73.41 159.64,70.91 160.78,69.76 160.78,57.74 156.13,53.1 v1(156.13,50.35)
  BOTTOM w0.127: v2(156.13,49.57) v1(156.13,50.35)
M_B_DQ1: length 76.4
  TOP w0.102: v1(138.2,108.85) 138.2,108.78 XU1.AD35
  TOP w0.127: DIMM1.4 v1(157.13,50.37)
  IN1 w0.127: v1(157.13,50.37) 157.13,53.56 161.16,57.58 161.16,69.92 160.02,71.06 160.02,73.57 158.92,74.67 158.92,94.86 144.77,109 138.61,109 v1(138.2,108.85)
  BOTTOM w0.127: v1(157.13,50.37) v2(157.85,50.37)
M_B_DQ2: length 75.8
  TOP w0.102: XU1.AG35 138.12,105.96 v1(138.2,105.96)
  TOP w0.127: v1(157.9,58.69) 157.38,58.18 DIMM1.3
  IN1 w0.102: 142.15,105.86 141.57,105.86 141.27,105.55 138.9,105.55 138.49,105.96 v1(138.2,105.96)
  IN1 w0.127: v1(157.9,58.69) 158.36,59.15 158.36,62.91 157.33,63.94 157.02,64.25 157.02,66.14 158.16,67.29 158.16,69.18 157.38,69.97 157.38,72.55 155.62,74.31 155.62,74.81 155.76,74.95 156.25,74.95 156.39,75.09 156.39,75.45 156.25,75.59 155.76,75.59 155.62,75.73 155.62,76.08 155.76,76.22 156.25,76.22 156.39,76.36 156.39,76.72 156.25,76.86 155.76,76.86 155.62,77 155.62,77.35 155.76,77.49 156.25,77.49 156.39,77.63 156.39,77.99 156.25,78.13 155.76,78.13 155.62,78.27 155.62,78.62 155.76,78.76 156.25,78.76 156.39,78.9 156.39,79.26 156.25,79.4 155.76,79.4 155.62,79.54 155.62,80.06 155.76,80.2 156.25,80.2 156.39,80.34 156.39,80.7 156.25,80.84 155.98,80.84 155.8,81.02 155.8,82.27 155.67,82.4 155.03,82.4 154.86,82.56 154.86,82.87 155.03,83.03 155.31,83.03 155.45,83.17 155.45,83.53 155.31,83.67 155.03,83.67 154.86,83.83 154.86,84.14 155.03,84.3 155.31,84.3 155.45,84.44 155.45,90.31 155.59,90.45 156.22,90.45 156.36,90.59 156.36,90.94 156.22,91.08 155.59,91.08 155.45,91.22 155.45,91.58 155.59,91.72 156.22,91.72 156.36,91.86 156.36,92.21 156.22,92.35 155.59,92.35 155.45,92.49 155.45,92.85 155.59,92.99 156.22,92.99 156.36,93.13 156.36,93.48 156.22,93.62 155.59,93.62 155.45,93.76 155.45,94.88 145.49,104.84 143.17,104.84 142.15,105.86
  BOTTOM w0.127: v1(157.9,58.69) v2(158.67,58.69)
M_B_DQ3: length 75.3
  TOP w0.102: v1(138.2,104.28) 138.13,104.28 XU1.AH35
  TOP w0.127: DIMM1.7 v1(156.38,58.58)
  IN1 w0.102: 142.63,103.97 142.04,104.56 141.66,104.56 141.37,104.28 v1(138.2,104.28)
  IN1 w0.127: 142.63,103.97 144.74,103.97 152.9,95.82 152.9,81.58 152.41,81.09 152.41,80.9 152.55,80.76 153,80.76 153.14,80.62 153.14,80.26 153,80.12 152.55,80.12 152.41,79.98 152.41,79.63 152.55,79.49 154.35,79.49 154.48,79.36 154.48,79.04 154.29,78.85 152.55,78.85 152.41,78.71 152.41,78.36 152.55,78.22 154.35,78.22 154.48,78.09 154.48,77.77 154.29,77.58 152.55,77.58 152.41,77.44 152.41,77.09 152.55,76.95 154.35,76.95 154.48,76.82 154.48,76.5 154.29,76.31 152.55,76.31 152.41,76.17 152.41,75.86 152.59,75.68 154.1,75.68 154.38,75.4 154.38,75.06 154.24,74.92 153.55,74.92 153.41,74.78 153.41,74.43 153.55,74.29 154.24,74.29 154.38,74.15 154.38,70.02 155.4,69.01 155.4,64.2 155.8,63.79 155.8,61.57 155.65,61.42 155.65,59.38 155.92,59.1 155.94,59.1 156.19,58.85 156.19,58.84 156.38,58.64 v1(156.38,58.58)
  BOTTOM w0.127: v1(156.38,58.58) v2(156.38,57.85)
M_B_DQ4: length 76.3
  TOP w0.102: v1(138.2,107.02) 138.13,107.02 XU1.AE35
  TOP w0.127: DIMM1.20 v1(153.13,50.35)
  IN1 w0.127: v1(153.13,50.35) 153.7,50.91 153.7,52.75 154.91,53.96 155.92,53.96 160.02,58.06 160.02,69.45 158.88,70.59 158.88,73.09 157.68,74.28 157.68,94.48 144.71,107.45 138.63,107.45 v1(138.2,107.02)
  BOTTOM w0.127: v1(153.13,50.35) 153.64,49.84 v2(153.64,49.75)
M_B_DQ5: length 77.8
  TOP w0.102: XU1.AE34 137.23,107.81 v1(137.28,107.81)
  TOP w0.127: DIMM1.16 v1(154.13,50.34)
  IN1 w0.102: v1(137.28,107.81) 137.69,108.23 138.88,108.23 138.89,108.24
  IN1 w0.127: v1(154.13,50.34) 154.43,50.34 154.92,50.82 154.92,52.42 160.4,57.9 160.4,69.6 159.26,70.75 159.26,73.25 158.06,74.44 158.06,94.64 144.36,108.34 138.99,108.34 138.89,108.24
  BOTTOM w0.127: v2(155.07,51.02) 154.38,50.34 v1(154.13,50.34)
M_B_DQ6: length 76.8
  TOP w0.102: v1(137.3,105.16) 137.24,105.16 XU1.AG34
  TOP w0.127: DIMM1.21 152.88,56.07 v1(152.94,56.01)
  IN1 w0.102: 141.69,105.62 141.42,105.35 141.42,105.01 141.1,104.7 138.95,104.7 138.64,105.01 138.64,105.29 138.4,105.54 137.68,105.54 v1(137.3,105.16)
  IN1 w0.127: v1(152.94,56.01) 154.68,57.75 156.71,57.75 157.2,58.24 157.2,59.25 157.78,59.83 157.78,62.93 156.64,64.08 156.64,66.94 156.81,67.11 156.81,72.54 155.24,74.11 155.24,80.25 154.46,81.03 154.46,84.69 154.6,84.83 154.93,84.83 155.07,84.97 155.07,85.33 154.93,85.47 154.6,85.47 154.46,85.61 154.46,85.96 154.6,86.1 154.93,86.1 155.07,86.24 155.07,86.6 154.93,86.74 154.6,86.74 154.46,86.88 154.46,87.23 154.6,87.37 154.93,87.37 155.07,87.51 155.07,87.87 154.93,88.01 154.6,88.01 154.46,88.15 154.46,88.5 154.6,88.64 154.93,88.64 155.07,88.78 155.07,89.14 154.93,89.28 154.6,89.28 154.46,89.42 154.46,89.77 154.6,89.91 154.93,89.91 155.07,90.05 155.07,90.41 154.93,90.55 154.6,90.55 154.46,90.69 154.46,91.04 154.6,91.18 154.93,91.18 155.07,91.32 155.07,91.68 154.93,91.82 154.6,91.82 154.46,91.96 154.46,92.31 154.6,92.45 154.93,92.45 155.07,92.59 155.07,92.95 154.93,93.09 154.6,93.09 154.46,93.23 154.46,93.42 154.32,93.56 153.83,93.56 153.69,93.7 153.69,94.05 153.83,94.19 154.32,94.19 154.46,94.33 154.46,95.34 145.18,104.61 143.07,104.61 142.07,105.62 141.69,105.62
  BOTTOM w0.127: v2(152.94,56.72) v1(152.94,56.01)
M_B_DQ7: length 76.2
  TOP w0.102: v1(137.27,104.22) XU1.AH34
  TOP w0.127: v1(154.1,58.66) 153.88,58.45 DIMM1.17
  IN1 w0.102: v1(137.27,104.22) 137.75,104.7 138.37,104.7 138.57,104.49 141.23,104.49 141.5,104.76 142.12,104.76 142.63,104.26 143.39,104.26
  IN1 w0.127: v1(154.1,58.66) 154.33,58.44 154.33,58.38 154.58,58.13 156.55,58.13 156.82,58.4 156.82,59.05 156.64,59.23 156.64,59.96 156.67,59.98 156.67,63.49 155.78,64.38 155.78,69.16 155.29,69.65 155.29,73.52 154.86,73.95 154.86,80.09 153.41,81.54 153.41,82.01 153.57,82.16 153.94,82.16 154.07,82.3 154.07,82.66 153.94,82.8 153.42,82.8 153.28,82.94 153.28,83.29 153.42,83.43 153.94,83.43 154.07,83.57 154.07,83.93 153.94,84.07 153.42,84.07 153.28,84.21 153.28,84.56 153.42,84.7 153.94,84.7 154.07,84.84 154.07,85.2 153.94,85.34 153.42,85.34 153.28,85.48 153.28,85.83 153.42,85.97 153.94,85.97 154.07,86.11 154.07,86.47 153.94,86.61 153.42,86.61 153.28,86.75 153.28,87.1 153.42,87.24 153.94,87.24 154.07,87.38 154.07,87.74 153.94,87.88 153.42,87.88 153.28,88.02 153.28,88.37 153.42,88.51 153.94,88.51 154.07,88.65 154.07,89.01 153.94,89.15 153.42,89.15 153.28,89.29 153.28,89.64 153.42,89.78 153.94,89.78 154.07,89.92 154.07,90.28 153.94,90.42 153.42,90.42 153.28,90.56 153.28,90.91 153.42,91.05 153.94,91.05 154.07,91.19 154.07,91.55 153.94,91.69 153.42,91.69 153.28,91.83 153.28,92.18 153.42,92.32 153.94,92.32 154.07,92.46 154.07,92.82 153.94,92.96 153.42,92.96 153.28,93.1 153.28,95.97 145,104.26 143.39,104.26
  BOTTOM w0.127: v2(154.1,59.38) v1(154.1,58.66)
M_B_DQ8: length 72.3
  TOP w0.102: XU1.AK35 137.29,103.29 v1(137.29,103.3)
  TOP w0.127: v1(151.14,47.82) 151.14,49.08 DIMM1.28
  IN1 w0.102: 142.32,102.51 142.01,102.82 139.97,102.82 139.6,103.19 139.6,103.5 139.35,103.74 138.96,103.74 138.61,103.4 138.61,103.11 138.36,102.87 137.72,102.87 v1(137.29,103.3)
  IN1 w0.127: 142.32,102.51 144.61,102.51 151.98,95.14 151.98,81.96 151.46,81.43 151.46,75.05 153.46,73.05 153.46,69.64 154.46,68.65 154.46,63.85 154.89,63.41 154.89,61.95 154.16,61.22 154.16,59.87 153.29,59 153.29,57.65 152.13,56.49 152.13,53.67 151.14,52.69 v1(151.14,47.82)
  BOTTOM w0.127: v2(151.85,47.82) v1(151.14,47.82)
M_B_DQ9: length 71.8
  TOP w0.102: XU1.AL35 138.2,102.39 v1(138.26,102.39)
  TOP w0.127: DIMM1.29 150.88,57.28 v1(150.88,55.81)
  IN1 w0.102: 142.61,102.07 142.51,101.97 139.82,101.97 139.54,102.26 139.54,102.61 139.29,102.86 138.73,102.86 v1(138.26,102.39)
  IN1 w0.127: v1(150.88,55.81) 152.91,57.83 152.91,59.16 153.78,60.03 153.78,61.38 153.9,61.5 153.9,66.76 153.47,67.2 153.47,68.87 152.91,69.42 152.91,70.03 152.5,70.44 152.5,73.47 150.9,75.07 150.9,81.82 151.04,81.96 151.45,81.96 151.59,82.1 151.59,82.46 151.45,82.6 151.04,82.6 150.9,82.73 150.9,83.09 151.04,83.23 151.45,83.23 151.59,83.37 151.59,83.73 151.45,83.87 151.04,83.87 150.9,84 150.9,84.36 151.04,84.5 151.45,84.5 151.59,84.64 151.59,85 151.45,85.14 151.04,85.14 150.9,85.27 150.9,85.63 151.04,85.77 151.45,85.77 151.59,85.91 151.59,86.27 151.45,86.41 151.04,86.41 150.9,86.54 150.9,86.9 151.04,87.04 151.45,87.04 151.59,87.18 151.59,87.54 151.45,87.68 151.04,87.68 150.9,87.81 150.9,88.25 151.6,88.96 151.6,89.54 151.46,89.68 150.53,89.68 150.39,89.82 150.39,90.18 150.53,90.32 151.46,90.32 151.6,90.45 151.6,90.81 151.46,90.95 150.53,90.95 150.39,91.09 150.39,91.45 150.53,91.59 151.46,91.59 151.6,91.72 151.6,94.98 150.02,96.56 149.38,96.56 148.43,97.51 148.43,98.15 144.51,102.07 142.61,102.07
  BOTTOM w0.127: v2(151.56,55.51) 151.27,55.81 v1(150.88,55.81)
M_B_DQ10: length 75
  TOP w0.102: XU1.AK32 v1(134.55,103.28)
  TOP w0.127: DIMM1.37 148.88,56.14 v1(148.66,55.92)
  IN1 w0.102: v1(134.55,103.28) 134.99,102.84 134.99,102.11 135.77,101.33 137.65,101.33 138.31,100.67 138.62,100.67 138.82,100.47 139.85,100.47 140.51,99.81 140.51,99.41 140.79,99.14 142.13,99.14 142.47,98.8
  IN1 w0.127: v1(148.66,55.92) 149.12,55.46 149.43,55.46 149.66,55.69 149.66,56.64 150.32,57.3 150.32,59.76 150.67,60.11 150.67,60.37 150.32,60.72 150.32,61.1 150.48,61.26 150.8,61.26 151.22,60.84 151.42,60.84 151.67,61.09 151.67,61.29 151.05,61.91 151.05,62.11 151.26,62.31 151.26,63.62 150.62,64.26 150.62,64.58 150.76,64.72 151.53,64.72 151.69,64.88 151.69,65.23 151.56,65.35 150.76,65.35 150.62,65.49 150.62,65.85 150.76,65.99 151.24,65.99 151.38,66.13 151.38,66.48 151.24,66.62 150.76,66.62 150.62,66.76 150.62,67.12 150.76,67.26 151.24,67.26 151.38,67.4 151.38,67.75 151.24,67.89 150.76,67.89 150.62,68.03 150.62,68.39 150.76,68.53 151.09,68.53 151.23,68.67 151.23,69.02 151.09,69.16 150.32,69.16 149.58,69.91 149.58,70.15 149.72,70.29 150.2,70.29 150.34,70.43 150.34,70.78 150.2,70.92 149.72,70.92 149.58,71.06 149.58,71.42 149.72,71.56 150.55,71.56 150.69,71.7 150.69,72.05 150.55,72.19 149.72,72.19 149.58,72.33 149.58,72.69 149.72,72.83 150.14,72.83 150.28,72.97 150.28,73.32 150.14,73.46 149.72,73.46 149.72,73.46 149.31,73.46 149.1,73.68 149.1,81.59 148.14,82.55 148.14,83.92 148.65,84.43 148.65,88.78 145.13,92.3 145.13,96.79 143.74,98.19 142.9,98.19 142.47,98.62 142.47,98.8
  BOTTOM w0.127: v1(148.66,55.92) 148.41,56.17 v2(148.41,56.99)
M_B_DQ11: length 73.9
  TOP w0.102: v1(134.55,101.52) 134.59,101.52 XU1.AL32
  TOP w0.127: v1(147.63,50.34) 147.63,49.08 DIMM1.42
  IN1 w0.102: 142.54,96.87 142.09,97.32 140.9,97.32 140.48,97.75 140.48,98 140.2,98.27 139.93,98.27 139.47,98.73 139.47,99.8 139.21,100.06 138.65,100.06 138.45,100.26 138.14,100.26 137.48,100.92 135.15,100.92 v1(134.55,101.52)
  IN1 w0.127: v1(147.63,50.34) 148.23,49.73 148.23,49.27 148,49.03 146.4,49.03 145.62,48.25 145.11,48.25 144.75,48.61 144.75,49.2 145.22,49.66 146.93,49.66 147.1,49.83 147.1,51.57 146.71,51.96 146.71,53.96 147.67,54.93 147.67,56.08 149.55,57.96 149.55,62.04 149.86,62.34 149.86,68.55 148.82,69.59 148.82,71.96 148.31,72.46 148.31,81.3 147.38,82.23 147.38,88.98 144.32,92.04 144.32,95.98 143.43,96.87 142.54,96.87
  BOTTOM w0.127: v2(148.36,50.34) v1(147.63,50.34)
M_B_DQ12: length 73.2
  TOP w0.102: XU1.AK34 136.38,103.28 v1(136.38,103.31)
  TOP w0.127: v1(152.14,50.34) 152.14,49.08 DIMM1.24
  IN1 w0.102: v1(136.38,103.31) 136.82,103.74 138.5,103.74 138.83,104.07 141.3,104.07 141.66,103.71 142.02,103.71 142.3,103.43 142.3,103.35 142.7,102.96 145,102.96 145.78,102.18
  IN1 w0.127: v1(152.14,50.34) 152.46,50.34 152.63,50.51 152.63,51.38 152.46,51.54 151.69,51.54 151.52,51.71 151.52,52.05 151.65,52.18 152.57,52.18 152.71,52.32 152.71,52.64 152.5,52.85 152.5,53.51 152.71,53.72 152.71,54.34 152.51,54.54 152.51,56.33 153.67,57.49 153.67,58.84 154.54,59.71 154.54,61.06 155.27,61.79 155.27,63.57 154.84,64 154.84,68.81 153.84,69.8 153.84,73.2 151.88,75.17 151.88,81.31 152.37,81.8 152.37,95.59 145.78,102.18
  BOTTOM w0.127: v1(152.14,50.34) 152.14,49.8 v2(152.35,49.6)
M_B_DQ13: length 72.9
  TOP w0.102: v1(137.25,102.37) 137.25,102.35 XU1.AL34
  TOP w0.127: v1(152.11,58.57) 151.88,58.35 DIMM1.25
  IN1 w0.102: 141.15,101.09 139.85,101.09 139.59,101.35 139.59,101.51 139.28,101.81 138.06,101.81 137.94,101.94 137.68,101.94 v1(137.25,102.37)
  IN1 w0.127: v1(152.11,58.57) 152.53,58.99 152.53,60.06 153.16,60.7 153.16,61.77 153.44,62.05 153.44,62.7 152.98,63.16 152.98,63.47 153.52,64 153.52,64.63 153.06,65.09 153.06,65.55 153.36,65.85 153.36,66.31 153.06,66.62 153.06,68.73 152.53,69.27 152.53,69.87 152.12,70.28 152.12,73.31 150.52,74.91 150.52,84.06 150.38,84.2 150.1,84.2 149.96,84.34 149.96,84.69 150.1,84.83 150.38,84.83 150.52,84.97 150.52,85.33 150.38,85.47 150.1,85.47 149.96,85.61 149.96,85.96 150.1,86.1 150.38,86.1 150.52,86.24 150.52,86.6 150.38,86.74 150.1,86.74 149.96,86.88 149.96,87.23 150.1,87.37 150.38,87.37 150.52,87.51 150.52,87.87 150.38,88.01 150.1,88.01 149.96,88.15 149.96,88.5 150.1,88.64 150.38,88.64 150.52,88.78 150.52,89.07 146.48,93.11 146.48,96.1 146.62,96.24 148.25,96.24 148.39,96.38 148.39,96.73 148.25,96.87 147.98,96.87 147.84,97.01 147.84,98.17 147.7,98.31 147.35,98.31 147.21,98.17 147.21,97.01 147.07,96.87 146.62,96.87 146.48,97.01 146.48,97.93 146.3,98.11 146.3,98.33 146.82,98.84 146.82,99.04 146.57,99.29 146.37,99.29 145.73,98.65 145.53,98.65 145.28,98.9 145.28,99.1 145.92,99.74 145.92,99.94 145.67,100.19 145.47,100.19 144.83,99.55 144.63,99.55 144.38,99.8 144.38,100 145.02,100.64 145.02,100.84 144.77,101.09 144.57,101.09 143.93,100.45 143.73,100.45 143.1,101.09 141.15,101.09
  BOTTOM w0.127: v2(151.13,58.28) 151.81,58.28 v1(152.11,58.57)
M_B_DQ14: length 74.9
  TOP w0.102: XU1.AK31 134.08,102.83 v1(134.52,102.4)
  TOP w0.127: v1(148.63,47.82) DIMM1.38
  IN1 w0.102: v1(134.52,102.4) 134.52,102.18 135.56,101.13 137.56,101.13 138.22,100.47 138.54,100.47 138.74,100.26 139.3,100.26 139.68,99.89 139.68,99.46 139.99,99.15 140.24,99.15 140.5,98.89 140.5,98.54 140.76,98.28 142.07,98.28 142.54,97.81
  IN1 w0.127: 142.54,97.81 142.54,97.5 142.75,97.3 143.58,97.3 144.7,96.18 144.7,92.19 147.76,89.13 147.76,82.39 148.69,81.46 148.69,72.62 149.2,72.11 149.2,69.75 150.24,68.71 150.24,64.1 150.87,63.47 150.87,62.47 149.93,61.53 149.93,57.8 148.08,55.95 148.08,54.8 147.09,53.81 147.09,52.16 148.63,50.61 148.63,49.27 148.77,49.13 149.82,49.13 150.01,48.94 150.01,48.63 149.87,48.49 147.1,48.49 146.91,48.3 146.91,48 147.09,47.82 v1(148.63,47.82)
  BOTTOM w0.127: v2(149.35,47.82) v1(148.63,47.82)
M_B_DQ15: length 74.2
  TOP w0.102: v1(133.65,101.44) 133.65,101.49 XU1.AL31
  TOP w0.127: DIMM1.41 147.88,58.52 148.04,58.67 v1(148.04,58.68)
  IN1 w0.102: 142.59,96.38 140.86,96.38 140.52,96.73 140.52,96.93 140.16,97.29 140,97.29 139.61,97.68 139.61,98.05 139.16,98.5 139.16,98.87 138.55,99.49 138.55,99.81 138.3,100.06 134.89,100.06 134.82,100.12 134.41,100.12 134.13,100.41 134.13,101.27 133.96,101.44 v1(133.65,101.44)
  IN1 w0.127: v1(148.04,58.68) 148.28,58.43 148.28,58.16 148.08,57.95 148.08,57.67 148.25,57.5 148.56,57.5 149.15,58.09 149.15,60.04 148.94,60.24 148.28,60.24 148.14,60.38 148.14,60.83 148.31,61 148.97,61 149.17,61.2 149.17,61.81 148.89,62.09 148.89,64.95 149.36,65.41 149.36,68.52 148.23,69.64 148.23,70.33 148.44,70.53 148.44,71.8 147.93,72.31 147.93,81.13 146.16,82.91 146.16,83.29 146.3,83.43 146.82,83.43 146.96,83.57 146.96,83.92 146.82,84.06 146.3,84.06 146.16,84.2 146.16,84.56 146.3,84.7 146.82,84.7 146.96,84.84 146.96,85.19 146.82,85.33 146.3,85.33 146.16,85.47 146.16,85.83 146.3,85.97 146.82,85.97 146.96,86.11 146.96,86.46 146.82,86.6 146.3,86.6 146.16,86.74 146.16,87.1 146.3,87.24 146.82,87.24 146.96,87.38 146.96,87.73 146.82,87.87 146.3,87.87 146.16,88.01 146.16,88.47 145.88,88.74 145.88,88.94 146.26,89.32 146.26,89.52 146.01,89.77 145.81,89.77 145.43,89.39 145.23,89.39 144.98,89.64 144.98,89.84 145.36,90.22 145.36,90.42 145.11,90.67 144.91,90.67 144.53,90.29 144.34,90.29 144.09,90.54 144.09,90.74 144.46,91.12 144.46,91.31 144.21,91.57 144.01,91.57 143.64,91.19 143.44,91.19 143.03,91.6 143.03,91.94 143.17,92.08 143.7,92.08 143.86,92.24 143.86,92.59 143.74,92.71 143.17,92.71 143.03,92.85 143.03,93.21 143.17,93.35 143.7,93.35 143.86,93.51 143.86,94.05 143.72,94.19 143.11,94.19 142.98,94.33 142.98,94.68 143.11,94.82 143.72,94.82 143.86,94.96 143.86,95.87 143.36,96.38 142.6,96.38 142.59,96.38
  BOTTOM w0.127: v1(148.04,58.68) 147.87,58.84 v2(147.34,58.84)
M_B_DQ16: length 56.7
  TOP w0.102: v1(138.2,98.66) 138.2,98.71 XU1.AP35
  TOP w0.127: DIMM1.46 146.63,50.34 v1(146.63,50.35)
  IN1 w0.102: v1(138.2,98.66) 138.55,98.31 138.55,97.26 138.65,97.17 138.65,96.71 138.98,96.38 139.25,96.38 139.54,96.09 139.54,95.87 140.09,95.31 140.93,95.31 142.17,94.07 142.17,92.57
  IN1 w0.127: v1(146.63,50.35) 146.18,50.8 146.18,54.26 146.67,54.75 146.67,57.8 147.23,58.35 147.23,61.4 147.98,62.16 147.98,65.31 148.07,65.4 148.07,68.51 147.07,69.51 147.07,71.9 146.86,72.11 146.86,80.06 145.21,81.71 145.21,87.98 142.17,91.02 142.17,92.57
  BOTTOM w0.127: v2(146.63,49.62) v1(146.63,50.35)
M_B_DQ17: length 58.1
  TOP w0.102: XU1.AN35 138.13,99.7 v1(138.13,99.64)
  TOP w0.127: DIMM1.45 146.88,56.05 v1(147.14,55.79)
  IN1 w0.102: 141.03,95.53 140.76,95.53 140.44,95.85 140.44,96.15 140.19,96.4 139.86,96.4 139.54,96.73 139.54,97.01 139.23,97.32 139.08,97.32 138.76,97.64 138.76,98.71 138.13,99.34 v1(138.13,99.64)
  IN1 w0.127: v1(147.14,55.79) 147.14,56.62 147.28,56.76 147.53,56.76 147.67,56.9 147.67,57.26 147.53,57.4 147.28,57.4 147.14,57.54 147.14,57.73 147.61,58.2 147.61,61.25 148.36,62 148.36,65.16 148.45,65.25 148.45,65.92 148.82,66.28 148.82,66.66 148.45,67.03 148.45,68.67 147.45,69.67 147.45,72.07 147.24,72.28 147.24,80.58 147.01,80.81 146.65,80.81 146.43,81.04 146.43,81.23 146.65,81.46 146.65,81.66 146.4,81.91 146.2,81.91 145.98,81.68 145.78,81.68 145.59,81.87 145.59,88.28 142.55,91.32 142.55,94.01 141.96,94.6 141.96,95.02 142.18,95.24 143.23,95.24 143.36,95.37 143.36,95.75 143.18,95.92 141.97,95.92 141.4,95.36 141.21,95.36 141.03,95.53
  BOTTOM w0.127: v2(147.85,55.29) 147.65,55.29 v1(147.14,55.79)
M_B_DQ18: length 60
  TOP w0.102: v1(134.56,99.65) XU1.AN32
  TOP w0.127: v1(142.63,47.81) DIMM1.62
  IN1 w0.102: v1(134.56,99.65) 134.97,99.24 134.97,98.6 135.31,98.26 135.58,98.26 135.86,97.98 135.86,97.44 136.08,97.22 136.08,95.59 137.22,94.45 137.22,93.65 138.54,92.34 138.86,92.34
  IN1 w0.127: v1(142.63,47.81) 143.19,48.36 143.19,56.89 144.19,57.9 144.19,61.88 144.45,62.14 144.45,64.16 144.88,64.59 144.88,65.26 143.63,66.51 143.63,69.57 142.75,70.46 142.75,86.99 139.6,90.14 139.6,91.6 138.86,92.34
  BOTTOM w0.127: v2(141.92,47.81) v1(142.63,47.81)
M_B_DQ19: length 59.7
  TOP w0.102: v1(135.45,99.63) XU1.AP32
  TOP w0.127: v1(143.63,50.34) DIMM1.58
  IN1 w0.102: v1(135.45,99.63) 135.88,99.2 135.88,98.36 136.06,98.17 136.06,97.52 136.28,97.3 136.28,95.79 138.83,93.24 138.83,92.91
  IN1 w0.127: v1(143.63,50.34) 143.63,49.58 143.84,49.37 144.17,49.37 144.37,49.57 144.37,51.15 143.58,51.93 143.58,52.67 143.94,53.03 143.94,53.61 143.58,53.96 143.58,56.71 144.58,57.7 144.58,61.73 144.83,61.98 144.83,64 145.26,64.43 145.26,67.94 144.02,69.18 144.02,71.64 143.15,72.51 143.15,87.12 139.98,90.3 139.98,91.6 139.61,91.97 139.61,92.13 138.83,92.91
  BOTTOM w0.127: v2(142.9,50.34) v1(143.63,50.34)
M_B_DQ20: length 59.1
  TOP w0.102: v1(137.28,99.57) 137.28,99.64 XU1.AN34
  TOP w0.127: v1(145.63,50.34) 145.63,50.33 DIMM1.50
  IN1 w0.102: v1(137.28,99.57) 137.77,99.07 137.77,98.14 137.72,98.09 137.72,97.21 137.76,97.17 137.76,96.74 138.12,96.38 138.39,96.38 138.65,96.12 138.65,95.8 138.95,95.49 139.26,95.49 139.79,94.96 141,94.96 141.79,94.16 141.79,92.92
  IN1 w0.127: 141.79,92.92 141.79,90.86 144.83,87.82 144.83,81.55 146.48,79.9 146.48,71.95 146.69,71.75 146.69,69.35 147.69,68.35 147.69,65.56 147.04,64.91 147.04,61.8 146.84,61.6 146.84,58.51 146.29,57.95 146.29,54.91 145.01,53.63 145.01,50.96 v1(145.63,50.34)
  BOTTOM w0.127: v2(144.86,51.1) v1(145.63,50.34)
M_B_DQ21: length 58.2
  TOP w0.102: v1(137.35,98.72) 137.28,98.72 XU1.AP34
  TOP w0.127: DIMM1.49 145.88,55.63 v1(145.74,55.49)
  IN1 w0.102: v1(137.35,98.72) 137.35,98.47 136.86,97.97 136.86,97.61 136.89,97.57 136.89,96.72 137.19,96.43 137.49,96.43 137.78,96.14 137.78,95.8 138.07,95.51 138.39,95.51 138.65,95.25 138.65,94.91 138.98,94.57 139.6,94.57 139.9,94.27 140.24,94.27 140.54,94.57 141.09,94.57 141.4,94.26 141.4,91.98
  IN1 w0.127: v1(145.74,55.49) 145.74,57.02 145.9,57.18 145.9,58.11 146.46,58.67 146.46,59.73 146.32,59.87 146.01,59.87 145.87,60.01 145.87,60.37 146.01,60.51 146.18,60.51 146.3,60.63 146.3,61.6 146.66,61.95 146.66,65.42 146.8,65.56 147.15,65.56 147.29,65.7 147.29,66.06 147.15,66.2 146.8,66.2 146.66,66.34 146.66,66.72 146.84,66.89 147.14,66.89 147.31,67.06 147.31,68.19 146.22,69.28 145.87,69.28 145.62,69.54 145.62,69.96 145.76,70.1 146.03,70.1 146.31,70.38 146.31,71.59 146.12,71.77 145.58,71.77 145.32,72.03 145.32,72.33 145.54,72.56 145.95,72.56 146.1,72.71 146.1,79.75 145.67,80.18 144.68,80.18 144.45,80.41 144.45,87.66 141.4,90.71 141.4,91.98
  BOTTOM w0.127: v2(145.74,56.2) v1(145.74,55.49)
M_B_DQ22: length 60.8
  TOP w0.102: XU1.AN31 133.69,99.7 v1(133.69,99.64)
  TOP w0.127: DIMM1.63 142.38,55.97 v1(142.38,55.97)
  IN1 w0.102: 137.82,92.3 136.82,93.3 136.82,94.22 135.68,95.36 135.68,96.06 134.1,97.64 134.1,99.23 v1(133.69,99.64)
  IN1 w0.127: 137.82,92.3 138.78,91.34 138.78,89.77 141.4,87.16 141.4,72.13 141.98,71.54 141.98,70.09 142.81,69.27 142.81,63.53 143.07,63.26 143.07,62.14 142.72,61.79 142.72,58.5 141.74,57.51 141.74,55.28 142.06,54.96 142.06,51.53 142.26,51.32 142.58,51.32 142.81,51.55 142.81,55.55 v1(142.38,55.97)
  BOTTOM w0.127: v2(143.09,55.97) v1(142.38,55.97)
M_B_DQ23: length 60.1
  TOP w0.102: XU1.AP31 134.47,98.79 v1(134.54,98.79)
  TOP w0.127: DIMM1.59 143.39,57.28 v1(143.39,58.54)
  IN1 w0.102: v1(134.54,98.79) 134.54,98.5 134.99,98.04 134.99,97.66 135.26,97.39 135.53,97.39 135.88,97.05 135.88,95.49 137.02,94.35 137.02,93.57 139.17,91.42
  IN1 w0.127: 139.17,91.42 139.17,90.03 141.78,87.42 141.78,85.17 141.92,85.03 142.23,85.03 142.37,84.89 142.37,84.54 142.23,84.4 141.92,84.4 141.78,84.26 141.78,83.9 141.92,83.76 142.23,83.76 142.37,83.62 142.37,83.27 142.23,83.13 141.92,83.13 141.78,82.99 141.78,82.63 141.92,82.49 142.23,82.49 142.37,82.35 142.37,82 142.23,81.86 141.92,81.86 141.78,81.72 141.78,81.36 141.92,81.22 142.23,81.22 142.37,81.08 142.37,80.73 142.23,80.59 141.92,80.59 141.78,80.45 141.78,80.09 141.92,79.95 142.23,79.95 142.37,79.81 142.37,79.46 142.23,79.32 141.92,79.32 141.78,79.18 141.78,78.82 141.92,78.68 142.23,78.68 142.37,78.54 142.37,78.19 142.23,78.05 141.92,78.05 141.78,77.91 141.78,77.55 141.92,77.41 142.23,77.41 142.37,77.27 142.37,76.92 142.23,76.78 141.92,76.78 141.78,76.64 141.78,76.28 141.92,76.14 142.23,76.14 142.37,76 142.37,75.65 142.23,75.51 141.92,75.51 141.78,75.37 141.78,75.01 141.92,74.87 142.23,74.87 142.37,74.73 142.37,74.38 142.23,74.24 141.92,74.24 141.78,74.1 141.78,73.74 141.92,73.6 142.23,73.6 142.37,73.46 142.37,73.11 142.23,72.97 141.92,72.97 141.78,72.83 141.78,72.28 142.37,71.7 142.37,70.3 143.23,69.43 143.23,65.39 143.37,65.25 144.36,65.25 144.5,65.11 144.5,64.76 144.35,64.61 143.33,64.61 143.19,64.47 143.19,64.12 143.34,63.97 143.89,63.97 144.07,63.79 144.07,62.4 143.81,62.14 143.81,61.94 143.67,61.8 143.32,61.8 143.18,61.66 143.18,61.31 143.32,61.17 143.67,61.17 143.81,61.03 143.81,60.67 143.67,60.53 143.32,60.53 143.18,60.39 143.18,60.04 143.32,59.9 143.67,59.9 143.81,59.76 143.81,58.96 v1(143.39,58.54)
  BOTTOM w0.127: v2(143.39,57.79) v1(143.39,58.54)
M_B_DQ24: length 60.3
  TOP w0.102: v1(131.82,101.49) 131.82,101.49 XU1.AL29
  TOP w0.127: v1(141.41,58.55) 141.38,58.53 DIMM1.67
  IN1 w0.102: 136.85,92.48 135.07,94.27 135.07,95.94 133.47,97.54 133.47,98.92 133.07,99.32 133.07,99.8 132.73,100.13 132.55,100.13 132.27,100.41 132.27,101.04 v1(131.82,101.49)
  IN1 w0.127: 136.85,92.48 137.87,91.46 137.87,89.39 139.93,87.34 139.93,85.54 140.07,85.4 140.35,85.4 140.49,85.26 140.49,84.9 140.35,84.76 140.07,84.76 139.93,84.62 139.93,84.27 140.07,84.13 140.35,84.13 140.49,83.99 140.49,83.63 140.35,83.49 140.07,83.49 139.93,83.35 139.93,83 140.07,82.86 140.35,82.86 140.49,82.72 140.49,82.36 140.35,82.22 140.07,82.22 139.93,82.08 139.93,81.73 140.07,81.59 140.35,81.59 140.49,81.45 140.49,81.09 140.35,80.95 140.07,80.95 139.93,80.81 139.93,80.46 140.07,80.32 140.35,80.32 140.49,80.18 140.49,79.82 140.35,79.68 140.07,79.68 139.93,79.54 139.93,79.19 140.07,79.05 140.35,79.05 140.49,78.91 140.49,78.55 140.35,78.41 140.07,78.41 139.93,78.27 139.93,77.92 140.07,77.78 140.35,77.78 140.49,77.64 140.49,77.28 140.35,77.14 140.07,77.14 139.93,77 139.93,76.65 140.07,76.51 140.35,76.51 140.49,76.37 140.49,76.01 140.35,75.87 140.07,75.87 139.93,75.73 139.93,75.38 140.07,75.24 140.35,75.24 140.49,75.1 140.49,74.74 140.35,74.6 140.07,74.6 139.93,74.46 139.93,74.11 140.07,73.97 140.35,73.97 140.49,73.83 140.49,73.47 140.35,73.33 140.07,73.33 139.93,73.19 139.93,72.84 140.07,72.7 140.35,72.7 140.49,72.56 140.49,72.2 140.35,72.06 140.07,72.06 139.93,71.92 139.93,70.85 141.4,69.38 141.4,67.02 141.8,66.62 141.8,65.92 141.4,65.52 141.4,65.01 141.8,64.61 141.8,64.12 141.4,63.72 141.4,63.21 141.8,62.81 141.8,62.41 141.2,61.81 141.2,61.32 141.34,61.18 141.64,61.18 141.78,61.04 141.78,60.68 141.64,60.54 141.34,60.54 141.2,60.4 141.2,58.76 v1(141.41,58.55)
  BOTTOM w0.127: v2(141.41,57.84) v1(141.41,58.55)
M_B_DQ25: length 59.8
  TOP w0.102: v1(132.71,101.49) 132.71,101.46 XU1.AM29
  TOP w0.127: v1(141.64,50.34) 141.64,49.08 DIMM1.66
  IN1 w0.102: v1(132.71,101.49) 133.27,100.92 133.27,99.47 133.69,99.05 133.69,97.67 135.27,96.09 135.27,94.37 138.25,91.39 138.25,91.28
  IN1 w0.127: 138.25,91.28 138.25,89.55 140.87,86.94 140.87,70.45 141.78,69.54 141.78,67.36 142.18,66.96 142.18,58.71 141.2,57.73 141.2,54.16 141.02,53.98 141.02,53.47 141.16,53.33 141.39,53.33 141.53,53.19 141.53,52.83 141.39,52.69 141.16,52.69 141.02,52.55 141.02,52.2 141.16,52.06 141.39,52.06 141.53,51.92 141.53,51.56 141.39,51.42 141.16,51.42 141.02,51.28 141.02,50.96 v1(141.64,50.34)
  BOTTOM w0.127: v1(141.64,50.34) v2(140.93,50.34)
M_B_DQ26: length 57.6
  TOP w0.102: v1(132.78,98.72) 132.71,98.72 XU1.AP29
  TOP w0.127: DIMM1.71 v1(140.38,56.02)
  IN1 w0.102: v1(132.78,98.72) 133.05,98.46 133.05,97.15 134.66,95.54 134.66,93.99 136.04,92.61
  IN1 w0.127: v1(140.38,56.02) 140.38,61.94 140.06,62.27 140.06,64.54 140.2,64.68 140.5,64.68 140.64,64.82 140.64,65.18 140.5,65.32 140.2,65.32 140.06,65.46 140.06,65.81 140.2,65.95 140.5,65.95 140.64,66.09 140.64,66.45 140.5,66.59 140.2,66.59 140.06,66.73 140.06,68.27 140.21,68.42 140.54,68.42 140.64,68.52 140.64,69.06 140.37,69.33 140.21,69.33 139.93,69.05 139.68,69.05 139.47,69.27 139.47,69.51 139.7,69.74 139.7,70 139.17,70.54 139.17,72.55 139.03,72.69 138.8,72.69 138.66,72.83 138.66,73.19 138.8,73.33 139.03,73.33 139.17,73.47 139.17,73.82 139.03,73.96 138.8,73.96 138.66,74.1 138.66,74.46 138.8,74.6 139.03,74.6 139.17,74.74 139.17,75.09 139.03,75.23 138.8,75.23 138.66,75.37 138.66,75.73 138.8,75.87 139.03,75.87 139.17,76.01 139.17,76.36 139.03,76.5 138.8,76.5 138.66,76.64 138.66,77 138.8,77.14 139.03,77.14 139.17,77.28 139.17,85.84 138.78,86.22 138.78,86.48 139.17,86.86 139.17,87.02 138.83,87.35 138.63,87.35 138.24,86.96 138.05,86.96 137.79,87.21 137.79,87.41 138.19,87.8 138.19,88 137.93,88.25 137.74,88.25 137.34,87.86 137.15,87.86 136.9,88.11 136.9,88.31 137.29,88.7 137.29,88.9 137.11,89.08 137.11,91.52 136.04,92.59 136.04,92.61
  BOTTOM w0.127: v2(141.1,56.02) v1(140.38,56.02)
M_B_DQ27: length 56.9
  TOP w0.102: XU1.AR29 131.85,97.86 v1(131.78,97.86)
  TOP w0.127: DIMM1.79 v1(138.38,56.02)
  IN1 w0.102: 134.8,91.72 134.8,92.89 134.05,93.64 134.05,95.19 132.43,96.81 132.43,97.21 v1(131.78,97.86)
  IN1 w0.127: 134.8,91.72 134.8,90.61 134.93,90.47 135.24,90.47 135.38,90.33 135.38,89.98 135.24,89.84 134.93,89.84 134.8,89.7 134.8,89.34 134.93,89.2 135.39,89.2 135.53,89.06 135.53,88.71 135.39,88.57 134.93,88.57 134.8,88.43 134.8,88.09 134.95,87.93 135.2,87.93 137.76,85.37 137.76,78.42 137.27,77.94 137.27,72.11 137.87,71.52 137.87,69.04 138.76,68.14 138.76,66.35 138.62,66.21 137.88,66.21 137.74,66.07 137.74,65.71 137.88,65.57 138.62,65.57 138.76,65.43 138.76,65.08 138.62,64.94 137.88,64.94 137.74,64.8 137.74,64.44 137.88,64.3 138.62,64.3 138.76,64.16 138.76,62.17 138.31,61.72 138.31,61.25 138.45,61.11 138.92,61.11 139.06,60.97 139.06,60.61 138.92,60.47 138.45,60.47 138.31,60.33 138.31,58.3 138.45,58.16 138.93,58.16 139.07,58.02 139.07,57.66 138.93,57.52 138.51,57.52 138.38,57.39 138.38,56.89 138.54,56.73 138.91,56.73 139.07,56.57 139.07,56.21 138.89,56.02 v1(138.38,56.02)
  BOTTOM w0.127: v2(139.14,56.02) v1(138.38,56.02)
M_B_DQ28: length 59.9
  TOP w0.102: v1(130.86,100.55) 130.88,100.55 XU1.AM28
  TOP w0.127: v1(138.13,47.82) 138.13,47.83 DIMM1.80
  IN1 w0.102: v1(130.86,100.55) 130.53,100.21 130.53,99.45 130.81,99.17 130.96,99.17 131.31,98.82 131.31,97.74 131.61,97.44 131.9,97.44 132.22,97.12 132.22,96.68 133.19,95.72 133.19,93.98 134.41,92.75 134.41,92.02
  IN1 w0.127: v1(138.13,47.82) 137.56,48.39 137.56,49.98 137.93,50.34 137.93,61.86 137.35,62.44 137.35,68.9 136.89,69.36 136.89,78.09 137.38,78.58 137.38,85.21 135.04,87.55 134.61,87.55 134.41,87.75 134.41,92.02
  BOTTOM w0.127: v1(138.13,47.82) v2(137.42,47.82)
M_B_DQ29: length 61
  TOP w0.102: v1(130.88,101.49) 130.9,101.49 XU1.AL28
  TOP w0.127: v1(140.63,47.82) DIMM1.70
  IN1 w0.102: v1(130.88,101.49) 131.34,101.03 131.34,100.42 131.67,100.08 131.87,100.08 132.17,99.78 132.17,99.51 132.51,99.17 132.93,99.17 133.26,98.83 133.26,97.27 134.86,95.67 134.86,94.09 136.35,92.61
  IN1 w0.127: v1(140.63,47.82) 140.63,54.14 140.82,54.32 140.82,61.97 141.02,62.17 141.02,69.22 139.55,70.69 139.55,87.18 137.49,89.24 137.49,91.47 136.35,92.61
  BOTTOM w0.127: v2(139.92,47.82) v1(140.63,47.82)
M_B_DQ30: length 57.1
  TOP w0.102: XU1.AR28 130.9,97.83 v1(130.88,97.83)
  TOP w0.127: DIMM1.83 137.39,57.28 v1(137.39,55.79)
  IN1 w0.102: 134.03,92.73 132.93,93.83 132.93,95.66 132.05,96.54 131.62,96.54 131.31,96.85 131.31,97.4 v1(130.88,97.83)
  IN1 w0.127: 134.03,92.73 134.03,87.26 134.3,86.99 134.5,86.99 134.68,87.17 134.88,87.17 135.13,86.92 135.13,86.72 134.95,86.54 134.95,86.34 135.2,86.09 135.4,86.09 135.58,86.27 135.78,86.27 136.03,86.02 136.03,85.82 135.85,85.64 135.85,85.44 136.01,85.28 136.55,85.28 136.7,85.13 136.7,84.87 136.51,84.67 136.51,84.45 136.65,84.31 136.86,84.31 137,84.17 137,83.82 136.86,83.68 136.65,83.68 136.51,83.54 136.51,83.18 136.65,83.04 136.86,83.04 137,82.9 137,82.55 136.86,82.41 136.65,82.41 136.51,82.27 136.51,81.91 136.65,81.77 136.86,81.77 137,81.63 137,81.28 136.86,81.14 136.65,81.14 136.51,81 136.51,80.64 136.65,80.5 136.86,80.5 137,80.36 137,80.01 136.86,79.87 136.65,79.87 136.51,79.73 136.51,79.37 136.65,79.23 136.86,79.23 137,79.09 137,78.74 136.86,78.6 136.65,78.6 136.51,78.46 136.51,69.2 136.97,68.74 136.97,62.28 137.55,61.7 137.55,61.05 137.42,60.93 136.83,60.93 136.7,60.8 136.7,60.42 136.83,60.29 137.42,60.29 137.55,60.17 137.55,58 137.35,57.8 136.84,57.8 136.7,57.66 136.7,57.29 136.83,57.16 137.41,57.16 137.54,57.04 137.54,56.66 137.41,56.53 136.83,56.53 136.7,56.4 136.7,55.95 136.85,55.79 v1(137.39,55.79)
  BOTTOM w0.127: v2(136.68,55.79) v1(137.39,55.79)
M_B_DQ31: length 58.5
  TOP w0.102: XU1.AP28 130.87,98.71 v1(130.83,98.71)
  TOP w0.127: DIMM1.84 137.13,50.33 v1(137.14,50.34)
  IN1 w0.102: v1(130.83,98.71) 130.46,98.35 130.46,96.77 130.78,96.45 131.2,96.45 131.32,96.34 131.97,96.34 132.7,95.6 132.7,93.53 133.65,92.58 133.65,91.72
  IN1 w0.127: v1(137.14,50.34) 136.52,50.34 136.32,50.54 136.32,50.9 136.19,51.02 135.56,51.02 135.43,51.15 135.43,51.53 135.56,51.66 136.19,51.66 136.32,51.79 136.32,52.17 136.19,52.29 135.56,52.29 135.43,52.42 135.43,52.8 135.56,52.93 136.19,52.93 136.32,53.06 136.32,61.31 136.59,61.57 136.59,68.58 136.13,69.05 136.13,84.62 133.65,87.1 133.65,91.72
  BOTTOM w0.127: v1(137.14,50.34) 136.81,50.34 v2(136.27,49.8)
M_B_DQ32: length 53.3
  TOP w0.102: XU1.AR12 116.32,97.87 v1(116.32,97.8)
  TOP w0.127: v1(113.89,55.88) 113.89,57.27 DIMM1.169
  IN1 w0.102: v1(116.32,97.8) 115.83,97.32 115.83,94.03 115.92,93.94 115.92,92.49
  IN1 w0.127: v1(113.89,55.88) 114.34,55.88 114.48,56.02 114.48,56.38 114.34,56.52 113.33,56.52 113.19,56.66 113.19,57.33 113.36,57.5 113.71,57.5 113.84,57.37 113.84,57.11 113.97,56.99 114.27,56.99 114.48,57.19 114.48,59.82 114.34,59.96 114.13,59.96 113.99,60.1 113.99,60.45 114.13,60.59 114.34,60.59 114.48,60.73 114.48,61.09 114.34,61.23 114.13,61.23 113.99,61.37 113.99,61.72 114.13,61.86 114.34,61.86 114.48,62 114.48,68.42 113.82,69.07 113.82,73.59 113.69,73.72 113.37,73.72 113.23,73.86 113.23,74.22 113.37,74.36 113.69,74.36 113.82,74.5 113.82,74.86 113.69,74.99 113.37,74.99 113.23,75.13 113.23,75.49 113.37,75.63 113.69,75.63 113.82,75.77 113.82,76.25 113.68,76.39 113.38,76.39 113.21,76.57 113.21,87.22 115.92,89.93 115.92,92.49
  BOTTOM w0.127: v1(113.89,55.88) v2(114.42,56.41)
M_B_DQ33: length 52.9
  TOP w0.102: XU1.AP12 116.25,98.72 v1(116.25,98.69)
  TOP w0.127: v1(112.9,55.26) 112.88,55.28 DIMM1.173
  IN1 w0.102: v1(116.25,98.69) 115.41,97.84 115.41,95.68 114.79,95.06 114.79,92.4 115.1,92.09
  IN1 w0.127: 115.1,92.09 115.16,92.03 115.16,90.32 112.44,87.61 112.44,78.19 112.3,78.05 111.8,78.05 111.66,77.91 111.66,77.56 111.8,77.42 112.3,77.42 112.44,77.28 112.44,76.92 112.3,76.78 111.8,76.78 111.66,76.64 111.66,76.29 111.8,76.15 112.3,76.15 112.44,76.01 112.44,68.93 113.16,68.21 113.16,66.89 113.31,66.74 113.59,66.74 113.71,66.61 113.71,62.63 113.22,62.13 113.22,59.77 113.17,59.72 113.17,58.81 113.03,58.66 112.62,58.66 112.43,58.47 112.43,55.73 v1(112.9,55.26)
  BOTTOM w0.127: v2(112.9,55.99) v1(112.9,55.26)
M_B_DQ34: length 57.6
  TOP w0.102: XU1.AM13 118.06,100.57 v1(118.1,100.57)
  TOP w0.127: DIMM1.183 110.38,58.53 v1(110.38,58.54)
  IN1 w0.102: v1(118.1,100.57) 117.64,101.03 115.92,101.03 114.58,99.68 114.58,96 113.97,95.39 113.97,92.1 113.58,91.72
  IN1 w0.127: v1(110.38,58.54) 110.41,58.57 110.41,61.08 111.54,62.21 111.54,62.57 111.31,62.8 111.31,64.13 111.17,64.27 110.55,64.27 110.41,64.41 110.41,64.77 110.55,64.9 111.17,64.9 111.31,65.04 111.31,65.74 110.28,66.76 110.28,68.07 110.29,68.07 110.29,69.97 109.78,70.47 109.78,79.75 109.93,79.9 110.59,79.9 110.77,80.07 110.77,80.39 110.63,80.53 110.02,80.53 109.88,80.67 109.88,81.03 110.02,81.17 110.63,81.17 110.77,81.31 110.77,81.66 110.63,81.8 110.02,81.8 109.88,81.94 109.88,82.3 110.02,82.44 110.63,82.44 110.77,82.58 110.77,82.93 110.63,83.07 110.02,83.07 109.88,83.21 109.88,83.57 110.02,83.71 110.63,83.71 110.77,83.85 110.77,88.3 113.58,91.12 113.58,91.72
  BOTTOM w0.127: v1(110.38,58.54) 110.63,58.28 v2(111.11,58.28)
M_B_DQ35: length 58.7
  TOP w0.102: XU1.AL13 117.22,101.52 v1(117.22,101.46)
  TOP w0.127: DIMM1.187 v1(109.38,56.01)
  IN1 w0.102: v1(117.22,101.46) 116.77,101.91 115.17,101.91 114.17,100.91 114.17,96.2 113.55,95.58 113.55,92.44 112.78,91.67
  IN1 w0.127: v1(109.38,56.01) 109.38,57.38 108.58,58.18 108.58,60.36 109.59,61.36 109.59,65.86 109.58,65.86 108.94,66.5 108.94,84.11 109.08,84.25 109.36,84.25 109.5,84.39 109.5,84.75 109.36,84.89 109.08,84.89 108.94,85.03 108.94,85.38 109.08,85.52 109.86,85.52 110,85.66 110,86.02 109.86,86.16 109.08,86.16 108.94,86.3 108.94,86.65 109.08,86.79 109.86,86.79 110,86.93 110,87.29 109.86,87.43 109.08,87.43 108.94,87.57 108.94,87.83 112.78,91.67
  BOTTOM w0.127: v1(109.38,56.01) v2(108.66,56.01)
M_B_DQ36: length 54
  TOP w0.102: v1(117.1,97.82) 117.17,97.82 XU1.AR13
  TOP w0.127: DIMM1.170 113.63,50.28 v1(113.74,50.38)
  IN1 w0.102: v1(117.1,97.82) 116.68,97.39 116.68,93.66 116.3,93.28 116.3,91.97
  IN1 w0.127: 116.3,91.97 116.3,91.96 116.3,89.77 113.59,87.06 113.59,77.03 114.21,76.41 114.21,69.23 114.86,68.58 114.86,55.6 113.74,54.49 113.74,53.37 113.6,53.23 113.19,53.23 113.05,53.09 113.05,52.74 113.19,52.6 113.6,52.6 113.74,52.46 113.74,52.1 113.6,51.96 113.19,51.96 113.05,51.82 113.05,51.47 113.19,51.33 113.6,51.33 113.74,51.19 v1(113.74,50.38)
