# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Library data of the parts (continued)
PU89001 = MX_NCP81203_4VIA
PU90001 PU90002 PU93001 PU93002 PU93004 = NCP5901MNTBG_0
PU93003 = LM393MX_1
Q1 = PNP_SOT23
Q4000 = P_MOS_SOT23
Q9433 Q93025 Q93041 = N_MOS_SOT23
R99527 = SHORT_PIN_SR_S
RN11 RN125-RN128 = MX_2R4PS_SHORT
RN43 RN44 = TX_2R4PS_SHORT
RN80 RN86 RN89-RN91 RN93-RN95 RN107-RN109 RN149 = 2R4Ps
RN133 RN134 = 4R8Ps
SW10 = TACT_SWITCH_4P_2HOLD_DIPTRON
SW_RST1 = TACT_SWITCH_4P_ALP
U1 = PCH
U6 = ALC3234_CGT_6
U104 = SCH5553_NU_SMC
U114 = RTL8151GH_CG_38
U131 = P1100SA
U7201 = NPCT750JAAYX_4VIA
U9434 = MX25L12875FM2I_10G
U9435 = W25Q128FVFIQ
UB1 = ICS553MILFT
UU19 UU22 UU65 = G524D1T11U
UU64 UU66 = G517C2T11U
XBT1 = BATT_HOLDER
XDP1 XDP3 = BTOB_CON_60P_2HOLD_TY
XU1 = MX_AZIF0049_P001C_3HD_COF
Y5 = CRYSTAL_SMD_23GND
Y18 Y4000 = CRYSTAL_SMD_24GND

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
A_BGA_874P_988X949_N
  round 0.305 smd: A2(-11.46,11.314) A3(-10.959,11.314) A4(-10.459,11.314) A46(10.459,11.314) A47(10.959,11.314) A48(11.46,11.314) AA19(-3.099,1.549) AA20(-2.324,1.549) AA22(-1.549,1.549) AA23(-0.775,1.549) AA25(0,1.549) AA27(0.775,1.549) AA28(1.549,1.549) AA30(2.324,1.549) AA31(3.099,1.549) AB19(-3.099,0.775) AB20(-2.324,0.775) AB22(-1.549,0.775) AB23(-0.775,0.775) AB25(0,0.775) AB27(0.775,0.775) AB28(1.549,0.775) AB30(2.324,0.775) AB31(3.099,0.775) AC6(-9.374,0.579) AC7(-8.612,0.579) AC9(-7.85,0.579) AC11(-7.088,0.579) AC12(-6.326,0.579) AC14(-5.564,0.579) AC15(-4.802,0.579) AC17(-4.04,0.579) AC33(4.04,0.579) AC35(4.802,0.579) AC36(5.564,0.579) AC38(6.326,0.579) AC39(7.088,0.579) AC41(7.85,0.579) AC43(8.612,0.579) AC44(9.374,0.579) AD19(-3.099,0) AD20(-2.324,0) AD22(-1.549,0) AD23(-0.775,0) AD25(0,0) AD27(0.775,0) AD28(1.549,0) AD30(2.324,0) AD31(3.099,0) AE6(-9.374,-0.579) AE7(-8.612,-0.579) AE9(-7.85,-0.579) AE11(-7.088,-0.579) AE12(-6.326,-0.579) AE14(-5.564,-0.579) AE15(-4.802,-0.579) AE17(-4.04,-0.579) AE33(4.04,-0.579) AE35(4.802,-0.579) AE36(5.564,-0.579) AE38(6.326,-0.579) AE39(7.088,-0.579) AE41(7.85,-0.579) AE43(8.612,-0.579) AE44(9.374,-0.579) AF19(-3.099,-0.775) AF20(-2.324,-0.775) AF22(-1.549,-0.775) AF23(-0.775,-0.775) AF25(0,-0.775) AF27(0.775,-0.775) AF28(1.549,-0.775) AF30(2.324,-0.775) AF31(3.099,-0.775) AG19(-3.099,-1.549) AG20(-2.324,-1.549) AG22(-1.549,-1.549) AG23(-0.775,-1.549) AG25(0,-1.549) AG27(0.775,-1.549) AG28(1.549,-1.549) AG30(2.324,-1.549) AG31(3.099,-1.549) AH9(-7.919,-2.205) AH10(-7.18,-2.014) AH12(-6.402,-2.014) AH14(-5.564,-2.014) AH15(-4.789,-2.014) AH17(-4.027,-2.014) AH33(4.027,-2.014) AH35(4.789,-2.014) AH36(5.564,-2.014) AH38(6.402,-2.014) AH40(7.18,-2.014) AH41(7.919,-2.205) AJ6(-9.397,-2.586) AJ7(-8.658,-2.395) AJ19(-3.099,-2.324) AJ20(-2.324,-2.324) AJ22(-1.549,-2.324) AJ23(-0.775,-2.324) AJ25(0,-2.324) AJ27(0.775,-2.324) AJ28(1.549,-2.324) AJ30(2.324,-2.324) AJ31(3.099,-2.324) AJ43(8.658,-2.395) AJ44(9.397,-2.586) AK19(-3.099,-3.099) AK20(-2.324,-3.099) AK22(-1.549,-3.099) AK23(-0.775,-3.099) AK25(0,-3.099) AK27(0.775,-3.099) AK28(1.549,-3.099) AK30(2.324,-3.099) AK31(3.099,-3.099) AL9(-7.914,-3.495) AL10(-7.181,-3.259) AL12(-6.419,-3.259) AL13(-5.657,-3.259) AL15(-4.895,-3.259) AL17(-4.133,-3.259) AL21(-2.014,-3.578) AL24(-0.579,-3.591) AL26(0.579,-3.591) AL29(2.014,-3.578) AL33(4.133,-3.259) AL35(4.895,-3.259) AL37(5.657,-3.259) AL38(6.419,-3.259) AL40(7.181,-3.259) AL41(7.914,-3.495) AM7(-8.635,-3.843) AM18(-3.259,-3.683) AM32(3.259,-3.683) AM43(8.635,-3.843) AN6(-9.295,-4.224) AN10(-7.181,-4.656) AN12(-6.444,-4.351) AN13(-5.682,-4.351) AN15(-4.92,-4.351) AN16(-4.351,-4.394) AN18(-3.259,-4.394) AN21(-2.014,-4.289) AN24(-0.579,-4.302) AN26(0.579,-4.302) AN29(2.014,-4.289) AN32(3.259,-4.394) AN34(4.351,-4.394) AN35(4.92,-4.351) AN37(5.682,-4.351) AN38(6.444,-4.351) AN40(7.181,-4.656) AN44(9.295,-4.224) AP9(-7.914,-4.968) AP21(-2.014,-5.064) AP24(-0.579,-5.064) AP26(0.579,-5.064) AP29(2.014,-5.064) AP41(7.914,-4.968) AR8(-8.508,-5.469) AR12(-6.444,-5.443) AR13(-5.682,-5.443) AR15(-4.92,-5.443) AR16(-4.351,-5.182) AR18(-3.259,-5.156) AR32(3.259,-5.156) AR34(4.351,-5.182) AR35(4.92,-5.443) AR37(5.682,-5.443) AR38(6.444,-5.443) AR42(8.508,-5.469) AT6(-9.295,-5.659) AT10(-7.181,-5.773) AT16(-4.351,-5.944) AT18(-3.259,-5.918) AT21(-2.014,-5.902) AT24(-0.579,-5.826) AT26(0.579,-5.826) AT29(2.014,-5.902) AT32(3.259,-5.918) AT34(4.351,-5.944) AT40(7.181,-5.773) AT44(9.295,-5.659) AU9(-7.914,-6.416) AU24(-0.579,-6.588) AU26(0.579,-6.588) AU41(7.914,-6.416) AV6(-9.295,-7.094) AV7(-8.597,-6.764) AV11(-7.079,-6.975) AV13(-5.748,-6.757) AV16(-4.656,-6.719) AV18(-3.259,-6.68) AV21(-2.014,-6.679) AV29(2.014,-6.679) AV32(3.259,-6.68) AV34(4.656,-6.719) AV37(5.748,-6.757) AV39(7.079,-6.975) AV43(8.597,-6.764) AV44(9.295,-7.094) AW9(-7.824,-7.577) AW10(-7.262,-7.509) AW13(-6.01,-7.49) AW15(-4.892,-7.452) AW18(-3.495,-7.413) AW21(-2.205,-7.419) AW24(-0.579,-7.35) AW26(0.579,-7.35) AW29(2.205,-7.419) AW32(3.495,-7.413) AW35(4.892,-7.452) AW37(6.01,-7.49) AW40(7.262,-7.509) AW41(7.824,-7.577) AY8(-8.533,-7.898) AY42(8.533,-7.898) B1(-11.814,10.96) B2(-11.33,10.83) B3(-10.709,10.878) B47(10.709,10.878) B48(11.33,10.83) B49(11.814,10.96) BA6(-9.13,-8.203) BA12(-6.485,-8.135) BA14(-5.24,-8.135) BA17(-3.843,-8.135) BA20(-2.395,-8.158) BA24(-0.579,-8.112) BA26(0.579,-8.112) BA30(2.395,-8.158) BA33(3.843,-8.135) BA36(5.24,-8.135) BA38(6.485,-8.135) BA44(9.13,-8.203) BB6(-9.088,-8.706) BB7(-8.589,-9) BB9(-8.024,-8.774) BB11(-6.866,-8.795) BB14(-5.621,-8.795) BB16(-4.224,-8.795) BB20(-2.586,-8.897) BB24(-0.579,-8.874) BB26(0.579,-8.874) BB30(2.586,-8.897) BB34(4.224,-8.795) BB36(5.621,-8.795) BB39(6.866,-8.795) BB41(8.024,-8.774) BB43(8.589,-9) BB44(9.088,-8.706) BC5(-9.634,-9.254) BC45(9.634,-9.254) BD1(-11.814,-9.959) BD4(-10.474,-9.983) BD46(10.474,-9.983) BD49(11.814,-9.959) BE1(-11.814,-10.459) BE2(-11.373,-10.196) BE3(-10.86,-10.311) BE4(-10.391,-10.487) BE5(-9.965,-10.212) BE45(9.965,-10.212) BE46(10.391,-10.487) BE47(10.86,-10.311) BE48(11.373,-10.196) BE49(11.814,-10.459) BF1(-11.814,-10.96) BF2(-11.33,-10.83) BF3(-10.709,-10.878) BF47(10.709,-10.878) BF48(11.33,-10.83) BF49(11.814,-10.96) BG2(-11.46,-11.314) BG3(-10.959,-11.314) BG4(-10.459,-11.314) BG46(10.459,-11.314) BG47(10.959,-11.314) BG48(11.46,-11.314) C1(-11.814,10.459) C2(-11.373,10.196) C3(-10.86,10.311) C4(-10.391,10.487) C5(-9.965,10.212) C45(9.965,10.212) C46(10.391,10.487) C47(10.86,10.311) C48(11.373,10.196) C49(11.814,10.459) D1(-11.814,9.959) D4(-10.474,9.983) D46(10.474,9.983) D49(11.814,9.959) E5(-9.634,9.254) E45(9.634,9.254) F6(-9.088,8.706) F7(-8.589,9) F9(-8.024,8.774) F11(-6.866,8.795) F14(-5.621,8.795) F16(-4.224,8.795) F20(-2.586,8.897) F24(-0.579,8.874) F26(0.579,8.874) F30(2.586,8.897) F34(4.224,8.795) F36(5.621,8.795) F39(6.866,8.795) F41(8.024,8.774) F43(8.589,9) F44(9.088,8.706) G6(-9.13,8.203) G12(-6.485,8.135) G14(-5.24,8.135) G17(-3.843,8.135) G20(-2.395,8.158) G24(-0.579,8.112) G26(0.579,8.112) G30(2.395,8.158) G33(3.843,8.135) G36(5.24,8.135) G38(6.485,8.135) G44(9.13,8.203) H8(-8.533,7.898) H42(8.533,7.898) J9(-7.824,7.577) J10(-7.262,7.509) J13(-6.01,7.49) J15(-4.892,7.452) J18(-3.495,7.413) J21(-2.205,7.419) J24(-0.579,7.35) J26(0.579,7.35) J29(2.205,7.419) J32(3.495,7.413) J35(4.892,7.452) J37(6.01,7.49) J40(7.262,7.509) J41(7.824,7.577) K6(-9.295,7.094) K7(-8.597,6.764) K11(-7.079,6.975) K13(-5.748,6.757) K16(-4.656,6.719) K18(-3.259,6.68) K21(-2.014,6.679) K29(2.014,6.679) K32(3.259,6.68) K34(4.656,6.719) K37(5.748,6.757) K39(7.079,6.975) K43(8.597,6.764) K44(9.295,7.094) L9(-7.914,6.416) L24(-0.579,6.588) L26(0.579,6.588) L41(7.914,6.416) M6(-9.295,5.659) M10(-7.181,5.773) M16(-4.351,5.944) M18(-3.259,5.918) M21(-2.014,5.902) M24(-0.579,5.826) M26(0.579,5.826) M29(2.014,5.902) M32(3.259,5.918) M34(4.351,5.944) M40(7.181,5.773) M44(9.295,5.659) N8(-8.508,5.469) N12(-6.444,5.443) N13(-5.682,5.443) N15(-4.92,5.443) N16(-4.351,5.182) N18(-3.259,5.156) N32(3.259,5.156) N34(4.351,5.182) N35(4.92,5.443) N37(5.682,5.443) N38(6.444,5.443) N42(8.508,5.469) P9(-7.914,4.968) P21(-2.014,5.064) P24(-0.579,5.064) P26(0.579,5.064) P29(2.014,5.064) P41(7.914,4.968) R6(-9.295,4.224) R10(-7.181,4.656) R12(-6.444,4.351) R13(-5.682,4.351) R15(-4.92,4.351) R16(-4.351,4.394) R18(-3.259,4.394) R21(-2.014,4.289) R24(-0.579,4.302) R26(0.579,4.302) R29(2.014,4.289) R32(3.259,4.394) R34(4.351,4.394) R35(4.92,4.351) R37(5.682,4.351) R38(6.444,4.351) R40(7.181,4.656) R44(9.295,4.224) T7(-8.635,3.843) T17(-3.811,3.683) T18(-3.259,3.683) T32(3.259,3.683) T43(8.635,3.843) U9(-7.914,3.495) U10(-7.181,3.259) U12(-6.419,3.259) U13(-5.657,3.259) U15(-4.895,3.259) U17(-4.133,3.259) U21(-2.014,3.578) U24(-0.579,3.591) U26(0.579,3.591) U29(2.014,3.578) U33(4.133,3.259) U35(4.895,3.259) U37(5.657,3.259) U38(6.419,3.259) U40(7.181,3.259) U41(7.914,3.495) V19(-3.099,3.099) V20(-2.324,3.099) V22(-1.549,3.099) V23(-0.775,3.099) V25(0,3.099) V27(0.775,3.099) V28(1.549,3.099) V30(2.324,3.099) V31(3.099,3.099) W6(-9.397,2.586) W7(-8.658,2.395) W19(-3.099,2.324) W20(-2.324,2.324) W22(-1.549,2.324) W23(-0.775,2.324) W25(0,2.324) W27(0.775,2.324) W28(1.549,2.324) W30(2.324,2.324) W31(3.099,2.324) W43(8.658,2.395) W44(9.397,2.586) Y9(-7.919,2.205) Y10(-7.18,2.014) Y12(-6.402,2.014) Y14(-5.564,2.014) Y15(-4.789,2.014) Y17(-4.027,2.014) Y33(4.027,2.014) Y35(4.789,2.014) Y36(5.564,2.014) Y38(6.402,2.014) Y40(7.18,2.014) Y41(7.919,2.205)
  round 0.279 smd: A5(-9.958,11.314) A45(9.958,11.314) BC1(-11.814,-9.458) BC49(11.814,-9.458) BG5(-9.958,-11.314) BG45(9.958,-11.314) E1(-11.814,9.458) E49(11.814,9.458)
  oval 0.203x0.254 smd: A6(-9.399,11.314) A8(-8.294,11.314) A13(-6.072,11.314) A17(-3.875,11.314) A22(-1.678,11.314) A25(0,11.314) A28(1.678,11.314) A33(3.875,11.314) A37(6.072,11.314) A42(8.294,11.314) A44(9.399,11.314) B10(-7.123,10.603) B12(-6.265,10.816) B14(-5.587,10.687) B15(-4.926,10.603) B17(-4.068,10.816) B18(-3.39,10.687) B19(-2.729,10.603) B21(-1.871,10.816) B23(-1.193,10.687) B24(-0.532,10.603) B25(0,10.806) B26(0.532,10.603) B27(1.193,10.687) B29(1.871,10.816) B31(2.729,10.603) B32(3.39,10.687) B33(4.068,10.816) B35(4.926,10.603) B36(5.587,10.687) B38(6.265,10.816) B40(7.123,10.603) BD8(-8.411,-9.813) BD12(-6.214,-9.813) BD17(-4.017,-9.813) BD21(-1.82,-9.813) BD29(1.82,-9.813) BD33(4.017,-9.813) BD38(6.214,-9.813) BD42(8.411,-9.813) BE9(-7.784,-10.186) BE10(-7.283,-10.059) BE11(-6.76,-10.118) BE12(-6.295,-10.313) BE14(-5.587,-10.186) BE15(-5.086,-10.059) BE16(-4.563,-10.118) BE17(-4.098,-10.313) BE18(-3.39,-10.186) BE19(-2.889,-10.059) BE20(-2.366,-10.118) BE21(-1.901,-10.313) BE23(-1.193,-10.186) BE24(-0.692,-10.059) BE25(0,-10.298) BE26(0.692,-10.059) BE27(1.193,-10.186) BE29(1.901,-10.313) BE30(2.366,-10.118) BE31(2.889,-10.059) BE32(3.39,-10.186) BE33(4.098,-10.313) BE34(4.563,-10.118) BE35(5.086,-10.059) BE36(5.587,-10.186) BE38(6.295,-10.313) BE39(6.76,-10.118) BE40(7.283,-10.059) BE41(7.784,-10.186) BF10(-7.123,-10.603) BF12(-6.265,-10.816) BF14(-5.587,-10.687) BF15(-4.926,-10.603) BF17(-4.068,-10.816) BF18(-3.39,-10.687) BF19(-2.729,-10.603) BF21(-1.871,-10.816) BF23(-1.193,-10.687) BF24(-0.532,-10.603) BF25(0,-10.806) BF26(0.532,-10.603) BF27(1.193,-10.687) BF29(1.871,-10.816) BF31(2.729,-10.603) BF32(3.39,-10.687) BF33(4.068,-10.816) BF35(4.926,-10.603) BF36(5.587,-10.687) BF38(6.265,-10.816) BF40(7.123,-10.603) BG6(-9.399,-11.314) BG8(-8.294,-11.314) BG13(-6.072,-11.314) BG17(-3.875,-11.314) BG22(-1.678,-11.314) BG25(0,-11.314) BG28(1.678,-11.314) BG33(3.875,-11.314) BG37(6.072,-11.314) BG42(8.294,-11.314) BG44(9.399,-11.314) C9(-7.784,10.186) C10(-7.283,10.059) C11(-6.76,10.118) C12(-6.295,10.313) C14(-5.587,10.186) C15(-5.086,10.059) C16(-4.563,10.118) C17(-4.098,10.313) C18(-3.39,10.186) C19(-2.889,10.059) C20(-2.366,10.118) C21(-1.901,10.313) C23(-1.193,10.186) C24(-0.692,10.059) C25(0,10.298) C26(0.692,10.059) C27(1.193,10.186) C29(1.901,10.313) C30(2.366,10.118) C31(2.889,10.059) C32(3.39,10.186) C33(4.098,10.313) C34(4.563,10.118) C35(5.086,10.059) C36(5.587,10.186) C38(6.295,10.313) C39(6.76,10.118) C40(7.283,10.059) C41(7.784,10.186) D8(-8.411,9.813) D12(-6.214,9.813) D17(-4.017,9.813) D21(-1.82,9.813) D29(1.82,9.813) D33(4.017,9.813) D38(6.214,9.813) D42(8.411,9.813)
  oval 0.254x0.203 smd: AA1(-11.814,1.678) AA49(11.814,1.678) AB2(-11.187,1.193) AB3(-10.686,1.193) AB47(10.686,1.193) AB48(11.187,1.193) AC2(-11.103,0.532) AC3(-10.559,0.692) AC47(10.559,0.692) AC48(11.103,0.532) AD1(-11.814,0) AD2(-11.306,0) AD3(-10.798,0) AD47(10.798,0) AD48(11.306,0) AD49(11.814,0) AE2(-11.103,-0.532) AE3(-10.559,-0.692) AE47(10.559,-0.692) AE48(11.103,-0.532) AF2(-11.187,-1.193) AF3(-10.686,-1.193) AF47(10.686,-1.193) AF48(11.187,-1.193) AG1(-11.814,-1.678) AG49(11.814,-1.678) AH2(-11.316,-1.871) AH3(-10.813,-1.901) AH4(-10.313,-1.82) AH46(10.313,-1.82) AH47(10.813,-1.901) AH48(11.316,-1.871) AJ3(-10.618,-2.366) AJ47(10.618,-2.366) AK2(-11.103,-2.729) AK3(-10.559,-2.883) AK47(10.559,-2.883) AK48(11.103,-2.729) AL2(-11.187,-3.39) AL3(-10.686,-3.39) AL47(10.686,-3.39) AL48(11.187,-3.39) AM1(-11.814,-3.875) AM2(-11.316,-4.068) AM3(-10.813,-4.098) AM4(-10.313,-4.017) AM46(10.313,-4.017) AM47(10.813,-4.098) AM48(11.316,-4.068) AM49(11.814,-3.875) AN3(-10.618,-4.563) AN47(10.618,-4.563) AP2(-11.103,-4.926) AP3(-10.559,-5.08) AP47(10.559,-5.08) AP48(11.103,-4.926) AR3(-10.686,-5.587) AR47(10.686,-5.587) AT1(-11.814,-6.097) AT49(11.814,-6.097) AU4(-10.313,-6.214) AU46(10.313,-6.214) AW3(-10.559,-7.277) AW47(10.559,-7.277) AY3(-10.686,-7.784) AY47(10.686,-7.784) BA1(-11.814,-8.32) BA49(11.814,-8.32) G1(-11.814,8.32) G49(11.814,8.32) H3(-10.686,7.784) H47(10.686,7.784) J3(-10.559,7.277) J47(10.559,7.277) L4(-10.313,6.214) L46(10.313,6.214) M1(-11.814,6.097) M49(11.814,6.097) N3(-10.686,5.587) N47(10.686,5.587) P2(-11.103,4.926) P3(-10.559,5.08) P47(10.559,5.08) P48(11.103,4.926) R3(-10.618,4.563) R47(10.618,4.563) T1(-11.814,3.875) T2(-11.316,4.068) T3(-10.813,4.098) T4(-10.313,4.017) T46(10.313,4.017) T47(10.813,4.098) T48(11.316,4.068) T49(11.814,3.875) U2(-11.187,3.39) U3(-10.686,3.39) U47(10.686,3.39) U48(11.187,3.39) V2(-11.103,2.729) V3(-10.559,2.883) V47(10.559,2.883) V48(11.103,2.729) W3(-10.618,2.366) W47(10.618,2.366) Y2(-11.316,1.871) Y3(-10.813,1.901) Y4(-10.313,1.82) Y46(10.313,1.82) Y47(10.813,1.901) Y48(11.316,1.871)
  round 0.254 smd: AA5(-9.856,1.601) AA45(9.856,1.601) AC4(-10.06,0.579) AC46(10.06,0.579) AE4(-10.06,-0.579) AE46(10.06,-0.579) AG5(-9.856,-1.601) AG45(9.856,-1.601) AJ4(-10.098,-2.274) AJ46(10.098,-2.274) AK4(-10.06,-2.776) AK46(10.06,-2.776) AM5(-9.856,-3.799) AM45(9.856,-3.799) AN4(-10.098,-4.471) AN46(10.098,-4.471) AP4(-10.06,-4.973) AP46(10.06,-4.973) AT5(-9.856,-5.996) AT45(9.856,-5.996) AV4(-10.098,-6.669) AV46(10.098,-6.669) AW4(-10.06,-7.17) AW46(10.06,-7.17) B6(-9.397,10.811) B44(9.397,10.811) BA2(-11.316,-8.526) BA3(-10.809,-8.594) BA4(-10.304,-8.468) BA5(-9.856,-8.193) BA45(9.856,-8.193) BA46(10.304,-8.468) BA47(10.809,-8.594) BA48(11.316,-8.526) BB3(-11.318,-9.315) BB4(-10.825,-9.126) BB46(10.825,-9.126) BB47(11.318,-9.315) BC8(-8.193,-9.356) BC10(-7.17,-9.56) BC13(-5.996,-9.356) BC15(-4.973,-9.56) BC17(-3.799,-9.356) BC19(-2.776,-9.56) BC22(-1.601,-9.356) BC24(-0.579,-9.56) BC26(0.579,-9.56) BC28(1.601,-9.356) BC31(2.776,-9.56) BC33(3.799,-9.356) BC35(4.973,-9.56) BC37(5.996,-9.356) BC40(7.17,-9.56) BC42(8.193,-9.356) BD7(-8.914,-9.872) BD11(-6.669,-9.598) BD16(-4.471,-9.598) BD20(-2.274,-9.598) BD30(2.274,-9.598) BD34(4.471,-9.598) BD39(6.669,-9.598) BD43(8.914,-9.872) BE6(-9.091,-10.357) BE44(9.091,-10.357) BF6(-9.397,-10.811) BF44(9.397,-10.811) C6(-9.091,10.357) C44(9.091,10.357) D7(-8.914,9.872) D11(-6.669,9.598) D16(-4.471,9.598) D20(-2.274,9.598) D30(2.274,9.598) D34(4.471,9.598) D39(6.669,9.598) D43(8.914,9.872) E8(-8.193,9.356) E10(-7.17,9.56) E13(-5.996,9.356) E15(-4.973,9.56) E17(-3.799,9.356) E19(-2.776,9.56) E22(-1.601,9.356) E24(-0.579,9.56) E26(0.579,9.56) E28(1.601,9.356) E31(2.776,9.56) E33(3.799,9.356) E35(4.973,9.56) E37(5.996,9.356) E40(7.17,9.56) E42(8.193,9.356) F3(-11.318,9.315) F4(-10.825,9.126) F46(10.825,9.126) F47(11.318,9.315) G2(-11.316,8.526) G3(-10.809,8.594) G4(-10.304,8.468) G5(-9.856,8.193) G45(9.856,8.193) G46(10.304,8.468) G47(10.809,8.594) G48(11.316,8.526) J4(-10.06,7.17) J46(10.06,7.17) K4(-10.098,6.669) K46(10.098,6.669) M5(-9.856,5.996) M45(9.856,5.996) P4(-10.06,4.973) P46(10.06,4.973) R4(-10.098,4.471) R46(10.098,4.471) T5(-9.856,3.799) T45(9.856,3.799) V4(-10.06,2.776) V46(10.06,2.776) W4(-10.098,2.274) W46(10.098,2.274)
  oval 0.305x0.203 smd: AR2(-11.187,-5.587) AR48(11.187,-5.587) AU2(-11.316,-6.265) AU3(-10.813,-6.295) AU47(10.813,-6.295) AU48(11.316,-6.265) AV3(-10.618,-6.76) AV47(10.618,-6.76) AW2(-11.103,-7.123) AW48(11.103,-7.123) AY2(-11.187,-7.784) AY48(11.187,-7.784) H2(-11.187,7.784) H48(11.187,7.784) J2(-11.103,7.123) J48(11.103,7.123) K3(-10.618,6.76) K47(10.618,6.76) L2(-11.316,6.265) L3(-10.813,6.295) L47(10.813,6.295) L48(11.316,6.265) N2(-11.187,5.587) N48(11.187,5.587)
  oval 0.203x0.305 smd: B8(-8.462,10.816) B9(-7.784,10.687) B41(7.784,10.687) B42(8.462,10.816) BE8(-8.492,-10.313) BE42(8.492,-10.313) BF8(-8.462,-10.816) BF9(-7.784,-10.687) BF41(7.784,-10.687) BF42(8.462,-10.816) C8(-8.492,10.313) C42(8.492,10.313)
A_HOLE_O118X28DO118X28N
  oval 2.997x0.711 hole 2.997x0.711 unplated: (0,0)
A_VARISTOR_0603_71X39_TK
  rect 1.067x0.787 smd: 1(-0.882,0) 2(0.882,0)
DX_CE_98_268_H236_HD31_LF5
  rect 1.194x1.194 hole 0.787: 1(1.25,0)
  round 1.194 hole 0.787: 2(-1.25,0)
DX_LED_D_2P_90_1H_RA_CO_LF5
  round 1.753 hole 1.753 unplated: (0,0)
  rect 1.372x1.372 hole 0.965: 1(-1.14,2.8)
  round 1.372 hole 0.965: 2(1.14,2.8)
DX_TO92_102_FSBREC_LF5
  rect 1.27x1.27 hole 0.864: 1(0,2.6)
  round 1.27 hole 0.864: 2(0,0) 3(0,-2.6)
H_2D_D169ND98X197N_M2_P2_V7
  round 4.293 hole 4.293 unplated: (0,0)
  oval 2.489x5.004 hole 2.489x5.004 unplated: (0,-1.25)
  round 0.61 hole 0.305: 3(0,3.201) 4(2.263,2.263) 5(3.201,0) 6(2.263,-2.263) 7(-2.263,-2.263) 8(-3.2,0) 9(-2.263,2.263)
HOLE_C157D157N
  round 3.988 hole 3.988 unplated: (0,0)
HOLE_C275D177N_M2_P2_V8
  round 4.496 hole 4.496 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,2.997) 3(2.119,2.119) 4(2.997,0) 5(2.119,-2.119) 6(0,-2.997) 7(-2.119,-2.119) 8(-2.997,0) 9(-2.119,2.119)
HOLE_C315D169N_M2_P2_V8
  round 4.293 hole 4.293 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.201) 3(2.263,2.263) 4(3.201,0) 5(2.263,-2.263) 6(0,-3.2) 7(-2.263,-2.263) 8(-3.2,0) 9(-2.263,2.263)
HOLE_C315D181N_M2_P2_V8
  round 4.597 hole 4.597 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.276) 3(2.316,2.316) 4(3.276,0) 5(2.316,-2.316) 6(0,-3.276) 7(-2.316,-2.316) 8(-3.276,0) 9(-2.316,2.316)
HOLE_C315D181N_M2_P2_V8#2
  round 4.597 hole 4.597 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.276) 3(2.316,2.316) 4(2.895,0) 5(2.316,-2.316) 6(0,-3.276) 7(-2.316,-2.316) 8(-3.276,0) 9(-2.316,2.316)
HOLE_C334D157N_M2_P2_V8
  round 3.988 hole 3.988 unplated: (0,0)
  round 0.61 hole 0.305: 2(0,3.245) 3(2.295,2.295) 4(3.245,0) 5(2.295,-2.294) 6(0,-3.245) 7(-2.294,-2.294) 8(-3.245,0) 9(-2.294,2.295)
HOLE_C394D157N_M2_P2_V8_SPE
  round 3.988 hole 3.988 unplated: (0,0)
  oval 2.489x3.429 hole 2.489x3.429 unplated: (0,-2.03)
  round 0.61 hole 0.305: 3(0,3.626) 4(2.564,2.564) 5(3.626,0) 6(2.157,-2.915) 7(0,-4.696) 8(-2.157,-2.914) 9(-3.626,0) 10(-2.564,2.564)
HSK_4P_1071X1071_2ANCHO_LF5
  round 1.575 hole 1.168: 1(25.42,-17.25) 2(20.34,-17.25) 3(-20.34,17.25) 4(-25.42,17.25)
LB1_LOGO_375X375
  round 0 smd: 1(0,0)
MX_2R4P0402
  rect 0.254x0.66 smd: 1(-0.325,-0.575) 2(-0.325,0.575) 3(0.325,-0.575) 4(0.325,0.575)
MX_2R4P0603_SHORT
  rect 0.508x0.838 smd: 1(-0.4,-0.825) 2(-0.4,0.825) 3(0.4,-0.825) 4(0.4,0.825)
MX_4R8P0603
  rect 0.635x0.94 smd: 1(-1.289,-0.818) 2(-1.289,0.818) 7(1.289,-0.818) 8(1.289,0.818)
  rect 0.457x0.94 smd: 3(-0.4,-0.818) 4(-0.4,0.818) 5(0.4,-0.818) 6(0.4,0.818)
MX_A_SMB_181X157_COLAY
  rect 1.93x2.083 smd: 1(2.391,0) 2(-2.391,0)
MX_ANCHOR_2P_100_AMCO_LF5
  rect 1.575x1.575 hole 1.168: 1(2.54,0)
  round 1.575 hole 1.168: 2(-2.54,0)
MX_BATHOLDER_2P_787_LF5
  rect 1.499x1.499 hole 1.092: 1(12.29,0)
  round 1.397 hole 0.991: 2(-7.71,0)
MX_BTOB_60P_20_F_SAMT_NS_NP
  round 1.041 hole 1.041 unplated: (-10.06,2.666) (10.066,2.666)
  rect 0.279x2.261 smd: 1(-7.25,-2.864) 2(-7.25,2.865) 3(-6.75,-2.864) 4(-6.75,2.865) 5(-6.25,-2.864) 6(-6.25,2.865) 7(-5.75,-2.864) 8(-5.75,2.865) 9(-5.25,-2.864) 10(-5.25,2.865) 11(-4.75,-2.864) 12(-4.75,2.865) 13(-4.25,-2.864) 14(-4.25,2.865) 15(-3.75,-2.864) 16(-3.75,2.865) 17(-3.25,-2.864) 18(-3.25,2.865) 19(-2.75,-2.864) 20(-2.75,2.865) 21(-2.25,-2.864) 22(-2.25,2.865) 23(-1.75,-2.864) 24(-1.75,2.865) 25(-1.25,-2.864) 26(-1.25,2.865) 27(-0.75,-2.864) 28(-0.75,2.865) 29(-0.25,-2.864) 30(-0.25,2.865) 31(0.25,-2.864) 32(0.25,2.865) 33(0.75,-2.864) 34(0.75,2.865) 35(1.25,-2.864) 36(1.25,2.865) 37(1.75,-2.864) 38(1.75,2.865) 39(2.25,-2.864) 40(2.25,2.865) 41(2.75,-2.864) 42(2.75,2.865) 43(3.25,-2.864) 44(3.25,2.865) 45(3.75,-2.864) 46(3.75,2.865) 47(4.25,-2.864) 48(4.25,2.865) 49(4.75,-2.864) 50(4.75,2.865) 51(5.25,-2.864) 52(5.25,2.865) 53(5.75,-2.864) 54(5.75,2.865) 55(6.25,-2.864) 56(6.25,2.865) 57(6.75,-2.864) 58(6.75,2.865) 59(7.25,-2.864) 60(7.25,2.865)
MX_C0201
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
MX_C0402_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_C0402_SMALL_T015
  rect 0.457x0.66 smd: 1(-0.419,0) 2(0.419,0)
MX_C0603_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_C0603_SMALL_T02
  rect 0.559x0.991 smd: 1(-0.67,0) 2(0.67,0)
MX_C0603_SMALL_T02_H37
  rect 0.559x0.991 smd: 1(-0.67,0) 2(0.67,0)
MX_C0805_SMALL_T02
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_C0805_SMALL_T02_H55
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_C1206_H75
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
MX_C7343D_H79
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
MX_C7343D_H83
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
MX_CE_79_BD217_H354HD31_LF5
  rect 1.194x1.194 hole 0.787: 1(1,0)
  round 1.194 hole 0.787: 2(-1,0)
MX_CE_98_BD268_H315_D33_LFH
  rect 1.219x1.219 hole 0.838: 1(1.25,0)
  round 1.219 hole 0.838: 2(-1.25,0)
MX_CE_98_BD268_H374_37_LFH
  rect 1.321x1.321 hole 0.94: 1(1.25,0)
  round 1.321 hole 0.94: 2(-1.25,0)
MX_CESMD_209X209_CHEMICON
  rect 2.769x1.88 smd: 1(1.983,0) 2(-1.983,0)
MX_CESMD_260X260_COLAY
  custom 0.47x0.47 smd: 1(2.475,0) 2(-2.475,0)
MX_CESMD_260X260_SAN
  rect 3.073x1.93 smd: 1(2.484,0) 2(-2.484,0)
MX_CHOKE_2P_158X177
  rect 3.988x1.651 smd: 1(0,1.425) 2(0,-1.425)
MX_CHOKE_4P_55X47_CHI
  rect 0.508x0.305 smd: 1(-0.625,0.275) 2(-0.625,-0.275) 3(0.625,-0.275) 4(0.625,0.275)
MX_CHOKE_4P_79X47
  rect 0.762x0.406 smd: 1(-0.925,-0.4) 2(0.925,-0.4) 3(0.925,0.4) 4(-0.925,0.4)
MX_CHOKE_4P_79X47_FUK_COLAY
  rect 0.889x0.406 smd: 1(-0.85,-0.401) 2(0.85,-0.4) 3(0.85,0.4) 4(-0.85,0.4)
MX_DDR4_260P_20_4H_STD_FX
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 2.007x3.505 smd: 263(-37.75,12) 264(37.75,8)
MX_DDR4_260P_20_4HOD_FOX
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
MX_DFN_8P_20_S79_PAD_ON
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.295x0.864 smd: 9(0,0)
MX_DFN_8P_26_122X122_2PAD
  rect 0.457x0.483 smd: 1(-0.975,-1.403) 2(-0.325,-1.403) 3(0.325,-1.403) 4(0.975,-1.403) 5(0.975,1.403) 6(0.325,1.403) 7(-0.325,1.403) 8(-0.975,1.403)
  rect 2.54x1.041 smd: 9(0,0.433)
  rect 2.54x0.559 smd: 10(0,-0.672)
MX_DFN_8P_50_201X248_P_8V
  rect 0.66x0.635 smd: 1(-1.905,-2.835) 8(-1.905,2.835)
  custom 0.487x0.487 smd: 2(0.643,-2.186)
  custom 0.161x0.161 smd: 5(0.667,2.803)
  rect 3.988x2.667 smd: 9(0,0.779)
  round 0.61 hole 0.305: 10(-1.687,1.807) 11(-0.561,1.807) 12(0.565,1.807) 13(1.681,1.807) 14(-1.689,-0.248) 15(-0.563,-0.248) 16(0.563,-0.248) 17(1.679,-0.248)
MX_DFN_10P_118X79_3PAD
  rect 0.254x0.584 smd: 1(-1.25,-0.99) 2(-0.65,-0.99) 3(0,-0.99) 4(0.65,-0.99) 5(1.25,-0.99) 6(1.25,0.99) 7(0.65,0.99) 8(0,0.99) 9(-0.65,0.99) 10(-1.25,0.99)
  rect 0.406x0.991 smd: 11(-0.95,0) 12(0,0) 13(0.95,0)
MX_DFN_14P_16_118X79_P_ANP
  rect 0.229x0.559 smd: 1(-1.2,-0.875) 2(-0.8,-0.875) 3(-0.4,-0.875) 4(0,-0.875) 5(0.4,-0.875) 6(0.8,-0.875) 7(1.2,-0.875) 8(1.2,0.875) 9(0.8,0.875) 10(0.4,0.875) 11(0,0.875) 12(-0.4,0.875) 13(-0.8,0.875) 14(-1.2,0.875)
  rect 2.591x0.838 smd: 15(0,0)
MX_DISPLAY_20P_4H_COXOC_LF5
  rect 1.118x1.118 hole 0.711: 1(6.2,7.2)
  round 1.118 hole 0.711: 2(5.7,5.8) 3(4.8,7.2) 4(4.4,5.8) 5(3.5,7.2) 6(3,5.8) 7(2.2,7.2) 8(1.7,5.8) 9(0.8,7.2) 10(0.4,5.8) 11(-0.5,7.2) 12(-1,5.8) 13(-1.8,7.2) 14(-2.3,5.8) 15(-3.1,7.2) 16(-3.6,5.8) 17(-4.5,7.2) 18(-4.9,5.8) 19(-5.8,7.2) 20(-6.2,5.8)
  oval 1.016x2.616 hole 0.61x2.21: 21(8.2,6.48) 22(-8.2,6.48)
  oval 1.016x2.108 hole 0.61x1.702: 23(8.2,0) 24(-8.2,0)
MX_ESD_10P_20_98X39_NXP
  rect 0.295x0.483 smd: 1(-1,-0.363) 2(-0.5,-0.363) 3(0,-0.363) 4(0.5,-0.363) 5(1,-0.363) 6(1,0.363) 7(0.5,0.363) 8(0,0.363) 9(-0.5,0.363) 10(-1,0.363)
MX_FPC_12P_39_4HOLD_AC
  rect 0.61x1.499 smd: 1(-2.75,-2.05) 2(-2.25,0.95) 3(-1.75,-2.05) 4(-1.25,0.95) 5(-0.75,-2.05) 6(-0.25,0.95) 7(0.25,-2.05) 8(0.75,0.95) 9(1.25,-2.05) 10(1.75,0.95) 11(2.25,-2.05) 12(2.75,0.95)
  rect 0.787x1.499 smd: 13(-3.75,-2.05) 14(-3.75,0.95) 15(3.75,-2.05) 16(3.75,0.95)
MX_HD_2X3P_100_LF3
  rect 1.575x1.575 hole 1.168: 1(-2.54,-1.27)
  round 1.575 hole 1.168: 2(-2.54,1.27) 3(0,-1.27) 4(0,1.27) 5(2.54,-1.27) 6(2.54,1.27)
MX_HD_2X4P_50_SINYA
  rect 0.711x2.565 smd: 1(-1.905,-1.887) 2(-1.905,1.887) 3(-0.635,-1.887) 4(-0.635,1.887) 5(0.635,-1.887) 6(0.635,1.887) 7(1.905,-1.887) 8(1.905,1.887)
MX_HD_2X5P_79_K4_H248_LF5
  rect 1.372x1.372 hole 0.965: 1(-4,-1)
  round 1.372 hole 0.965: 2(-4,1) 3(-2,-1) 5(0,-1) 6(0,1) 7(2,-1) 8(2,1) 9(4,-1) 10(4,1)
MX_HD_2X7P_100_XINYA_NOMASK
  rect 0.991x3.251 smd: 1(-7.62,-2.375) 2(-7.62,2.375) 3(-5.08,-2.375) 4(-5.08,2.375) 5(-2.54,-2.375) 6(-2.54,2.375) 7(0,-2.375) 8(0,2.375) 9(2.54,-2.375) 10(2.54,2.375) 11(5.08,-2.375) 12(5.08,2.375) 13(7.62,-2.375) 14(7.62,2.375)
MX_HDMI_19P_59_5HD_LOT_LF5
  round 1.854 hole 1.854 unplated: (0,0)
  rect 1.143x1.143 hole 0.737: 1(4.75,6.5)
  round 1.143 hole 0.737: 2(4,5) 3(3.25,6.5) 4(3.25,3.5) 5(2.5,5) 6(1.75,3.5) 7(1.75,6.5) 8(1,5) 9(0.25,6.5) 10(0.25,3.5) 11(-0.5,5) 12(-1.25,3.5) 13(-1.25,6.5) 14(-2,5) 15(-2.75,6.5) 16(-2.75,3.5) 17(-3.5,5) 18(-4.25,3.5) 19(-4.25,6.5)
  oval 1.905x3.124 hole 0.889x2.108: 20(7.25,5.21) 21(-7.25,5.21)
  oval 1.778x2.718 hole 0.762x1.702: 22(7.25,-0.75) 23(-7.25,-0.75)
MX_INDUCTOR_2P_274X260_COLA
  rect 2.489x3.505 smd: 1(-3.1,0) 2(3.1,0)
MX_INDUCTOR_2P_287X260
  rect 2.845x2.997 smd: 1(-3.025,0) 2(3.025,0)
MX_INDUCTOR_2P_453X394_COLA
  rect 4.013x3.988 smd: 1(-4.254,0) 2(4.254,0)
MX_L0402
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_L0402_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_L0603
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
MX_L0603_SMALL_T02
  rect 0.559x0.991 smd: 1(-0.67,0) 2(0.67,0)
MX_LAN_JACK_12P_2H_ALL_SMT
  round 1.245 hole 0.838: 1(3.57,9.25) 2(2.55,10.35) 3(1.53,9.25) 4(0.51,10.35) 5(-0.51,9.25) 6(-1.53,10.35) 7(-2.55,9.25) 8(-3.57,10.35)
  round 1.448 hole 1.041: 9(7.1,12.05) 10(4.56,12.05) 11(-4.56,7.6) 12(-6.85,7.6)
  oval 1.397x2.616 hole 0.991x2.21: 13(10.125,-1.37) 14(-10.125,-1.37)
MX_LED_2P_63X31_EVER
  rect 0.787x0.787 smd: 1(0.75,0) 2(-0.75,0)
MX_LED_2P_63X31_H16
  rect 0.787x0.787 smd: 1(0.75,0) 2(-0.75,0)
MX_MIN_PCI_67P_20_4H
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
MX_MINI_PCI_67P_20_4H_LOTE1
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
MX_PHONE_JACK_6P_2H_COL_LF5
  round 1.143 hole 1.143 unplated: (-3.25,0) (3.25,0)
  oval 1.626x0.965 hole 1.219x0.559: 1(0.25,-1.1)
  oval 0.914x1.575 hole 0.508x1.168: 2(3.85,3.9) 3(-1.35,7) 6(1.85,7)
  oval 0.864x1.524 hole 0.457x1.118: 4(-2.85,5) 5(-4.25,7)
MX_POLYSWITCH_2P_0805_H30
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
MX_PWR_JACK_9P_2HD_FOX_LF5
  round 1.245 hole 1.245 unplated: (0,4.3) (0,0)
  oval 0.914x1.524 hole 0.508x1.118: 1(3.575,0) 2(3.575,4.75) 3(-3.575,0) 4(-3.575,4.75) 5(1.96,7.63) 6(-1.96,7.63)
  oval 0.864x1.473 hole 0.457x1.067: 7(4.04,7.63) 8(-4.04,7.63)
  oval 1.067x1.676 hole 0.66x1.27: 9(0,7.63)
MX_QFN_16P_20_S118_P_2V
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
  round 0.61 hole 0.305: 18(-0.533,-0.533) 19(0.533,0.533)
MX_QFN_20P_16_S122_P_4V
  rect 0.229x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.229 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.521,0.521) 23(0.521,0.521) 24(-0.521,-0.521) 25(0.521,-0.521)
MX_QFN_20P_16_S122_PD_4V
  rect 0.229x0.61 smd: 1(-0.8,-1.345) 2(-0.4,-1.345) 3(0,-1.345) 4(0.4,-1.345) 5(0.8,-1.345) 11(0.8,1.345) 12(0.4,1.345) 13(0,1.345) 14(-0.4,1.345) 15(-0.8,1.345)
  rect 0.61x0.229 smd: 6(1.345,-0.8) 7(1.345,-0.4) 8(1.345,0) 9(1.345,0.4) 10(1.345,0.8) 16(-1.345,0.8) 17(-1.345,0.4) 18(-1.345,0) 19(-1.345,-0.4) 20(-1.345,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.521,0.521) 23(0.521,0.521) 24(-0.521,-0.521) 25(0.521,-0.521)
MX_QFN_32P_16_S157_P_H35_8V
  rect 0.222x0.508 smd: 1(-1.4,-1.901) 8(1.4,-1.901) 17(1.4,1.901) 24(-1.4,1.901)
  rect 0.222x0.61 smd: 2(-1,-1.85) 3(-0.6,-1.85) 4(-0.2,-1.85) 5(0.2,-1.85) 6(0.6,-1.85) 7(1,-1.85) 18(1,1.85) 19(0.6,1.85) 20(0.2,1.85) 21(-0.2,1.85) 22(-0.6,1.85) 23(-1,1.85)
  rect 0.508x0.222 smd: 9(1.901,-1.4) 16(1.901,1.4) 25(-1.901,1.4) 32(-1.901,-1.4)
  rect 0.61x0.222 smd: 10(1.85,-1) 11(1.85,-0.6) 12(1.85,-0.2) 13(1.85,0.2) 14(1.85,0.6) 15(1.85,1) 26(-1.85,1) 27(-1.85,0.6) 28(-1.85,0.2) 29(-1.85,-0.2) 30(-1.85,-0.6) 31(-1.85,-1)
  rect 2.667x2.667 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.029,1.029) 35(-0.521,1.029) 36(0.521,1.029) 37(1.029,1.029) 38(-1.029,-1.029) 39(-0.521,-1.029) 40(0.521,-1.029) 41(1.029,-1.029)
MX_QFN_32P_20_S201_P_4V
  rect 0.279x0.61 smd: 1(-1.75,-2.345) 2(-1.25,-2.345) 3(-0.75,-2.345) 4(-0.25,-2.345) 5(0.25,-2.345) 6(0.75,-2.345) 7(1.25,-2.345) 8(1.75,-2.345) 17(1.75,2.345) 18(1.25,2.345) 19(0.75,2.345) 20(0.25,2.345) 21(-0.25,2.345) 22(-0.75,2.345) 23(-1.25,2.345) 24(-1.75,2.345)
  rect 0.61x0.279 smd: 9(2.345,-1.75) 10(2.345,-1.25) 11(2.345,-0.75) 12(2.345,-0.25) 13(2.345,0.25) 14(2.345,0.75) 15(2.345,1.25) 16(2.345,1.75) 25(-2.345,1.75) 26(-2.345,1.25) 27(-2.345,0.75) 28(-2.345,0.25) 29(-2.345,-0.25) 30(-2.345,-0.75) 31(-2.345,-1.25) 32(-2.345,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.499,1.499) 35(1.499,1.499) 36(-1.499,-1.499) 37(1.499,-1.499)
MX_QFN_48P_16_S240_PAD_9V
  rect 0.229x0.61 smd: 1(-2.2,-2.845) 2(-1.8,-2.845) 3(-1.4,-2.845) 4(-1,-2.845) 5(-0.6,-2.845) 6(-0.2,-2.845) 7(0.2,-2.845) 8(0.6,-2.845) 9(1,-2.845) 10(1.4,-2.845) 11(1.8,-2.845) 12(2.2,-2.845) 25(2.2,2.845) 26(1.8,2.845) 27(1.4,2.845) 28(1,2.845) 29(0.6,2.845) 30(0.2,2.845) 31(-0.2,2.845) 32(-0.6,2.845) 33(-1,2.845) 34(-1.4,2.845) 35(-1.8,2.845) 36(-2.2,2.845)
  rect 0.61x0.229 smd: 13(2.845,-2.2) 14(2.845,-1.8) 15(2.845,-1.4) 16(2.845,-1) 17(2.845,-0.6) 18(2.845,-0.2) 19(2.845,0.2) 20(2.845,0.6) 21(2.845,1) 22(2.845,1.4) 23(2.845,1.8) 24(2.845,2.2) 37(-2.845,2.2) 38(-2.845,1.8) 39(-2.845,1.4) 40(-2.845,1) 41(-2.845,0.6) 42(-2.845,0.2) 43(-2.845,-0.2) 44(-2.845,-0.6) 45(-2.845,-1) 46(-2.845,-1.4) 47(-2.845,-1.8) 48(-2.845,-2.2)
  rect 4.648x4.648 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-2.019,-2.019) 51(0,-2.019) 52(2.019,-2.019) 53(-2.019,0) 54(2.019,0) 55(-2.019,2.019) 56(0,2.019) 57(2.019,2.019) 58(0,0)
MX_QFN_52P_16_S236_PD_4VIA
  rect 0.229x0.508 smd: 1(-2.4,-2.9) 13(2.4,-2.9) 27(2.4,2.9) 39(-2.4,2.9)
  rect 0.229x0.559 smd: 2(-2,-2.875) 3(-1.6,-2.875) 4(-1.2,-2.875) 5(-0.8,-2.875) 6(-0.4,-2.875) 7(0,-2.875) 8(0.4,-2.875) 9(0.8,-2.875) 10(1.2,-2.875) 11(1.6,-2.875) 12(2,-2.875) 28(2,2.875) 29(1.6,2.875) 30(1.2,2.875) 31(0.8,2.875) 32(0.4,2.875) 33(0,2.875) 34(-0.4,2.875) 35(-0.8,2.875) 36(-1.2,2.875) 37(-1.6,2.875) 38(-2,2.875)
  rect 0.508x0.229 smd: 14(2.9,-2.4) 26(2.9,2.4) 40(-2.9,2.4) 52(-2.9,-2.4)
  rect 0.559x0.229 smd: 15(2.875,-2) 16(2.875,-1.6) 17(2.875,-1.2) 18(2.875,-0.8) 19(2.875,-0.4) 20(2.875,0) 21(2.875,0.4) 22(2.875,0.8) 23(2.875,1.2) 24(2.875,1.6) 25(2.875,2) 41(-2.875,2) 42(-2.875,1.6) 43(-2.875,1.2) 44(-2.875,0.8) 45(-2.875,0.4) 46(-2.875,0) 47(-2.875,-0.4) 48(-2.875,-0.8) 49(-2.875,-1.2) 50(-2.875,-1.6) 51(-2.875,-2)
  rect 4.775x4.775 smd: 53(0,0)
  round 0.61 hole 0.305: 54(-2.083,2.083) 55(2.083,2.083) 56(-2.083,-2.083) 57(2.083,-2.083)
MX_QFP_128P_16_S630_H47
  rect 0.191x1.499 smd: 1(-6.2,-7.86) 2(-5.8,-7.86) 3(-5.4,-7.86) 4(-5,-7.86) 5(-4.6,-7.86) 6(-4.2,-7.86) 7(-3.8,-7.86) 8(-3.4,-7.86) 9(-3,-7.86) 10(-2.6,-7.86) 11(-2.2,-7.86) 12(-1.8,-7.86) 13(-1.4,-7.86) 14(-1,-7.86) 15(-0.6,-7.86) 16(-0.2,-7.86) 17(0.2,-7.86) 18(0.6,-7.86) 19(1,-7.86) 20(1.4,-7.86) 21(1.8,-7.86) 22(2.2,-7.86) 23(2.6,-7.86) 24(3,-7.86) 25(3.4,-7.86) 26(3.8,-7.86) 27(4.2,-7.86) 28(4.6,-7.86) 29(5,-7.86) 30(5.4,-7.86) 31(5.8,-7.86) 32(6.2,-7.86) 65(6.2,7.86) 66(5.8,7.86) 67(5.4,7.86) 68(5,7.86) 69(4.6,7.86) 70(4.2,7.86) 71(3.8,7.86) 72(3.4,7.86) 73(3,7.86) 74(2.6,7.86) 75(2.2,7.86) 76(1.8,7.86) 77(1.4,7.86) 78(1,7.86) 79(0.6,7.86) 80(0.2,7.86) 81(-0.2,7.86) 82(-0.6,7.86) 83(-1,7.86) 84(-1.4,7.86) 85(-1.8,7.86) 86(-2.2,7.86) 87(-2.6,7.86) 88(-3,7.86) 89(-3.4,7.86) 90(-3.8,7.86) 91(-4.2,7.86) 92(-4.6,7.86) 93(-5,7.86) 94(-5.4,7.86) 95(-5.8,7.86) 96(-6.2,7.86)
  rect 1.499x0.191 smd: 33(7.86,-6.2) 34(7.86,-5.8) 35(7.86,-5.4) 36(7.86,-5) 37(7.86,-4.6) 38(7.86,-4.2) 39(7.86,-3.8) 40(7.86,-3.4) 41(7.86,-3) 42(7.86,-2.6) 43(7.86,-2.2) 44(7.86,-1.8) 45(7.86,-1.4) 46(7.86,-1) 47(7.86,-0.6) 48(7.86,-0.2) 49(7.86,0.2) 50(7.86,0.6) 51(7.86,1) 52(7.86,1.4) 53(7.86,1.8) 54(7.86,2.2) 55(7.86,2.6) 56(7.86,3) 57(7.86,3.4) 58(7.86,3.8) 59(7.86,4.2) 60(7.86,4.6) 61(7.86,5) 62(7.86,5.4) 63(7.86,5.8) 64(7.86,6.2) 97(-7.86,6.2) 98(-7.86,5.8) 99(-7.86,5.4) 100(-7.86,5) 101(-7.86,4.6) 102(-7.86,4.2) 103(-7.86,3.8) 104(-7.86,3.4) 105(-7.86,3) 106(-7.86,2.6) 107(-7.86,2.2) 108(-7.86,1.8) 109(-7.86,1.4) 110(-7.86,1) 111(-7.86,0.6) 112(-7.86,0.2) 113(-7.86,-0.2) 114(-7.86,-0.6) 115(-7.86,-1) 116(-7.86,-1.4) 117(-7.86,-1.8) 118(-7.86,-2.2) 119(-7.86,-2.6) 120(-7.86,-3) 121(-7.86,-3.4) 122(-7.86,-3.8) 123(-7.86,-4.2) 124(-7.86,-4.6) 125(-7.86,-5) 126(-7.86,-5.4) 127(-7.86,-5.8) 128(-7.86,-6.2)
MX_R0402_SHORT_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_R0402_SMALL_T01
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
MX_R0603_SHORT_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_R0603_SMALL_T01
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
MX_R0805_SHORT_SMALL_T02
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_R0805_SMALL_T02
  rect 0.711x1.397 smd: 1(-0.864,0) 2(0.864,0)
MX_R1206
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
MX_R1206_H26
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
MX_R1508
  rect 0.991x3.759 smd: 1(-1,0) 2(1,0)
MX_S0402_AMAZ_COLAY
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_S0402_AMAZ_COLAY_T01
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
MX_SATA_22P_6HD_RA_LOTE_LF5
  round 1.753 hole 1.753 unplated: (-15,0) (15,0)
  oval 1.194x3.2 hole 0.787x2.794: 1(-21.2,4.65) 2(21.2,4.65)
  round 2.718 hole 2.311: 3(-21.2,0.65) 4(21.2,0.65)
  round 1.092 hole 0.711: P1(-1.905,3) P2(-0.635,3) P3(0.635,3) P4(1.905,2.5) P5(3.175,3) P6(4.445,3) P7(5.715,3) P8(6.985,3) P9(8.255,3) P10(9.525,3) P11(10.795,3) P12(12.065,2.5) P13(13.335,3) P14(14.605,3) P15(15.875,3) S1(-15.875,3) S2(-14.605,3) S3(-13.335,3) S4(-12.065,3) S5(-10.795,3) S6(-9.525,3) S7(-8.255,3)
MX_SC70_6_VISHAY_T01
  custom 0.237x0.237 smd: 1(-0.325,0)
  rect 0.305x0.356 smd: 3(0.65,-0.925) 4(0.65,0.925)
  rect 0.229x0.864 smd: 7(0.668,0.04)
MX_SC70_S6_87X55
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
MX_SI7850DP_COLAY
  rect 0.61x1.27 smd: 1(-1.905,-2.67) 2(-0.635,-2.67) 3(0.635,-2.67) 4(1.905,-2.67)
  custom 1.105x1.105 smd: 5(0,0.69)
MX_SI7900EDN_COLAY
  rect 0.305x0.914 smd: 1(-0.975,-1.608) 2(-0.325,-1.608) 3(0.325,-1.608) 4(0.975,-1.608)
  custom 0.603x0.603 smd: 5(-0.025,0.859)
MX_SMA
  rect 1.956x1.499 smd: 1(2.25,0) 2(-2.25,0)
MX_SMT_NUT_CT217B63D47_NSP
  round 5.512 hole 1.194: 1(0,0)
MX_SO8_H69
  rect 0.635x1.549 smd: 1(-1.91,-2.83) 2(-0.64,-2.83) 3(0.63,-2.83) 4(1.9,-2.83) 5(1.91,2.83) 6(0.64,2.83) 7(-0.63,2.83) 8(-1.9,2.83)
MX_SOCKET1151_FOXN_3HD
  round 3.81 hole 3.81 unplated: (-35.21,0) (25.81,18) (25.81,-18)
  round 0.508 smd: A4(-16.187,18.288) A5(-15.273,18.288) AT40(18.931,-14.63) AU1(-18.931,-14.63) AU39(18.016,-15.545) AU40(18.931,-15.545) AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW3(-17.102,-16.459) AW37(16.187,-17.374) AW38(17.102,-17.374) AY3(-17.102,-17.374) AY4(-16.187,-17.374) B3(-17.102,17.374) B4(-16.187,17.374) B37(16.187,16.459) B38(17.102,16.459) B39(18.016,16.459) C2(-18.016,16.459) C3(-17.102,16.459) C39(18.016,15.545) C40(18.931,15.545) D1(-18.931,15.545) D2(-18.016,15.545) D40(18.931,14.63) E40(18.931,13.716)
  round 0.432 smd: A6(-14.359,18.288) A7(-13.444,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.673,18.288) A30(7.587,18.288) AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA8(-12.53,0) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AA37(16.187,-0.914) AA38(17.102,-0.914) AB5(-15.273,-0.914) AB6(-14.359,-0.914) AB7(-13.444,-0.914) AB8(-12.53,-0.914) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AB37(16.187,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC8(-12.53,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.187,-2.743) AD3(-17.102,-2.743) AD4(-16.187,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD8(-12.53,-2.743) AD33(12.53,-3.658) AD34(13.444,-3.658) AD35(14.359,-3.658) AD36(15.273,-3.658) AD37(16.187,-3.658) AE3(-17.102,-3.658) AE4(-16.187,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE8(-12.53,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.187,-4.572) AE38(17.102,-4.572) AF4(-16.187,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF8(-12.53,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.187,-5.486) AF38(17.102,-5.486) AG4(-16.187,-5.486) AG5(-15.273,-5.486) AG6(-14.359,-5.486) AG7(-13.444,-5.486) AG8(-12.53,-5.486) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.187,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.187,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.187,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.187,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.615,-7.315) AJ11(-7.587,-8.23) AJ12(-6.673,-8.23) AJ13(-5.758,-8.23) AJ14(-4.844,-8.23) AJ15(-3.929,-8.23) AJ16(-3.015,-8.23) AJ17(-2.101,-8.23) AJ18(-1.186,-8.23) AJ19(-0.272,-8.23) AJ20(0.643,-8.23) AJ21(1.557,-8.23) AJ22(2.471,-8.23) AJ23(3.386,-8.23) AJ24(4.3,-8.23) AJ25(5.215,-8.23) AJ26(6.129,-8.23) AJ27(7.043,-8.23) AJ28(7.958,-8.23) AJ29(8.872,-8.23) AJ30(9.787,-8.23) AJ31(10.701,-8.23) AJ32(11.615,-8.23) AJ33(12.53,-8.23) AJ34(13.444,-8.23) AJ35(14.359,-8.23) AJ36(15.273,-8.23) AJ37(16.187,-8.23) AJ38(17.102,-8.23) AK3(-17.102,-8.23) AK4(-16.187,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.615,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.673,-9.144) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.101,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.471,-9.144) AK23(3.386,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.043,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.615,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.187,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.187,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.615,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.673,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.101,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.471,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.043,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.615,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.187,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.058) AM4(-16.187,-10.058) AM5(-15.273,-10.058) AM6(-14.359,-10.058) AM7(-13.444,-10.058) AM8(-12.53,-10.058) AM9(-11.615,-10.058) AM10(-10.701,-10.058) AM11(-7.587,-10.973) AM12(-6.673,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.101,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.471,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.043,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.615,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.187,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.187,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.615,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.673,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.101,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.471,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.043,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.615,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.187,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.187,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.615,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.802) AP12(-6.673,-12.802) AP13(-5.758,-12.802) AP14(-4.844,-12.802) AP15(-3.929,-12.802) AP16(-3.015,-12.802) AP17(-2.101,-12.802) AP18(-1.186,-12.802) AP19(-0.272,-12.802) AP20(0.643,-12.802) AP21(1.557,-12.802) AP22(2.471,-12.802) AP23(3.386,-12.802) AP24(4.3,-12.802) AP25(5.215,-12.802) AP26(6.129,-12.802) AP27(7.043,-12.802) AP28(7.958,-12.802) AP29(8.872,-12.802) AP30(9.787,-12.802) AP31(10.701,-12.802) AP32(11.615,-12.802) AP33(12.53,-12.802) AP34(13.444,-12.802) AP35(14.359,-12.802) AP36(15.273,-12.802) AP37(16.187,-12.802) AP38(17.102,-12.802) AR3(-17.102,-12.802) AR4(-16.187,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.615,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.673,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.101,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.471,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.043,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.615,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.187,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.187,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.615,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.673,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.101,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.471,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.043,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.615,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.187,-14.63) AT38(17.102,-14.63) AU3(-17.102,-14.63) AU4(-16.187,-14.63) AU5(-15.273,-14.63) AU6(-14.359,-14.63) AU7(-13.444,-14.63) AU8(-12.53,-14.63) AU9(-11.615,-14.63) AU10(-10.701,-14.63) AU11(-7.587,-15.545) AU12(-6.673,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.101,-15.545) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.043,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.615,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.187,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.187,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.615,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.673,-16.459) AV13(-5.758,-16.459) AV14(-4.844,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV37(16.187,-16.459) AW4(-16.187,-16.459) AW9(-11.615,-16.459) AW10(-10.701,-16.459) AW11(-7.587,-17.374) AW12(-6.673,-17.374) AW13(-5.758,-17.374) AW14(-4.844,-17.374) AY10(-10.701,-17.374) B5(-15.273,17.374) B6(-14.359,17.374) B7(-13.444,17.374) B25(3.015,17.374) B26(3.929,17.374) B27(4.844,17.374) B28(5.758,17.374) B29(6.673,17.374) B30(7.587,17.374) B31(10.701,16.459) B32(11.615,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) B36(15.273,16.459) C4(-16.187,16.459) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C8(-12.53,16.459) C9(-11.615,16.459) C12(-8.872,16.459) C13(-7.958,16.459) C14(-7.043,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.673,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.615,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) C36(15.273,15.545) C37(16.187,15.545) C38(17.102,15.545) D3(-17.102,15.545) D4(-16.187,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D8(-12.53,15.545) D9(-11.615,15.545) D10(-10.701,15.545) D11(-9.787,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.043,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D18(-3.386,15.545) D24(2.101,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.673,15.545) D30(7.587,15.545) D31(10.701,14.63) D32(11.615,14.63) D33(12.53,14.63) D34(13.444,14.63) D35(14.359,14.63) D36(15.273,14.63) D37(16.187,14.63) D38(17.102,14.63) D39(18.016,14.63) E3(-17.102,14.63) E4(-16.187,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.615,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.043,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E18(-3.386,14.63) E19(-2.471,14.63) E21(-0.643,14.63) E23(1.186,14.63) E24(2.101,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.673,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.615,13.716) E33(12.53,13.716) E34(13.444,13.716) E35(14.359,13.716) E36(15.273,13.716) E37(16.187,13.716) E38(17.102,13.716) E39(18.016,13.716) F4(-16.187,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.615,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.043,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F18(-3.386,13.716) F19(-2.471,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.101,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.673,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.615,12.802) F33(12.53,12.802) F34(13.444,12.802) F35(14.359,12.802) F36(15.273,12.802) F37(16.187,12.802) F38(17.102,12.802) F39(18.016,12.802) F40(18.931,12.802) G3(-17.102,12.802) G4(-16.187,12.802) G5(-15.273,12.802) G6(-14.359,12.802) G7(-13.444,12.802) G8(-12.53,12.802) G9(-11.615,12.802) G10(-10.701,12.802) G11(-9.787,12.802) G12(-8.872,12.802) G13(-7.958,12.802) G14(-7.043,12.802) G15(-6.129,12.802) G16(-5.215,12.802) G17(-4.3,12.802) G18(-3.386,12.802) G19(-2.471,12.802) G20(-1.557,12.802) G21(-0.643,12.802) G22(0.272,12.802) G23(1.186,12.802) G24(2.101,12.802) G25(3.015,12.802) G26(3.929,12.802) G27(4.844,12.802) G28(5.758,12.802) G29(6.673,12.802) G30(7.587,12.802) G31(10.701,11.887) G32(11.615,11.887) G33(12.53,11.887) G34(13.444,11.887) G35(14.359,11.887) G36(15.273,11.887) G37(16.187,11.887) G38(17.102,11.887) G39(18.016,11.887) G40(18.931,11.887) H4(-16.187,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.615,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.043,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H18(-3.386,11.887) H19(-2.471,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.101,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.673,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.615,10.973) H33(12.53,10.973) H34(13.444,10.973) H35(14.359,10.973) H36(15.273,10.973) H37(16.187,10.973) H38(17.102,10.973) H39(18.016,10.973) H40(18.931,10.973) J3(-17.102,10.973) J4(-16.187,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.615,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.043,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J18(-3.386,10.973) J19(-2.471,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.101,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.673,10.973) J30(7.587,10.973) J31(10.701,10.058) J32(11.615,10.058) J33(12.53,10.058) J34(13.444,10.058) J35(14.359,10.058) J36(15.273,10.058) J37(16.187,10.058) J38(17.102,10.058) J39(18.016,10.058) J40(18.931,10.058) K4(-16.187,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.615,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.043,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K18(-3.386,10.058) K19(-2.471,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.101,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.673,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.615,9.144) K33(12.53,9.144) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.187,9.144) K38(17.102,9.144) K39(18.016,9.144) K40(18.931,9.144) L3(-17.102,9.144) L4(-16.187,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.615,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.043,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L18(-3.386,9.144) L19(-2.471,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.101,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.673,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.615,8.23) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.187,8.23) L38(17.102,8.23) L39(18.016,8.23) L40(18.931,8.23) M4(-16.187,8.23) M5(-15.273,8.23) M6(-14.359,8.23) M7(-13.444,8.23) M8(-12.53,8.23) M9(-11.615,8.23) M10(-10.701,8.23) M11(-9.787,8.23) M12(-8.872,8.23) M13(-7.958,8.23) M14(-7.043,8.23) M15(-6.129,8.23) M16(-5.215,8.23) M17(-4.3,8.23) M18(-3.386,8.23) M19(-2.471,8.23) M20(-1.557,8.23) M21(-0.643,8.23) M22(0.272,8.23) M23(1.186,8.23) M24(2.101,8.23) M25(3.015,8.23) M26(3.929,8.23) M27(4.844,8.23) M28(5.758,8.23) M29(6.673,8.23) M30(7.587,8.23) M32(11.615,7.315) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.187,7.315) M38(17.102,7.315) M39(18.016,7.315) M40(18.931,7.315) N3(-17.102,7.315) N4(-16.187,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.187,6.401) N38(17.102,6.401) N39(18.016,6.401) N40(18.931,6.401) P4(-16.187,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P33(12.53,5.486) P34(13.444,5.486) P35(14.359,5.486) P36(15.273,5.486) P37(16.187,5.486) P38(17.102,5.486) P39(18.016,5.486) P40(18.931,5.486) R3(-17.102,5.486) R4(-16.187,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) R37(16.187,4.572) R38(17.102,4.572) R39(18.016,4.572) R40(18.931,4.572) T4(-16.187,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T33(12.53,3.658) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.187,3.658) T38(17.102,3.658) T39(18.016,3.658) T40(18.931,3.658) U4(-16.187,3.658) U5(-15.273,3.658) U6(-14.359,3.658) U7(-13.444,3.658) U8(-12.53,3.658) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.187,2.743) U38(17.102,2.743) U39(18.016,2.743) U40(18.931,2.743) V4(-16.187,2.743) V5(-15.273,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V8(-12.53,2.743) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.187,1.829) V38(17.102,1.829) V39(18.016,1.829) V40(18.931,1.829) W4(-16.187,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W8(-12.53,1.829) W33(12.53,0.914) W34(13.444,0.914) W35(14.359,0.914) W36(15.273,0.914) W37(16.187,0.914) W38(17.102,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y8(-12.53,0.914) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.187,0) Y38(17.102,0)
  oval 0.356x0.457 smd: A11(-9.787,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.043,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) A23(1.186,18.288) A24(2.101,18.288) AU22(2.471,-15.545) AU23(3.386,-15.545) AV15(-3.929,-16.459) AV16(-3.015,-16.459) AV17(-2.101,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.471,-16.459) AV23(3.386,-16.459) AV26(6.129,-16.459) AV27(7.043,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AV32(11.615,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW15(-3.929,-17.374) AW16(-3.015,-17.374) AW17(-2.101,-17.374) AW18(-1.186,-17.374) AW23(3.386,-17.374) AW24(4.3,-17.374) AW25(5.215,-17.374) AW26(6.129,-17.374) AW27(7.043,-17.374) AW28(7.958,-17.374) AW29(8.872,-17.374) AW30(9.787,-17.374) AW31(10.701,-17.374) AW32(11.615,-17.374) AW33(12.53,-17.374) AW34(13.444,-17.374) AW35(14.359,-17.374) AW36(15.273,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY9(-11.615,-17.374) AY11(-7.587,-18.288) AY12(-6.673,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.101,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.043,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) AY31(10.701,-18.288) B8(-12.53,17.374) B9(-11.615,17.374) B10(-10.701,17.374) B11(-9.787,17.374) B12(-8.872,17.374) B13(-7.958,17.374) B14(-7.043,17.374) B15(-6.129,17.374) B16(-5.215,17.374) B17(-4.3,17.374) B18(-3.386,17.374) B23(1.186,17.374) B24(2.101,17.374) C10(-10.701,16.459) C11(-9.787,16.459) C18(-3.386,16.459) C19(-2.471,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) C23(1.186,16.459) C24(2.101,16.459) D19(-2.471,15.545) D20(-1.557,15.545) D21(-0.643,15.545) D22(0.272,15.545) D23(1.186,15.545) E20(-1.557,14.63) E22(0.272,14.63)
  oval 0.457x0.356 smd: AA3(-17.102,0) AA4(-16.187,0) AB3(-17.102,-0.914) AB4(-16.187,-0.914) AB38(17.102,-1.829) AB39(18.016,-1.829) AB40(18.931,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC4(-16.187,-1.829) AC38(17.102,-2.743) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD38(17.102,-3.658) AD39(18.016,-3.658) AD40(18.931,-3.658) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF3(-17.102,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.486) AG2(-18.016,-5.486) AG3(-17.102,-5.486) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.23) AJ40(18.931,-8.23) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.058) AM2(-18.016,-10.058) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.802) AP40(18.931,-12.802) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AU2(-18.016,-14.63) E1(-18.931,14.63) E2(-18.016,14.63) F1(-18.931,13.716) F2(-18.016,13.716) F3(-17.102,13.716) G1(-18.931,12.802) G2(-18.016,12.802) H1(-18.931,11.887) H2(-18.016,11.887) H3(-17.102,11.887) J1(-18.931,10.973) J2(-18.016,10.973) K1(-18.931,10.058) K2(-18.016,10.058) K3(-17.102,10.058) L1(-18.931,9.144) L2(-18.016,9.144) M1(-18.931,8.23) M2(-18.016,8.23) M3(-17.102,8.23) N1(-18.931,7.315) N2(-18.016,7.315) P1(-18.931,6.401) P2(-18.016,6.401) P3(-17.102,6.401) R1(-18.931,5.486) R2(-18.016,5.486) T1(-18.931,4.572) T2(-18.016,4.572) T3(-17.102,4.572) U1(-18.931,3.658) U2(-18.016,3.658) U3(-17.102,3.658) V1(-18.931,2.743) V2(-18.016,2.743) V3(-17.102,2.743) W1(-18.931,1.829) W2(-18.016,1.829) W3(-17.102,1.829) Y3(-17.102,0.914) Y4(-16.187,0.914)
