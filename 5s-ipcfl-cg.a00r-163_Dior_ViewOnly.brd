# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_AUDIO: length 94.5
  TOP w0.203: v1(21.56,19.88) 21.3,19.88 21.14,20.04 U6.38
  TOP w0.229: v1(15.14,19.04) 15.14,18.81 15.28,18.67 15.6,18.67 15.69,18.76 U6.25
  TOP w0.457: AC97.2 11.8,23.34 v1(11.45,23.69) 11.45,23.8 11.91,24.25 AC98.2 ; C4306.2 34.1,14 34.29,13.81 v1(34.57,13.81) ; C4304.2 36.69,14.06 v1(36.32,14.06) ; R123.2 v1(40.19,13.99)
  TOP w0.508: v1(36.14,13.2) 36.23,13.28 D4305.1 ; AQ3.2 26.95,15.21 27.35,14.8 v1(27.35,14.62) ; C4305.2 26.76,14.16 v1(26.77,14.16) ; D4303.1 35.18,12.93 35.18,12.79 v1(34.73,12.35) ; C4308.2 39.41,17.22 v1(39.32,17.31) ; D4307.1 32.76,14.39 v1(33.2,14.82) ; C4302.2 41.48,12.46 41.76,12.18 ; AC85.2 10.2,21.55 v1(10.08,21.55) ; D4306.1 25.97,12.77 25.77,12.57 25.77,11.58 J301.6 ; D4302.1 39.48,12.8 v1(39.8,12.49) ; C4301.2 45.15,13.99 v1(45.41,13.99) ; v1(45.41,14.62) 45.41,15.17 C4307.2 ; v1(45.36,12.46) 45.07,12.75 D4301.1 ; v1(24.94,17.74) 24.76,17.92 AC90.2 ; D4308.1 28.05,14.08 v1(27.95,14.18) ; R124.2 v1(42.2,15.61)
  TOP w0.635: 34.4,4.71 J301.8 35.11,5.75 ; 42.32,9.48 J89.6 ; J89.6 43.06,10.55 ; J89.6 41.58,10.55 ; J89.6 42.32,11.62 ; J89.1 40.72,3.21 ; J89.1 41.81,2.45 ; J89.1 40.72,1.69 ; J89.1 39.63,2.45
  IN1 w0.254: v1(34.57,13.81) 35.46,13.81
  IN1 w0.635: 40.72,1.69 J89.1 ; J89.1 39.63,2.45 ; J89.1 40.72,3.21 ; J89.1 41.81,2.45 ; J301.7 25.2,5.71 ; J301.7 24.49,6.75 ; J301.7 25.2,7.79 ; J301.7 25.91,6.75 ; 41.58,10.55 J89.6 ; J89.6 42.32,11.62 ; J89.6 42.32,9.48 ; J89.6 43.06,10.55 ; J301.8 33.69,5.75 ; J301.8 35.11,5.75 ; J301.8 34.4,6.79 ; J301.8 34.4,4.71 ; J301.6 25.29,11.35 ; J301.6 26,12.39 ; J301.6 26.71,11.35 ; J301.6 26,10.31 ; 35.51,10.55 J89.5 ; J89.5 36.22,9.51 ; J89.5 36.22,11.59
  IN2 w0.635: J301.8 33.69,5.75 ; J301.8 34.4,6.79 ; J301.8 35.11,5.75 ; J301.8 34.4,4.71 ; J89.5 36.22,11.59 ; J89.5 36.93,10.55 ; J89.5 36.22,9.51 ; J89.5 35.51,10.55 ; 41.58,10.55 J89.6 ; J89.6 42.32,9.48 ; J89.6 42.32,11.62 ; J89.6 43.06,10.55 ; 40.72,1.69 J89.1 ; J89.1 41.81,2.45 ; J89.1 39.63,2.45 ; J89.1 40.72,3.21 ; J301.7 25.2,5.71 ; J301.7 25.91,6.75 ; J301.7 24.49,6.75 ; J301.7 25.2,7.79 ; J301.6 26,12.39 ; J301.6 26.71,11.35 ; J301.6 25.29,11.35 ; J301.6 26,10.31
  BOTTOM w0.635: 26,6.75 J301.7 ; J301.7 25.2,7.88 ; J301.7 24.4,6.75 ; J89.5 37.02,10.55 ; J89.5 35.42,10.55 ; J89.5 36.22,9.42 ; J89.5 36.22,11.68 ; J89.6 43.15,10.55 ; J89.6 42.32,11.71 ; J89.6 42.32,9.39 ; J89.6 41.49,10.55 ; J301.8 34.4,6.88 ; J301.8 34.4,4.62 ; J301.8 35.2,5.75 ; J301.8 33.6,5.75 ; 26,10.22 J301.6 25.2,11.35 ; 39.54,2.45 J89.1 ; J89.1 40.72,1.6 ; J89.1 41.9,2.45 ; J89.1 40.72,3.3
  vias: v1(8.18,18.02) v1(11.22,19.8) v1(11.71,14.82) v1(12.34,14.82) v1(16.31,14.87) v1(16.97,14.77) v1(23.38,6.6) v1(24.88,9.27) v1(25.51,1.01) v1(26.78,4.95) v1(28.81,0.89) v1(29.03,3.98) v1(29.06,7.03) v1(29.06,5.53) v1(29.41,15.2) v1(30.43,17.97) v1(30.48,10.02) v1(30.46,0.89) v1(30.86,3.47) v1(31.11,6.95) v1(31.19,5.1) v1(31.32,17.67) v1(31.75,11.42) v1(31.75,9.03) v1(32.11,0.89) v1(32.21,2.23) v1(33.04,10.02) v1(32.99,8.47) v1(33.73,18.15) v1(34.36,18.15) v1(34.53,3.02) v1(35.04,0.89) v1(37.19,0.89) v1(37.77,5.65) v1(38.05,17.34) v1(38.68,17.34) v1(38.73,3.24) v1(39.1,0.89) v1(39.27,8.12) v1(40.49,10.2) v1(40.94,5.81) v1(42.27,0.89) v1(42.57,4.89) v1(42.95,7.51) v1(42.87,2.2) v1(43.05,12.18) v1(44.31,0.89) v1(44.63,4.87) v1(44.68,15.94) v1(45.31,15.92) v1(45.34,11.83) v1(45.29,10.45) v1(45.29,9.79) v1(45.29,9.13) v1(45.29,8.5) v1(45.96,5.2) v1(45.96,0.89) v2(26.08,16.07)
PVDD: length 0.8
  BOTTOM w0.102: v2(22.99,23.36) 22.99,24.09 v1(22.91,24.17)
V5_ALW_MON: length 27.8
  IN1 w0.102: v1(33.02,111.29) 35.01,109.3 37.21,109.3 v1(37.68,109.77)
  IN2 w0.102: v1(33.02,111.29) 32.07,110.34 31.83,110.34 30.24,108.76 29.21,108.76 28.13,107.67 25.95,107.67 24.57,106.29 24.57,105.07 23.58,104.08 23.58,101.98 v1(22.73,101.13)
  BOTTOM w0.102: O2Q4.3 38.92,110.16 38.67,109.91 38.67,109.64 R93115.1 OR152.2 37.68,109.54 v1(37.68,109.77) ; v1(33.02,111.29) 33.53,110.78 v2(33.53,110.71) ; v1(22.73,101.13) 22.76,101.16 U104.15
VCC_SENSE: length 115.7
  TOP w0.203: v1(140.91,127.95) 140.49,127.52 XU1.C38
  TOP w0.229: v1(80.57,164.59) 81.06,165.08 81.06,166.14 81.76,166.84 84.03,166.84 PR89023.1
  IN2 w0.203: v1(140.91,127.95) 141.57,127.95 147.65,134.02 147.65,149.67 146.38,150.94 146.38,153.3 148.66,155.59 148.66,158.8 147.79,159.68 145.89,159.68 145.53,159.31 143.32,159.31 142.94,159.69 135.52,159.69 135.28,159.93 129.89,159.93 129.64,159.68 126.47,159.68 125.61,158.82 121.75,158.82 121.24,159.32 105.39,159.32 103.99,160.72 99.82,160.72 96.38,164.16 94.72,164.16 94.39,163.83 88.96,163.83 88.2,164.59 v1(80.57,164.59)
  BOTTOM w0.254: v1(80.57,164.59) 80.75,164.77 v2(80.75,166.41)
VCCGT_SENSE: length 98.4
  TOP w0.254: v1(140.95,124.34) XU1.F39 ; v1(101.27,163.92) 101.27,164.24 PR89050.1
  IN2 w0.203: v1(140.95,124.34) 142.4,125.79 142.4,126.77 148.84,133.21 148.84,149.39 149.99,150.54 149.99,155.01 149.58,155.42 149.58,159.31 148.29,160.59 145.51,160.59 145.15,160.23 143.83,160.23 143.45,160.61 136.21,160.61 133.39,163.43 132.37,163.43 131.28,164.52 128.87,164.52 127.73,165.66 123.08,165.66 122.3,164.87 121.26,164.87 120,163.61 115.44,163.61 114.73,162.9 114.73,160.53 114.53,160.33 105.9,160.33 102.57,163.66 101.91,163.66 101.67,163.9 101.29,163.9 v1(101.27,163.92)
  BOTTOM w0.254: v2(100.89,165.37) 101.27,164.99 v1(101.27,163.92)
VCCHDA: length 2.5
  TOP w0.254: v1(41.38,98.77) 41.48,98.66 U1.BB14
  BOTTOM w0.381: HR425.2 40.46,99.1 v2(40.64,98.92) 40.79,98.77 v1(41.38,98.77)
VCCIO_PWRGD: length 166.6
  TOP w0.254: PU3.5 50.02,134.25 49.49,133.72 49.12,133.72 v1(49,133.59) ; v1(82.83,74.41) 82.44,74.8 R5.1
  IN1 w0.254: v1(90.32,130.89) 90.32,131.13 89.46,131.99 88.56,131.99 88.24,132.31 88.24,132.85 87.74,133.35 87.22,133.35 86.73,133.84 85.91,133.84 81.89,137.87 77.13,137.87 76.92,138.08 v1(76.88,138.08)
  IN2 w0.254: v1(49,133.59) 51.08,131.51 51.71,131.51 51.87,131.35 56.27,131.35 57.15,132.22 60.27,132.22 62.16,134.11 62.83,134.11 63.71,135 64.97,135 65.27,135 69.22,135 73.23,139.01 74.94,139.01 76.09,140.16 76.51,140.16 76.88,139.78 v1(76.88,138.08) 77.69,138.08 80.44,140.82 80.44,141.27 81.29,142.13 82.3,142.13 83.06,142.89 83.06,147.08 83.01,147.12 83.01,154.02 v1(83.13,154.14)
  BOTTOM w0.229: PU89001.2 89.79,166 89.57,166.22 89.17,166.22
  BOTTOM w0.254: v1(90.32,130.89) 90.32,130.55 93.33,127.53 93.33,124.29 93.92,123.7 93.92,122.66 95.82,120.75 95.82,119.32 93.64,117.14 93.64,110.11 87.23,103.71 87.23,97.15 90.5,93.89 90.5,78.87 87,75.37 86.61,75.37 v2(85.65,74.41) v1(82.83,74.41) ; 89.17,166.22 89.14,166.2 88.64,166.2 88.64,166.19 87.58,166.19 87.3,166.47 87.3,167.24 PC89007.1 PR89008.2 85.16,168.46 84.53,168.46 84.13,168.05 82.67,168.05 82.03,167.41 82.03,166.92 82.46,166.5 82.46,162.72 82.93,162.25 82.93,159.1 83.52,158.51 83.52,156.65 83.79,156.38 83.79,154.74 83.19,154.14 v1(83.13,154.14)
VCCIO_PWRGD_DISCH_A: length 4.4
  TOP w0.254: Q6.3 83.26,73.09 81.6,74.75 R5.2 81.6,75.75 v2(82.02,76.16)
VCCIO_SENSE: length 91.5
  TOP w0.254: v1(51.2,130.66) 50.45,131.41 48.58,131.41 PR37.1 ; XU1.AF4 107.19,107.43 v1(106.72,107.91)
  IN1 w0.254: v1(75.8,138.55) 75.85,138.55 75.87,138.57 77.58,138.57 77.93,138.23 82.03,138.23 86.04,134.21 86.86,134.21 87.37,133.71 88.35,133.71 90.46,131.6 94.1,131.6 94.33,131.37 96.83,131.37 v1(97.18,131.03)
  IN2 w0.254: v1(51.2,130.66) 51.23,130.63 56.57,130.63 57.44,131.51 60.56,131.51 62.45,133.4 63.13,133.4 63.81,134.08 64.02,134.29 69.52,134.29 72.89,137.66 75.37,137.66 75.8,138.1 v1(75.8,138.55)
  BOTTOM w0.254: v1(97.18,131.03) 97.43,131.28 97.79,131.28 99.66,129.41 99.84,129.41 100.6,128.65 100.6,126.18 100.75,126.03 100.75,118.47 98.26,115.98 98.26,110.09 99.82,108.53 106.1,108.53 v1(106.72,107.91) ; v2(51.38,131.38) 51.38,130.84 v1(51.2,130.66)
VCCMPHY_SENSE: length 44.6
  TOP w0.102: U1.K47 56.92,81.72 56.92,80.56 57.96,79.52 57.96,79.29 58.18,79.07
  TOP w0.254: v1(73.94,63.21) 73.81,63.33 R99522.2 ; 58.18,79.07 58.75,79.07 v1(58.89,79.21)
  IN2 w0.254: v1(73.94,63.21) 74.78,62.37 76.75,62.37 78.51,64.13 78.51,64.35 78.99,64.84 78.99,68.42 v1(79.7,69.13) ; v1(58.89,79.21) 59.76,79.21 62.1,76.88 64.27,76.88 v1(64.84,76.3)
  BOTTOM w0.254: v1(64.84,76.3) 65.12,76.3 67.05,74.36 67.05,72.33 67.98,71.41 67.99,71.41 69.1,70.29 69.1,70.27 69.24,70.13 69.27,70.13 69.28,70.12 70.47,70.12 70.79,69.8 75.96,69.8 77.16,71 79.44,71 v2(79.86,70.58) 80.08,70.35 80.08,69.51 v1(79.7,69.13)
VCCSA_PWRGD: length 304
  TOP w0.254: v1(31.49,37.33) 32.1,36.72 32.75,36.72 33.31,36.16 R70296.1 ; v1(49.1,134.23) 49.1,134.97 49.31,135.18 PU3.4 ; v1(93.7,36.69) 94.03,36.36 98.18,36.36 101.27,39.45 110.07,39.45 113.75,35.77 135.68,35.77 136.3,36.38 142.24,36.38 151.23,27.39 R93112.2
  IN1 w0.254: v1(76.58,142) 76.73,142 77.33,141.4 79.86,141.4 80.7,140.56 83,140.56 85.02,138.55 85.76,138.55 88.26,136.04 88.81,136.04 90.24,134.61 90.98,134.61 91.51,134.08 v1(91.72,134.08)
  IN2 w0.254: v1(49.1,134.23) 49.99,133.34 51.18,133.34 51.33,133.19 52.07,133.19 52.19,133.07 52.95,133.07 53.24,133.36 53.24,135.11 54.98,136.86 67.02,136.86 71.64,141.48 74.38,141.48 74.55,141.31 75.84,141.31 76.53,142.01 76.57,142.01 v1(76.58,142) ; v1(31.49,37.33) 31.99,36.83 32.44,36.83 32.63,37.02 47.35,37.02 48.69,35.68 65.17,35.68 65.63,36.13 65.63,38.57 67.58,40.52 76.41,40.52 76.66,40.28 86.8,40.28 v1(87.16,40.63) 91.09,36.69 v1(93.7,36.69)
  BOTTOM w0.254: v1(91.72,134.08) 91.95,134.08 92.75,133.28 92.75,132.51 93.93,131.33 93.93,129.79 96.2,127.52 96.2,125.97 96.98,125.2 96.98,124.77 97.33,124.41 97.33,122.92 98.35,121.91 98.35,119.17 95.78,116.6 95.78,107.9 89.64,101.75 89.64,96.49 91.81,94.32 91.81,78.64 88,74.82 88,72.76 86.57,71.34 86.57,71 86.56,70.98 86.56,60.62 86.57,60.61 86.57,57.33 v2(84.9,55.65) 84.77,55.53 84.77,52.97 87.16,50.59 v1(87.16,40.63)
VCCSA_PWRGD_LED_B: length 4.9
  TOP w0.254: Q93036.1 162.25,28.16 162.18,28.23 R93112.1 159.86,28.23 v1(159.27,28.83)
  BOTTOM w0.254: v2(158.8,28.19) 158.8,28.36 v1(159.27,28.83)
VCCSA_PWRGD_LED_C: length 5
  TOP w0.254: v1(160.49,29.94) 160.49,30.33 161.12,30.96 R93111.2 162.75,30.96 162.94,30.76 Q93036.3
  BOTTOM w0.254: v2(159.66,29.94) v1(160.49,29.94)
VCCSA_PWRGD_LED_E: length 3.7
  TOP w0.254: Q93036.2 164.93,27.66 v1(165.38,27.22) 165.85,27.22 CR6.1
  BOTTOM w0.254: v2(164.06,27.22) v1(165.38,27.22)
VCCSA_PWRGD_R: length 6.2
  TOP w0.254: R70296.2 32.47,33.84 v2(32.76,33.56) R70295.2 R6501.2 C941488.1 29.74,34.51 29.93,34.7 Q9438.1
VCCSA_PWRGD_R_C: length 7.5
  TOP w0.254: v2(32.46,35.55) 32.36,35.65 Q9438.3 28.14,34.81 27.91,34.58 R70297.2 R70298.1
VCCSA_SENSE: length 100.1
  TOP w0.254: XU1.AD5 108.11,109.28 v1(107.66,109.73) ; PR45.2 44.38,131.3 v1(44.21,131.13)
  IN1 w0.254: v1(97.21,132.42) 96.87,132.08 94.63,132.08 94.4,132.31 90.76,132.31 88.65,134.42 87.74,134.42 87.24,134.93 86.7,134.93 85.93,135.7 85.93,136.24 85.64,136.53 84.74,136.53 82.33,138.94 78.22,138.94 77.49,139.66 v1(76.3,139.66)
  IN2 w0.254: v1(76.3,139.66) 76.3,138.04 74.01,135.75 71.58,135.75 69.76,133.94 64.17,133.94 63.28,133.05 62.6,133.05 60.71,131.15 57.59,131.15 56.71,130.28 55.56,130.28 54.85,129.57 46.72,129.57 45.16,131.13 v1(44.21,131.13)
  BOTTOM w0.254: v1(107.66,109.73) 107.16,109.24 100.11,109.24 98.97,110.38 98.97,115.69 101.46,118.17 101.46,126.33 101.31,126.48 101.31,128.95 100.14,130.12 99.97,130.12 97.89,132.2 97.43,132.2 v1(97.21,132.42) ; v2(77.05,140.82) 77.05,140.41 v1(76.3,139.66)
VCCSA_SENSE_R: length 13.9
  TOP w0.254: PR41.2 47.29,137.94 47.47,138.12 PC36.1 46.04,138.99 v1(45.74,138.7) 45.06,138.01 45.06,136.54 44.83,136.31 44.83,134.95 44.97,134.81 46.06,134.81 46.22,134.97 PC37.1 PR44.2 46.29,133.75 46.29,133.68 46.08,133.47 45.76,133.47 PR43.1 45.34,133.05 45.34,132.68 45.22,132.57 PR45.1
  BOTTOM w0.254: v2(45.71,139.45) 45.71,138.74 v1(45.74,138.7)
VCCST_PWRGD: length 98.4
  TOP w0.102: 104.32,115.99 105.01,115.99 XU1.U2
  TOP w0.127: 104.32,115.99 104.32,115.99 102.98,117.33 v1(102.98,121.12) ; R4.1 84.07,76.14 83.86,76.35 v1(83.42,76.35)
  IN1 w0.127: v1(86.49,117.01) 92.3,117.01 94.84,119.55 v1(95.32,119.55) 101.41,119.55 v1(102.98,121.12)
  BOTTOM w0.127: v1(95.32,119.55) 93.13,117.35 93.13,110.31 86.5,103.68 86.5,96.74 89.77,93.47 89.77,79.59 v2(87.19,77.01) 86.17,75.99 83.79,75.99 v1(83.42,76.35) 83.15,76.35 82.95,76.15 82.95,75.73 R99528.2 ; HC31.1 107.49,117.46 107.21,117.74 107.21,119.17 105.26,121.12 v1(102.98,121.12) ; HR93.1 81.81,111.1 81.81,111.32 82.75,112.26 82.75,113.27 v1(86.49,117.01)
VCCST_PWRGD_DISCH_A: length 7.1
  TOP w0.254: Q5.3 82.54,76.39 R4.2 83.23,75.33 83.51,75.05 v2(85.01,75.05)
VCCST_PWRGD_R: length 5.5
  BOTTOM w0.254: XDP1.39 79.16,111.96 79.63,111.5 HR392.2 HR93.2 HR374.2 80.45,109.07 v2(80.75,108.78)
VDDQ_EN: length 6.8
  BOTTOM w0.127: v2(138.16,43.18) 137.74,42.76 137.74,42.76 APR131.2 137.74,41.2 137.7,41.16 137.52,40.98 APR129.2 APR130.1 135.62,40.08 135.32,39.78 PQ25.1
VSS_AL37: length 18.4
  TOP w0.102: U1.AL37 46.63,86.79 v1(46.44,86.61) ; SR35.1 45.44,75.05 44.94,75.54 v1(44.94,75.75)
  IN2 w0.102: v1(46.44,86.61) 46.22,86.83 45.36,86.83 44.88,86.35 44.88,86.15 44.23,85.49 43.24,85.49 42.39,84.65 42.39,83.75 42.2,83.56 42.2,82.47 42.15,82.43 42.15,82.04 42.76,81.44 42.76,80.9 43.6,80.05 43.6,79.13 43.8,78.93 43.8,76.89 v1(44.94,75.75)
  BOTTOM w0.102: v2(44.87,74.92) 44.87,75.67 v1(44.94,75.75)
VSS_SAIO_SENSE: length 87.3
  TOP w0.254: XU1.AE4 107.61,107.91 v1(107.66,107.91) ; v1(53.73,133.45) 53.73,133.16 PR6802.1
  IN1 w0.254: v1(97.22,131.73) 94.48,131.73 94.25,131.96 90.61,131.96 88.5,134.06 87.52,134.06 87.01,134.57 86.19,134.57 82.18,138.58 78.07,138.58 77.57,139.09 75.76,139.09 v1(74.57,140.27)
  IN2 w0.254: v1(53.73,133.45) 53.82,133.54 57.61,133.54 59.56,135.49 60.29,135.49 61.3,136.5 67.78,136.5 69.9,138.62 71.15,138.62 72.5,139.97 74.27,139.97 v1(74.57,140.27)
  BOTTOM w0.254: v1(107.66,107.91) 106.68,108.88 99.97,108.88 98.62,110.23 98.62,115.83 101.1,118.32 101.1,126.18 100.95,126.33 100.95,128.8 99.99,129.76 99.82,129.76 97.85,131.73 v1(97.22,131.73) ; v1(53.73,133.45) 53.14,132.86 v2(52.55,132.86)
VSS_SAIO_SENSE_R: length 3.3
  TOP w0.254: v2(51.37,133.34) 51.37,132.22 PR42.2 52.04,132.04 52.08,132.01 PR46.1 PR6802.2
VSS_SENSE: length 116.3
  TOP w0.203: XU1.D38 v1(140.94,127.07)
  TOP w0.254: v1(80.21,165.89) 80.21,167.08 81.6,168.47 v2(82.17,168.47) 83,168.47 83.06,168.42 PR89028.1
  IN2 w0.203: v1(140.94,127.07) 141.41,127.07 148.06,133.71 148.06,149.82 146.76,151.12 146.76,153.15 148.97,155.36 148.97,158.93 147.91,159.98 145.77,159.98 145.4,159.62 143.45,159.62 143.06,160 135.77,160 135.46,160.31 129.82,160.31 129.51,160.01 126.37,160.01 125.48,159.12 121.88,159.12 121.37,159.63 105.59,159.63 103.47,161.74 101.35,161.74 100.66,161.05 99.92,161.05 96.51,164.47 94.52,164.47 94.21,164.16 89.13,164.16 88.35,164.95 81.15,164.95 v1(80.21,165.89)
VSS_SENSE_R: length 5.5
  TOP w0.254: v2(87.17,166.61) 86.55,166.61 86.31,166.37 PC89016.2 85.52,166.84 85.53,166.86 PC89019.1 PR89029.1 85.3,168.42 PR89028.2 PR89032.2
VSSGT_SENSE: length 101.8
  TOP w0.254: XU1.F38 140.48,124.78 v1(140.04,124.34)
  IN2 w0.203: v1(140.04,124.34) 141.99,126.28 141.99,126.99 148.46,133.47 148.46,149.6 149.68,150.82 149.68,154.88 149.27,155.29 149.27,159.18 148.17,160.29 145.64,160.29 145.27,159.92 143.57,159.92 143.19,160.3 136.03,160.3 133.31,163.02 132.35,163.02 131.16,164.21 128.75,164.21 127.6,165.36 123.21,165.36 122.42,164.57 121.39,164.57 120.12,163.31 115.57,163.31 115.04,162.78 115.04,160.39 114.67,160.03 105.77,160.03 102.45,163.35 v1(101.55,163.35)
  BOTTOM w0.229: PR89053.1 99.55,167.5 v2(101.42,167.5) 101.42,166.97 101.8,166.59 101.8,163.6 v1(101.55,163.35)
VSSGT_SENSE_R: length 6.1
  TOP w0.254: v1(99.74,169.46) 99.74,170.03 PR89056.2
  BOTTOM w0.254: v1(99.74,169.46) 99.29,169 v2(99.29,168.65) 98.8,168.65 98.46,168.3 PR89053.2 ; PR89053.2 98.46,167.3 PC89027.2 ; PR89053.2 98.09,167.76 97.99,167.86 PR89054.1 PC89031.1
VSSMPHY_SENSE: length 39.5
  TOP w0.089: U1.K46 57.28,82.02 57.28,81.64 57.13,81.5 57.13,81.43
  TOP w0.102: 57.13,81.43 57.13,80.64 57.59,80.18 58.09,80.18
  TOP w0.254: R99521.2 77.33,63.96 v1(77.28,63.91) ; v1(58.39,79.62) 58.39,79.87 58.09,80.18
  IN2 w0.254: v1(79.58,69.81) 78.46,68.7 78.46,65.06 78.15,64.76 78.15,64.53 77.53,63.91 v1(77.28,63.91) ; v1(64.82,75.66) 64.42,75.66 63.57,76.52 61.95,76.52 59.76,78.72 58.68,78.72 58.39,79.01 58.39,79.42 58.39,79.42 v1(58.39,79.62)
  BOTTOM w0.254: v1(79.58,69.81) 79.58,69.89 78.83,70.64 77.74,70.64 v2(77.11,70.02) 76.54,69.45 70.64,69.45 70.32,69.76 69.13,69.76 69.12,69.77 69.1,69.77 67.83,71.04 67.83,71.05 66.7,72.19 66.7,74.21 65.25,75.66 v1(64.82,75.66)
VSSMPHY_SENSE_R: length 2.8
  TOP w0.254: PR109.2 77.68,65.96 77.84,65.96 v2(78.18,65.62) 78.21,65.6 R99521.1 PR7301.1
1P2V_DUAL_EN: length 15.6
  BOTTOM w0.203: PU9.8 138.29,30.53
  BOTTOM w0.229: PC124.1 138.03,30.79 138.29,30.53
  BOTTOM w0.254: PC124.1 138.38,31.58 138.53,31.73 138.53,33.35 PR131.2 139.58,34.4 139.58,35.56 139.83,35.8 PQ24.3 139.83,37.12 140.17,37.47 140.17,39.88 v2(140.75,40.46) 140.75,40.9 139.41,42.24 APR131.1
1P2V_DUAL_PWRGD: length 515.3
  TOP w0.102: v1(132.31,25.01) 132.31,28.74 135.85,32.29 140.17,32.29 140.9,33.02 v1(140.9,33.45) ; v1(91.54,35.42) 91.85,35.12 96.57,35.12 v1(97,35.55) ; v1(51.64,21.25) 51.64,32.54 ECR154.1 43.79,40.06 42.67,41.18 36.78,41.18 36.13,41.82 36.13,44.38 34.28,46.23 32.86,46.23 32.7,46.38 32.7,47.37 v1(32.36,47.7) ; R93102.1 v1(132.52,164.24)
  IN1 w0.102: v1(91.54,35.42) 91.54,36.06 92.18,36.69 92.18,41.14 88.64,44.67 88.64,53.48 88.11,54.02 88.11,56.5 83.44,61.18 83.44,63.42 84.52,64.51 85.36,64.51 87.27,66.42 87.27,83.39 87.6,83.72 87.6,90.79 80.75,97.65 77.57,97.65 v1(76.71,98.52) 76.71,100.79 77.15,101.24 77.15,102.07 75.6,103.62 75.6,104.49 72.88,107.2 72.88,117.4 73.43,117.94 73.43,122.86 74.12,123.55 74.12,129.25 69.45,133.91 69.45,134.29 64.08,139.66 64.08,140.58 63.65,141.01 61.61,141.01 57.14,145.48 55.24,145.48 v1(52.97,147.75) ; v1(101.07,12.46) 100.91,12.46 94.99,18.38 v1(94.99,20.51) 94.68,20.83 94.68,33.23 v1(97,35.55)
  IN2 w0.102: v1(32.36,47.7) 31.56,48.5 27.49,48.5 27.48,48.49 26.01,48.49 24.46,50.04 20.93,50.04 19.45,51.52 19.45,53.6 19.12,53.93 19.12,55.42 18.53,56.01 18.53,63.5 18.63,63.61 18.63,65 17.63,66 17.63,77.82 19.15,79.34 19.15,85.12 17.38,86.88 17.38,92.41 17.99,93.02 17.99,96.81 19.8,98.62 19.8,99.31 20.42,99.93 20.42,101.76 21.83,103.16 21.83,104.85 22.04,105.06 22.04,106.02 22.78,106.76 22.78,106.98 26.19,110.39 27.65,110.39 v1(28,110.74) ; v1(132.52,164.24) 131.92,164.24 131.39,164.77 128.98,164.77 127.84,165.91 122.98,165.91 122.19,165.13 121.15,165.13 119.89,163.87 112.37,163.87 109.33,160.82 105.81,160.82 102.61,164.02 101.9,164.02 101.59,164.34 100.77,164.34 100.26,163.83 98.77,163.83 97.88,164.72 94.38,164.72 94.07,164.42 89.27,164.42 88.48,165.2 81.62,165.2 80.52,166.31 78.01,166.31 76.1,164.39 76.1,155.41 74.47,153.78 66.98,153.78 65.58,152.38 65.58,151.08 64.47,149.97 57.74,149.97 56.62,148.85 54.39,148.85 53.29,147.75 v1(52.97,147.75) ; v1(51.64,21.25) 55.04,21.25 55.75,20.54 57.86,20.54 59.27,19.13 62.71,19.13 63.12,19.54 64.57,19.54 64.96,19.14 70.36,19.14 70.75,19.54 71.52,19.54 74,22.01 83.94,22.01 85.25,20.7 90.82,20.7 91.92,19.6 94.08,19.6 v1(94.99,20.51) 95.48,20.02 106.18,20.02 106.58,20.43 120.29,20.43 123.82,23.95 129.24,23.95 130.05,24.76 132.06,24.76 v1(132.31,25.01)
  BOTTOM w0.102: v1(76.71,98.52) 74.77,98.52 73.94,97.69 73.94,95.11 72.1,93.27 PR123.1 ; v1(101.07,12.46) ECR155.1 ; PQ93031.3 31.33,109.88 30.88,110.33 28.42,110.33 v1(28,110.74) ; v2(141.28,34.19) 140.64,34.19 PR135.2 140.74,33.45 v1(140.9,33.45) 140.9,33.12 140.79,33.01 140.42,32.64 140.41,32.63 140.41,31.97 140.19,31.75 PC128.1 139.55,31.3 139.55,30.34 139.09,29.88 PU9.10
2P5VPP_PG: length 43.1
  IN1 w0.127: v1(118.29,43.45) 120.4,41.34 123.09,41.34 126.57,44.82 v1(132.69,44.82)
  BOTTOM w0.127: v1(132.69,44.82) 133.75,43.75 135.53,43.75 v2(136.29,42.99) 136.64,42.65 APR129.1 ; v1(118.29,43.45) 117.62,44.12 102.14,44.12 PR116.2 101.57,43.02 100.87,42.32 100.62,42.06 100.09,42.06 99.61,42.54 PU6.1
65W_ADP_R: length 24.7
  TOP w0.102: v1(42.98,84.14) 43.19,83.93 43.19,83.16 U1.AV44 ; v1(26.57,79.64) 26.67,79.64 26.85,79.47 v2(28.4,79.47) 28.7,79.47 29.14,79.91 29.75,79.91 SR7838.1
  IN1 w0.102: v1(26.57,79.64) 27.04,80.12 31.06,80.12 31.35,79.83 32.02,79.83 32.46,80.28 33.93,80.28 34.24,80.58 35.96,80.58 36.55,80 37.17,80 37.41,80.24 37.41,80.7 39.7,82.99 39.7,83.17 40.76,84.24 42.88,84.24 v1(42.98,84.14)
4125_INT: length 99.5
  TOP w0.102: U1.AH41 48.38,84.84 v1(48.69,84.84)
  IN1 w0.102: v1(21.64,56.05) 22.68,55.01 25.58,55.01 25.85,54.74 27.33,54.74 27.51,54.56 28.35,54.56 28.94,55.15 31.45,55.15 33.01,53.58 34.67,53.58 35.29,52.96 38.24,52.96 39.11,52.09 41.59,52.09 41.87,51.81 45.28,51.81 45.7,51.39 52.68,51.39 53.69,52.4 55.07,52.4 55.7,53.04 59.17,53.04 v1(59.81,53.68)
  IN2 w0.102: v1(59.81,53.68) 60.37,54.24 60.37,54.93 61.7,56.25 63.23,56.25 64.53,57.55 64.53,62.71 66.43,64.61 66.43,67.1 67.09,67.76 67.09,69.29 66.45,69.94 66.45,70.13 66.44,70.13 66.44,70.64 66.45,70.65 66.45,71.3 65.67,72.08 65.67,76.64 64.75,77.56 63.31,77.56 60.58,80.3 60.58,81.52 60.15,81.94 59.65,81.94 v1(59.28,82.31) 58.82,81.85 56.92,81.85 56.08,82.69 55.62,82.69 55.39,82.46 54.61,82.46 54.39,82.68 54.39,83.52 53.08,84.83 52.05,84.83 51.24,85.64 49.98,85.64 49.67,85.95 48.74,85.95 48.49,85.7 48.49,85.04 v1(48.69,84.84)
  BOTTOM w0.102: v1(21.64,56.05) 21.15,55.56 XDP3.4 ; SR50.2 60.81,83.48 v2(60.68,83.61) 60.08,83.61 SR7815.1 59.5,82.53 v1(59.28,82.31)
4125_INT_OPTION: length 34.4
  TOP w0.102: v1(30.48,106.36) 30.6,106.48 R2348.1 31.52,106.06 32.24,106.06 32.63,106.45 34.3,106.45 34.89,105.87 34.89,105.65 35.45,105.08 35.45,104.12 35.8,103.77 35.8,101.81 37.54,100.08 39.19,100.08 39.26,100.11 39.32,100.14 39.49,100.23 U1.BF9
  IN1 w0.102: v1(24.56,117.62) 25.42,116.75 25.42,116.03 24.84,115.44 24.84,112.42 25.46,111.79 25.46,108.85 26.65,107.66 26.71,107.66 v1(27.11,107.25)
  BOTTOM w0.102: v1(24.56,117.62) 24.51,117.67 v2(23.77,117.67) 23.09,117.67 22.54,117.12 R2346.2 ; v1(27.11,107.25) 27.11,107.65 27.91,108.45 28.85,108.45 29.82,107.48 29.82,107.02 v1(30.48,106.36)
4125_SW_WP: length 96.8
  TOP w0.102: U1.AK47 47.64,81.64 47.66,81.64 47.81,81.48 47.81,81.12 47.67,80.98 47.67,79.2 48.26,78.61 48.26,75.79 48.51,75.53 v1(48.51,74.92)
  IN1 w0.102: v1(59.66,60.26) 59.36,60.26 58.55,59.45 58.29,59.45 57.78,58.94 56.39,58.94 55.43,57.98 54.35,57.98 53.79,57.42 52.98,57.42 52.38,56.81 52.2,56.81 50.74,55.35 50.74,55 50.32,54.58 50.32,53.98 50.01,53.68 46.65,53.68 46.23,54.09 43.59,54.09 42.64,55.04 37.59,55.04 36.38,56.25 36.38,57.41 34.94,58.85 33.98,58.85 32.97,57.85 32.36,57.85 32.08,57.57 30.37,57.57 29.53,58.41 24.94,58.41 24.93,58.42 24.29,58.42 v1(24.23,58.36)
  IN2 w0.102: v1(59.66,60.26) 59.66,60.95 59.28,61.33 58.49,61.33 56.78,63.05 56.78,69.65 57.1,69.97 v1(57.1,70.65)
  BOTTOM w0.102: SR155.1 19.33,44.41 19.56,44.41 19.71,44.26 20.75,44.26 22.43,45.94 22.43,50.1 23.6,51.27 23.6,56.58 24.23,57.22 v1(24.23,58.36) ; v1(48.51,74.92) 48.21,74.61 48.21,73.72 48.55,73.37 48.55,73.25 49.86,71.94 49.97,71.94 50.34,71.58 50.34,70.71 51.26,69.78 51.26,69.61 51.26,68.75 51.37,68.65 53.4,68.65 53.85,69.1 53.85,70.36 SR7817.1 54.79,71.3 55.39,71.3 55.78,71.69 56.32,71.69 56.46,71.69 SR53.2 57.1,71.06 v1(57.1,70.65) ; v2(59.84,59.56) 59.84,59.88 59.66,60.06 v1(59.66,60.26)
4125_SW_WP_OPTION: length 55
  TOP w0.089: U1.BE9 39.85,99.99 39.46,99.99 39.46,99.99 39.25,99.87
  TOP w0.102: 39.25,99.87 37.45,99.87 35.6,101.73 35.6,103.68 34.92,104.36 v2(34.92,104.41) 34.92,104.97 v1(34.52,105.37) 34.52,105.4 34.52,105.49 R2344.1 ; v1(29.18,130.93) 28.42,130.16 23.76,130.16 21.72,132.2 20.09,132.2 19.95,132.34 R2342.2
  IN1 w0.102: v1(34.52,105.37) 34.52,105.4 34.52,105.93 33.6,106.85 33.6,108.73 31.71,110.62 31.71,111.38 31.55,111.54 31.55,113.64 31.76,113.85 31.76,114.95 30.97,115.74 30.72,115.74 29.58,116.88 29.58,117.77 28.26,119.08 28.26,124.97 27.27,125.96 25.68,125.96 24.88,126.75 24.88,128.21 25.82,129.14 27.4,129.14 v1(29.18,130.93)
+0P95V_CPUIO: length 137.8
  TOP w0.254: HR365.1 77.81,116.09 77.61,116.09 AR43.2 76.97,117.95 82.42,117.95 v1(83.31,118.84)
  TOP w0.305: XU1.AK11 116.25,103.29 v1(116.25,103.33) ; v1(118.1,103.33) 118.1,103.27 XU1.AK14
  IN1 w0.127: 109.96,110.4 109.96,110.86 ; 109.32,113.78 109.68,113.78 ; 109.02,113.17 109.02,113.53 ; 108.13,117.74 108.13,118.13 ; 109.07,117.69 109.07,118.13 ; 109.93,113.17 109.93,113.53 ; 108.43,115.66 109.68,115.66 ; 109.04,111.29 109.04,111.75 ; 110.21,114.7 110.59,114.7
  IN1 w0.508: v1(132.74,105.56) 132.48,105.31 127.31,105.31 ; v1(83.31,118.84) 84.15,118.84 85.37,117.62 85.37,116.6
  IN2 w0.254: v1(82.45,101.16) 83.16,101.16 84.25,102.25 88.39,102.25 89.61,101.03 89.61,96.11 90.1,95.62 90.1,79.41 87.63,76.94 87.63,62.78 91.72,58.69 91.72,56.79 96.78,51.73 96.78,48.17 96.64,48.03 96.64,46.98 97.66,45.96 107.02,45.96 110.19,42.79 113.8,42.79 118.02,38.57 123.61,38.57 v1(127.43,34.76)
  BOTTOM w0.254: HR12.1 133.18,105.11 v1(132.74,105.56) ; v1(127.43,34.76) 127.43,33.15 v2(128.1,32.49) 128.37,32.21 R69683.1 ; v1(83.31,118.84) 83.51,119.04 83.51,119.51 R93119.2
  BOTTOM w0.457: HR10.1 112.35,118.49 ; 111.39,118.49 HR9.1
  vias: v1(78.89,102.5) v1(78.89,101.87) v1(79.53,102.5) v1(79.53,101.87) v1(79.81,98.49) v1(80.19,102.5) v1(80.19,101.87) v1(82.55,99.3) v1(83.21,99.33) v1(83.77,98.8) v1(83.89,99.43) v1(84.56,99.41) v1(84.58,98.75) v1(111.72,116.07) v1(113.01,118.18) v1(127.23,103.34) v3(111.56,118.23)
+0P95V_DISCH_A: length 2.7
  BOTTOM w0.254: v2(129.3,29.89) 129.35,29.94 R69683.2 128.58,30.87 128.05,31.4 Q9540.3
+1P2V_DUAL: length 390.8
  TOP w0.254: 106.38,56.36 106.24,56.22 106.24,55.49 105.49,54.74 v1(105.37,54.74) ; v1(129.01,95.05) 128.59,94.64 XU1.AW25 ; v1(100.13,51.67) 100.46,51.67 101.13,51 DIMM1.220 ; v1(111.23,59.77) 111.62,60.17 DIMM2.178 111.62,63.22 111.07,63.77 v1(110.46,63.77) ; v1(99.9,63.87) 100.05,63.87 101.12,62.8 DIMM2.220 101.12,60.08 v1(101.43,59.77) ; DIMM1.129 125.88,58.28 125.63,58.54 125.32,58.54 ; v1(129.16,70.91) 129.84,71.59 130.01,71.59 D4CB4.1 ; XU1.AU19 123.1,96.43 v1(122.62,96.91) ; v1(107.37,66.74) 107.13,66.74 106.37,67.5 DIMM2.199 ; DIMM2.33 149.87,68.2 151.43,66.64 v1(151.81,66.64) ; XU1.AV21 125.01,95.45 125.01,94.83 124.61,94.43 v1(124.47,94.43) ; DIMM1.135 124.38,58.28 124.64,58.54 125.32,58.54 ; v1(125.32,58.54) 125.32,58.54 ; DIMM1.123 127.38,58.21 127.72,58.55 v1(128.72,58.55) 128.72,58.54 128.88,58.37 DIMM1.117 ; DIMM2.241 95.87,67.26 96.39,66.74 v1(96.87,66.74) ; DIMM2.54 144.62,62.05 144.57,62.1 ; v1(96.37,54.45) 96.35,54.45 95.64,55.16 95.64,56.15 95.88,56.4 DIMM1.241 ; XU1.AU15 119.45,96.45 v1(119,96.9) ; DIMM1.33 149.88,55.87 149.13,55.12 149.13,54.92 148.84,54.63 v1(148.64,54.63) ; v1(40.92,124.37) 39.11,126.18 26.5,126.18 25.47,125.15 25.47,124.35 25.17,124.06 23.15,124.06 22.63,123.53 21.35,123.53 20.44,122.62 20.44,122.54 v1(20.03,122.13)
  TOP w0.305: v1(127.23,93.25) 127.2,93.25 XU1.AY23 ; XU1.AY18 122.33,93.69 122.62,93.41 v1(122.72,93.41) ; v1(123.16,73.33) 123.47,73.02 D4CB3.1 ; 128.67,47.82 v1(127.13,47.82) DIMM1.124 ; 128.67,47.82 129.97,47.82 130.13,47.98 DIMM1.112 ; 128.67,47.82 128.63,47.86 DIMM1.118 ; DIMM2.111 130.37,68.12 v1(130.27,68.01) ; DIMM2.141 122.87,68.27 123.03,68.11 123.03,67.1 122.65,66.72 v1(122.37,66.72) ; DIMM2.147 119.37,67.07 118.85,66.54 v1(118.36,66.54) 118.11,66.54 117.78,66.87 117.78,68.14 117.87,68.23 DIMM2.153 117.87,71.66 117.96,71.74 D4CB1.1 117.97,72.14 D4C31.1 ; DIMM1.159 116.38,58.28 116.08,58.59 v1(115.91,58.59) 115.69,58.59 115.38,58.28 DIMM1.163 ; v1(117.36,47.42) 117.36,47.53 117.63,47.8 DIMM1.154 v1(117.63,50.36) ; DIMM1.130 v1(125.63,47.82) ; DIMM1.12 v1(155.13,47.82) ; XU1.AW10 112.29,95.13 112.29,95.08 112.29,95.08 v1(112.29,95.06) ; DIMM1.111 130.38,55.71 131.15,54.94 v1(131.64,54.94) ; XU1.AY16 120.37,93.15 v1(120.82,92.69) ; XU1.AV17 120.82,95.98 v1(120.82,96.05) ; v1(118.15,95.98) 118.08,95.98 XU1.AU13 ; XU1.AU23 126.84,96.43 v1(127.3,96.89) ; DIMM2.136 124.12,60.16 123.39,59.43 v1(123.23,59.43) 122.93,59.43 122.62,59.74 DIMM2.142 ; D4CB2.1 127.46,71.41 126.74,71.41 v1(125.87,70.55) DIMM2.129 125.87,68.27 125.47,67.86 124.68,67.86 124.37,68.17 DIMM2.135 ; v1(129.16,70.91) 128.87,70.63 DIMM2.117 ; v1(119.23,47.51) 119.13,47.6 DIMM1.148 v1(119.13,50.4) ; v1(127.61,68.01) 127.37,68.25 DIMM2.123 ; v1(124.44,96.86) 124.93,97.35 XU1.AT21 ; DIMM2.148 119.12,60.11 118.77,59.75 v1(118.13,59.75) 117.93,59.75 117.62,60.06 DIMM2.154 ; v1(119.57,55.96) 119.38,56.15 DIMM1.147 ; v1(128.62,62.35) DIMM2.118 ; DIMM2.160 116.12,60.03 v1(115.91,59.82) ; v1(130.12,62.4) DIMM2.112 ; DIMM1.241 95.88,58.3 96.38,58.79 v1(96.62,58.79) ; XU1.AT18 122.19,97.36 v1(121.73,97.83) ; XU1.AV11 115.81,95.52 v1(116.25,95.08) ; DIMM2.12 v1(155.12,59.81) ; XU1.AW14 118.54,94.53 v1(118.15,94.15) ; DIMM1.178 111.63,50.49 112.24,51.09 v1(112.32,51.09) ; v1(145.29,63.77) 145.28,63.77 144.57,63.06 144.57,62.1 ; DIMM2.124 127.12,60.08 126.82,59.78 v1(125.79,59.78) 125.62,59.94 DIMM2.130 ; DIMM2.159 116.37,70.27 116.02,70.63 v1(115.34,70.63) 115.37,70.59 DIMM2.163 ; v1(123.23,58.69) 122.88,58.35 DIMM1.141 ; DIMM1.136 124.13,48.12 v1(124.48,47.77) ; DIMM1.96 v1(134.13,50.4) ; v1(132.69,58.54) 133.22,58.54 134.12,59.44 DIMM2.96 134.12,62.62 134.54,63.04 v1(134.97,63.04) ; v1(116.13,50.39) DIMM1.160 v1(116.13,47.61) ; DIMM1.75 139.38,55.21 139.86,54.74 v1(140.37,54.74) ; v1(118.13,58.56) 117.88,58.31 DIMM1.153 ; DIMM2.75 139.37,67 139.07,66.69 v1(138.33,66.69) ; 106.38,56.36 DIMM1.199 ; DIMM1.54 v1(144.63,47.82) ; v1(122.63,50.54) DIMM1.142 122.63,47.95 122.33,47.64 v1(121.66,47.64)
  TOP w0.356: XU1.AY12 116.71,93.1 v1(116.73,93.08)
  TOP w0.381: v1(40.92,124.37) 41.48,124.37 42.76,125.66 54.98,125.66 55.48,126.16 57.77,126.16 59.33,124.6 59.33,124.03 60.36,123 61.64,123 64.41,120.23 64.41,117.54 66.8,115.15 66.8,109.9 67,109.69 68.8,109.69 71.61,106.89 76.28,106.89
  TOP w0.457: O2R22.1 16.81,94.28 v1(16.67,94.43)
  TOP w0.635: 149.84,16.68 PCE9.1 ; PCE9.1 150.78,15.74 ; PCE9.1 151.72,16.68
  TOP w1.27: 134.81,25.71 134.81,28.06 136.59,29.85 145.22,29.85 148.83,26.24 148.83,22.15
  IN1 w0.508: v1(122.63,50.54) 122.63,46.07 122.12,45.56 v3(122.12,41.9)
  IN2 w0.178: 20.64,102.56 21.1,103.01 21.33,103.01 21.57,103.25 21.57,105.29 21.44,105.43
  IN2 w0.254: v1(20.03,122.13) 17.89,122.13 16.76,121 16.76,119.95 16.46,119.65 16.46,118.45 15.14,117.13 15.14,116.37 13.7,114.93 v1(13.7,114.6)
  IN2 w0.33: 20.64,102.56 20.55,102.65 20.55,104.54 21.44,105.43
  IN2 w0.508: 20.64,102.56 20.01,101.93 20.01,100.1 19.32,99.41 18.96,99.41 18.57,99.02 18.57,98.59 17.34,97.36 17.09,97.36 16.67,96.94 v1(16.67,94.43) ; 21.44,105.43 21.44,105.99 22.38,106.93 22.38,107.15 26.1,110.87 27.1,110.87 29.16,112.94 29.16,115.23 29.67,115.74 31.51,115.74 34.01,118.24 34.01,119.43 36.26,121.68 37.09,121.68 39.78,124.37 v1(40.92,124.37)
  BOTTOM w0.127: 124.23,98.24 124.64,98.24 ; 118.59,98.92 118.59,98.49 ; 121.26,96.66 121.26,97.09 ; 139.55,102.2 139.55,102.61 ; 135.63,99.18 135.23,99.18 ; 141.37,96.71 141.37,97.07 ; 137.75,105.64 137.75,106.28 ; 128.34,95.54 127.05,95.54 ; 111.81,96.66 111.81,97.17 ; 124.28,99.18 124.61,99.18 ; 121.26,98.9 121.26,98.54 ; 104.42,99.48 104.42,99.91 ; 111.5,101.87 111.07,101.87 ; 136.57,99.18 136.14,99.18 ; 124.92,101.23 124.92,101.64 ; 137.46,97.35 137.08,97.35 ; 125.83,101.26 125.83,101.67 ; 118.79,100.12 119.15,100.12 ; 139.62,97.63 139.62,98.06 ; 128.57,97.6 128.57,98.06 ; 139.83,101.95 140.26,101.95 ; 130.4,100.32 130.4,100.78 ; 104.7,102.89 105.13,102.89 ; 129.79,101.95 129.79,101.94 131.04,101.94 131.04,101.95 ; 132.26,100.35 132.26,100.78 ; 127.91,100.12 128.29,100.12 ; 118.59,97.6 118.59,98.03 ; 120.6,99.18 121.03,99.18 ; 136.83,103.11 136.83,103.52 ; 107.47,96.43 107.85,96.43 ; 120.65,98.26 121,98.26 ; 120.6,100.09 120.98,100.09 ; 136.83,103.98 136.83,104.41 ; 129.82,99.15 130.2,99.15 ; 110.46,98.26 110.16,98.26 ; 124.89,100.35 124.89,100.83 ; 128.57,96.69 128.57,97.12 ; 137.08,96.43 140.23,96.43 140.23,96.43 ; 117.88,101.01 118.29,101.01 ; 105.97,95.49 105.64,95.49 ; 139.83,99.15 140.74,99.15 140.75,99.14 141.18,99.14 ; 122.16,98.93 122.16,98.51 ; 121.54,93.74 121.94,93.74 ; 136.83,100.32 136.83,100.7 ; 110.84,100.52 110.84,100.8 ; 110.84,99.41 110.84,99.74 ; 116.05,99.13 116.48,99.13 ; 126.74,101.29 126.74,101.67 ; 107.19,95.77 107.19,96.15 ; 111.63,50.36 111.63,51.17 ; 109.25,97.34 109.72,97.34 ; 116.69,103.11 116.69,103.55 ; 112.01,97.35 112.42,97.35 ; 118.85,94.6 119.18,94.6 ; 111.2,96.43 111.56,96.43 ; 122.45,98.26 122.81,98.26 ; 109.17,95.54 110.56,95.54 ; 140.49,104.87 140.49,106.24 ; 138.05,102.83 138.43,102.83 ; 123.06,101.23 123.06,101.59 ; 116.91,94.6 117.3,94.6 ; 132.21,99.41 132.21,99.84 ; 122.17,94.88 122.17,95.27 ; 122.19,99.46 122.19,99.93 ; 133.17,102.2 133.17,102.56 ; 126.03,96.43 126.41,96.43 ; 141.4,97.65 141.4,97.67 141.4,97.67 141.4,98.03 141.4,98.03 141.4,98.08 ; 106.27,101.21 106.27,101.62 ; 106.3,95.72 106.3,96.15 ; 116.05,96.43 117.32,96.43 ; 126.97,101.01 128.37,101.01 ; 111.17,95.52 111.58,95.52 ; 138.94,102.89 139.37,102.89 ; 131.9,99.15 131.52,99.15 ; 135,103.06 135,103.47 ; 120.47,100.98 121.23,100.98 ; 128.62,93.97 128.62,94.38 ; 142.95,99.05 143.31,99.15 ; 114.98,93.79 115.44,93.79 ; 140.23,98.26 139.88,98.26 ; 134.99,97.62 134.99,98.04 ; 111.81,97.65 111.81,97.98 ; 126.11,98.26 126.52,98.26 ; 107.49,95.52 107.9,95.52 ; 106.53,95.52 106.93,95.52 ; 117.93,99.18 118.34,99.18 ; 133.5,100.09 133.86,100.09 ; 116.07,98.26 117.34,98.26 ; 111.76,99.41 111.76,99.76 ; 136.78,100.04 136.09,100.04 ; 112.83,101.89 113.49,101.89 ; 118.9,92.75 118.64,93.08 ; 116.99,100.09 117.4,100.09 ; 128.6,95.75 128.6,96.21 ; 118.87,98.26 119.25,98.26 ; 138.66,104.92 138.66,106.24 ; 111.73,101.26 111.73,101.67 ; 134.35,99.22 134.76,99.22 ; 134.06,102.61 134.06,102.17 ; 127.1,98.26 127.51,98.26 ; 143.03,98.19 143.38,98.19 ; 130.4,93.94 130.4,94.35 ; 134.09,101.26 134.09,101.69 ; 141.63,99.18 142.04,99.18
  BOTTOM w0.254: D4R14.1 122.92,51.99 ; C8310.1 93.33,76.14 ; C8310.1 93.33,77.31 ; C8310.1 93.89,76.72
  BOTTOM w0.305: 120.09,50.25 120.09,49.78 D4C20.1
  BOTTOM w0.356: O2Q3.4 13.35,115.81 13.7,115.45 v1(13.7,114.6)
  BOTTOM w0.406: 125.32,61.08 124.9,61.5 D4R2.1 123.59,61.5
  BOTTOM w0.457: 114.62,105.47 HR63.1
  BOTTOM w0.508: SR265.1 134.21,46.34
  BOTTOM w0.635: PCE9.1 151.81,16.68 ; PCE9.1 150.78,15.65 ; PCE9.1 150.78,17.71 ; PCE9.1 149.75,16.68
  vias: v1(136.24,25.01) v2(146.84,79.21) v3(91.03,100.73) v3(91.03,99.84) v3(91.03,98.95) v3(91.03,98.03) v3(91.03,97.14) v3(136.17,24.25) v3(147.7,20.46) v3(147.67,19.32) v3(148.74,20.44) v3(148.74,19.34) v3(149.73,20.46) v3(149.73,19.37) v3(150.72,22.57) v3(150.7,21.43) v3(150.71,20.42) v3(150.72,19.4)
+1P2V_DUAL_A_CS: length 2.1
  BOTTOM w0.254: v2(142.87,26.27) 142.45,26.27 141.8,26.92 141.8,27.67 141.81,27.68
+1P2V_DUAL_A_FB_A: length 16.5
  IN1 w0.254: v1(134.58,33.73) 128.51,27.66 128.51,27.41 v1(128.01,26.91)
  BOTTOM w0.203: PU9.6 137.49,29.88
  BOTTOM w0.229: 137.49,29.88 136.38,30.98
  BOTTOM w0.254: v1(134.58,33.73) 134.58,33.19 PR214.1 134.89,32.46 135,32.35 PC130.2 PR93024.1 136.2,31.62 136.2,31.16 136.38,30.98 ; v2(128.01,26) v1(128.01,26.91)
+1P2V_DUAL_A_S3: length 7.2
  BOTTOM w0.203: 137.89,30.32 PU9.7
  BOTTOM w0.229: v2(137.09,31.11) 137.89,30.32
  BOTTOM w0.254: v2(137.09,31.11) 136.79,31.42 PC120.1 137.28,31.99 137.47,32.18 137.47,33.37 137.78,33.68 PR128.2 PR129.2
+1P2V_DUAL_A_TON: length 2.3
  BOTTOM w0.229: v2(139.05,30.71) 138.69,30.34 PU9.9
  BOTTOM w0.457: PR126.2 v2(139.05,30.71)
+1P2V_DUAL_A_V5IN: length 1.1
  BOTTOM w0.254: 142.08,31.59 PR7702.1 142.64,32.18
  vias: v2(140.83,28.83)
+1P2V_DUAL_A_VOUT_R_A: length 38.5
  TOP w0.254: PJP9.2 151.62,18.15 v1(151.66,18.1)
  IN1 w0.254: v1(151.66,18.1) 151.99,18.43 151.99,25.3 143.2,34.09 135.57,34.09 v1(135.21,33.73)
  BOTTOM w0.203: PU9.5 136.75,28.86 136.5,29.12
  BOTTOM w0.254: v1(135.21,33.73) 135.21,34.03 134.91,34.34 134.26,34.34 PC941483.1 v2(133.84,33.83) 133.84,33.09 PR214.2 134.16,32.77 PC130.1 134.16,31.69 134.47,31.38 135.25,31.38 136.5,30.14 136.5,29.12
+1P2V_DUAL_BST: length 3.6
  BOTTOM w0.254: 138.54,24.28 138.05,23.79 138.05,22.62 137.77,22.34 137.19,22.34 137.01,22.16 v2(136.5,22.16)
+1P2V_DUAL_BST_RC: length 1.8
  BOTTOM w0.254: 140.06,22.69 140.06,21.65 v2(140.59,21.12)
+1P2V_DUAL_DISCH_A: length 3.4
  BOTTOM w0.254: R661.2 122.98,39.49 v2(123.7,38.78) 123.7,38.78 Q9543.3
+1P2V_DUAL_HG: length 13.4
  TOP w0.635: v3(135.67,21.84) 139.05,25.22 v3(139.05,25.57)
  BOTTOM w0.635: PR127.1 134.01,15.13 v2(134.01,18.07) 134.01,19.32 134.82,20.14 134.82,20.99 v3(135.67,21.84)
+1P2V_DUAL_HG_IN:
  vias: v1(135.28,11.83) v2(134.87,12.89)
+1P2V_DUAL_LG: length 10.2
  TOP w0.635: v3(140.37,26.67) 140.37,24.56 v3(137.4,21.59)
  BOTTOM w0.508: v2(141.08,25.96) 141.08,25.96 v3(140.37,26.67)
  BOTTOM w0.635: PR134.1 135.89,20.08 v3(137.4,21.59)
+1P2V_DUAL_LG_R_D:
  vias: v2(135.56,15.38) v3(135.74,16.25)
+1P2V_DUAL_PHASE: length 10
  BOTTOM w0.635: 141.07,24 141.71,23.36 141.71,20.97 142.87,19.8 142.87,15 v3(142.72,14.85)
  vias: v2(140,11.88) v3(139.34,14.75) v3(140.44,14.85) v3(141.58,14.85)
+1P2V_DUAL_SUR:
  vias: v2(141.45,17.82)
+1P2V_DUAL_VID: length 7.5
  BOTTOM w0.203: 140.16,29.02 140,28.86 PU9.11
  BOTTOM w0.254: 140.16,29.02 140.81,29.68 140.81,30.38 PR7701.2 141.14,31.08 141.25,31.18 PR7702.2 141.25,33.09 142.07,33.92 142.82,34.67 v2(142.97,34.67)
+1P2V_DUAL_VIN: length 27.3
  IN1 w0.508: v1(138.07,11.55) 138.07,12.97 135.94,15.1 135.13,15.1 134.59,15.64 134.59,20.84 133.15,22.29 133.15,23.92 134.33,25.1 134.33,28.42 v1(139.05,33.14)
  BOTTOM w0.457: PR126.1 v1(139.05,33.14)
  vias: v2(133.07,12.77)
+1P5V: length 4.4
  BOTTOM w0.508: 28.64,24.51 v2(27.3,24.51) 26.58,24.51 25.47,23.41 25.37,23.41 v1(24.89,22.93)
+1P5V_FB: length 5.3
  TOP w0.508: PR122.2 v1(28.61,22.77)
  BOTTOM w0.508: v2(27.71,22.77) v1(28.61,22.77) 28.6,22.79 PR121.2 PC7607.2 30.08,23.42 30.12,23.46 PU7.4
+1P05V_SA_DISCH_A: length 3.3
  BOTTOM w0.254: v2(117.68,34.71) 117.68,34.4 118.13,33.95 R651.2 119.17,33.95 119.95,34.73 Q9537.3
+1P05VSB: length 310.1
  TOP w0.254: SR158.1 45.31,111.37 45.28,111.33 SR173.1 44.85,111.67 45.12,111.94 v1(45.16,111.94) ; v1(75.84,111.81) 75.84,111.76 76.27,111.33 80.48,111.33 80.82,111.67 82.55,111.67 83.09,111.13 83.64,111.13 84.15,111.63 84.15,113.68 91.5,121.03 91.5,124.4 91.19,124.72 90.78,124.72 90.14,124.08 88.05,124.08 87.56,123.59 87.56,122.87 87.74,122.69 87.74,122.11 87.45,121.82 86.52,121.82 86.44,121.9 85.82,121.9 v1(85.75,121.97) 85.75,121.62 HR58.1 ; SR153.1 43.92,111.85 v1(44.01,111.94)
  TOP w0.508: v1(13.09,56.65) 11.55,58.18 11.55,58.9 12.23,59.57 v1(12.42,59.57) ; v1(65,118) 65,120.44 61.2,124.24 61.2,125.68 58.49,128.39 39.5,128.39 38.68,127.57 35.44,127.57 v1(34.92,128.09)
  IN1 w0.254: v1(44.01,111.94) v1(45.16,111.94) 45.16,114.49 45.69,115.02 45.69,120.04 44.98,120.75 38.73,120.75 35.61,123.88 35.61,124.61 35.06,125.16 35.06,127.96 v1(34.92,128.09)
  IN1 w0.508: v1(34.92,128.09) 34.92,128.25 34.93,128.26 34.93,129.99 35.28,130.34 35.28,133.3 34.59,133.99 34.59,134.87 34.95,135.22 34.95,135.93 34.78,136.1 v1(34.78,137.23)
  IN2 w0.254: 62.2,104.61 61.57,103.98 61.57,102.86 62.11,102.31 62.11,102.42 62.6,102.9 62.6,103.56 62.2,103.95 62.2,104.61 ; 62.2,104.61 62.22,104.63 ; v1(12.06,52.24) 12.06,50.78 v1(12.09,50.75)
  IN2 w0.508: v1(13.09,56.65) 12.77,56.65 12.1,55.98 11.24,55.98 10.55,56.66 10.55,63.46 9.58,64.44 9.58,69.82 9.15,70.25 9.15,76.54 8.81,76.88 6.24,79.45 6.24,85.09 8.41,87.26 8.41,92.04 10.54,94.17 10.54,99.02 8.41,101.15 8.41,107.66 11.21,110.47 11.21,111.75 8.37,114.6 v1(8.13,114.6) 14.38,120.85 14.64,120.85 15.54,121.75 15.54,122 18.9,125.36 18.9,125.67 18.92,125.69 18.92,125.97 20.08,127.13 21.53,127.13 21.91,127.51 21.91,129.44 26.45,133.97 26.83,133.97 27.83,134.98 29.83,134.98 30.82,135.97 31.7,135.97 32.98,137.25 34.76,137.25 v1(34.78,137.23) ; v1(58.96,109.37) 58.02,108.44 58.02,105.55 58.39,105.18 59.62,105.18 59.83,105.39 61.89,105.39 62.22,105.06 62.22,104.63 ; 62.11,102.31 62.11,101.5 63.04,100.57 66.52,100.57 66.9,100.95 68.3,100.95 72.34,96.92 72.34,95.49 v1(72.13,95.29)
  BOTTOM w0.254: SR767.1 7.6,58.6 7.18,59.02 7.18,60.04 7.47,60.33 8.62,60.33 9.23,59.72 9.23,59.41 9.78,58.86 9.84,58.86 SR758.1 11.04,58.94 11.79,58.94 v1(12.42,59.57) ; v1(85.75,121.97) 85.75,122.51 85.22,123.04 85.22,123.52 85.48,123.78 85.52,123.78 86.01,124.28 86.01,125.15 CB4135.2 SR773.1
  BOTTOM w0.279: v1(12.09,50.75) 12.04,50.75 11.15,49.86 XDP3.43 ; XDP1.43 76.22,110.96 75.84,111.35 v1(75.84,111.81) 74.3,111.81 73.46,110.96 XDP1.44 66.82,110.96 ; 11.61,55.84 11.15,55.39 XDP3.44 11.15,52.36 11.28,52.24 v1(12.06,52.24)
  BOTTOM w0.356: v1(8.13,114.6) 8.13,114.63 8.1,114.66 8.1,115.79 8.37,116.06 O2Q2.1
  BOTTOM w0.457: M1C66.1 12.4,56.64 11.61,55.84
  BOTTOM w0.508: v1(65,118) 65,117.44 66.82,115.62 66.82,109.59 66.29,109.06 64.26,109.06 63.6,109.72 v2(63.6,110.23) 63.11,110.72 61.5,110.72 60.86,110.07 59.66,110.07 v1(58.96,109.37) 58.84,109.5 HR423.2 ; M1C66.1 SR167.1 13.4,56.96 v1(13.09,56.65)
  vias: v1(72.67,94.83)
+1P05VSB_EN: length 5.4
  TOP w0.254: v1(72.08,66.77) 72.08,66.7 PC95.1 72.77,66.29 PU5.2
  BOTTOM w0.254: v1(72.08,66.77) 72.49,66.36 v2(72.49,65.83) PR96.2 R93166.2
+1P05VSB_FB_A: length 4.9
  TOP w0.254: PR109.1 76.18,65.95 PR107.1 75.57,65.95 74.66,65.95 PC104.2 v1(74.66,66.72) 74.27,67.12 PU5.5
  BOTTOM w0.254: v2(75.59,65.8) v1(74.66,66.72)
+1P05VSB_FB_PJP: length 35.5
  TOP w0.254: PJP8.2 71.47,93.84 71.68,94.05 73.63,94.05 74.73,92.95 74.73,88.79 76.73,86.78 v2(76.73,80.46) 76.73,78.81 v1(77.72,77.82)
  IN1 w0.254: v1(77.72,77.82) 77.72,70.5 76.81,69.59 v1(76.81,64.66)
  BOTTOM w0.254: PR108.2 77.44,65.14 77.32,65.01 77.16,65.01 v1(76.81,64.66)
+1P05VSB_FB_RC_A: length 6.7
  TOP w0.254: R99522.1 74.65,64.56 74.66,64.57 PC104.1 75.16,65.11 PR107.2 75.61,65.11 75.82,65.33 PC105.1 76.12,64.97 v1(76.12,64.63)
  BOTTOM w0.254: v2(77.11,63.19) 77.11,63.31 76.48,63.95 76.48,64.28 v1(76.12,64.63) 76.12,65.05 PR108.1
+1P05VSB_PFM: length 3.9
  TOP w0.254: PU5.3 v1(73.27,66.78) 73.27,66.53 PR1016.2
  BOTTOM w0.508: v1(73.27,66.78) 73.27,66.42 73.79,65.9 v2(73.81,65.9) 74.71,65.01 PR1017.2
+1P05VSB_PG: length 2.8
  TOP w0.254: PR93097.2 71.41,66.4 v1(71.41,66.8) 71.99,67.39 PU5.1
  BOTTOM w0.508: v2(71.14,66) 71.41,66.27 v1(71.41,66.8)
+1P05VSB_PHASE:
  vias: v1(68.91,71.82) v1(70.81,71.82) v1(71.47,71.82) v2(68.22,71.98)
+1P05VSB_SS: length 3.3
  TOP w0.254: PU5.22 71.69,67.65 71.35,67.3 71.21,67.3 70.98,67.08 70.89,67.08 v1(70.65,66.84) 70.65,66.64 70.65,66.63 PC808.1
  BOTTOM w0.254: v2(69.87,67.1) 70.13,66.84 v1(70.65,66.84)
+1P05VSB_SUR:
  vias: v2(74.22,72.08)
+1P05VSB_TON: length 1.8
  TOP w0.254: PU5.6 v1(75.74,67.39)
  BOTTOM w0.254: v2(76.48,67.5) 75.86,67.5 v1(75.74,67.39)
+1P05VSB_VBST:
  vias: v2(70.86,69.48)
+1P05VSB_VBST_RC: length 0.8
  BOTTOM w0.254: v2(68.23,69.31) 68.56,68.98 v1(68.93,68.98)
+1P05VSB_VCC: length 3.9
  TOP w0.254: PU5.21 71.51,68.96 70.82,68.27 v2(70.82,67.72)
  TOP w0.508: v2(70.82,67.72) 70.76,67.66 PC97.1 69.92,67.05 PR99.2
+1P05VSB_VIN:
  vias: v2(78.46,67.68)
+1P8VSB: length 30.4
  IN2 w0.127: 58.88,87.44 59.1,87.72 ; 57.45,85.66 57.55,86.05
  IN2 w1.016: 68.62,64.81 69.49,65.68 69.49,67.14 74.25,71.9 74.25,81.31 71.58,83.99 66.24,83.99
  BOTTOM w0.457: PR7601.2 64.31,61.61 64.16,61.76 PC7601.1 ; PC7603.1 64.29,60.65 64.2,60.56 PC7602.1
  vias: v1(51.26,87.26) v1(51.26,86.53) v1(66.55,62.42) v1(66.98,61.94) v2(64.82,62.68)
+1P8VSB_EN_A: length 9.6
  BOTTOM w0.127: PU7601.2 64.87,52.31 65,52.19 66.78,52.19 66.9,52.31 66.9,53.03 67.11,53.23 PC7606.1 PR7607.2 68.03,52.77 69.42,52.77 v2(69.92,53.28) 69.92,53.96 69.8,54.09 PR93166.2
+1P8VSB_PG: length 17.1
  TOP w0.254: v1(70.2,55.59) 72.28,55.59 73.87,57.19 73.87,59.34 73.14,60.07 73.14,63.07 v1(73.28,63.21)
  BOTTOM w0.254: v1(73.28,63.21) 73.28,63.6 R93166.1
  BOTTOM w0.457: v1(70.2,55.59) 69.95,55.84 v2(69.06,55.84) 68.49,55.84 67.52,54.88 PR7609.2 67.38,54.19 66.36,53.16 PU7601.1
+1P8VSB_VDD_A: length 4
  BOTTOM w0.254: PU7601.4 61.49,53.16 PC7605.1 60.73,51.83 60.49,51.59 PR7608.2 61.28,51.35 v2(61.4,51.48)
+1P8VSB_VREF_A: length 4.8
  BOTTOM w0.254: PU7601.7 64.87,59.3 65.43,59.86 PC7603.2 PR7601.1 66.17,61.61 v2(66.24,61.53) 66.24,61.52 66.2,61.48 PR7602.1
+1P24V_FB: length 5
  BOTTOM w0.254: v2(28.01,105.4) 28.37,105.76 PR760.1 PC762.2 29.31,105.74 PR761.2 29.91,105.15 30.94,105.15 31.31,104.78 PU76.4
+1P24VSB: length 9.4
  BOTTOM w0.254: v2(28.37,107.94) PR760.2 PC762.1 29.81,106.59 29.81,106.33 30.59,105.55 31.04,105.55 31.24,105.35 31.82,105.35 32.58,104.59 PU76.5
  BOTTOM w0.457: PU76.5 34.02,104.59 34.16,104.74 PC761.1 34.73,104.42 34.8,104.36 HR73.2
+2P5VPP: length 76.9
  TOP w0.305: DIMM1.257 91.88,55.96 v1(91.67,55.74) 91.38,56.03 DIMM1.259
  BOTTOM w0.508: 89.32,39.65 89.32,38.05 90.02,37.35 94.82,37.35 95.06,37.59 98.46,37.59 100.8,35.25 v2(101.52,35.25) 101.96,34.81 102.79,34.81 103.68,35.7 105.26,35.7 105.79,35.17 113.81,35.17 117.75,31.22 R93121.1
  BOTTOM w0.762: 89.97,69.03 89.97,67.07 88.82,65.93 88.82,63.36 89.58,62.6 90.25,62.6 ; 91.01,69.08 91,69.07 91,67.1 91.29,66.82 91.29,63.64 90.25,62.6 ; 90.25,62.6 90.25,62.4
  BOTTOM w1.524: 89.28,42.51 89.28,50.9 87.64,52.54 87.64,53.63 90.25,56.24 90.25,62.4
  vias: v3(88.6,69.84) v3(88.6,68.91)
+2P5VPP_DISCH_A: length 3.5
  BOTTOM w0.254: v2(117.78,26.91) 118.84,26.91 119.09,27.17 R93121.2 119.57,28.11 119.58,28.11 Q93037.3
+2P5VPP_EN_A: length 6
  BOTTOM w0.127: PU6.2 99.67,41.27 100.13,41.72 100.63,41.72 100.98,42.06 101.29,42.38 102.27,42.38 PC109.1 102.8,42.92 PR118.2 103.61,42.75 v2(103.61,41.9)
+2P5VPP_VDD_A: length 5.5
  BOTTOM w0.432: v2(100.29,37) PR117.2 101.29,37.89 101.37,37.96 PC941669.1 PC110.1 100.86,39.13 100.46,38.73 PU6.4
+2P5VPP_VREF_A:
  vias: v2(90.91,43.73)
+3P3V: length 1139.4
  TOP w0.178: v1(28.09,45.41) 28.42,45.74 28.42,46.82 28.42,46.83 28.15,47.09 28.15,47.97 28.51,48.33 28.51,51.71 29.21,52.4 R70291.2
  TOP w0.254: v1(146.61,156.86) 146.63,156.88 M1R24.1 M1R23.1 ; v3(158.27,34.2) 158.47,34.2 160.82,31.85 161.89,31.85 162.91,32.88 v1(165.63,32.88) 165.84,32.88 CR7.1 ; v1(7.75,88.2) 7.75,87.76 R70280.1 7.3,86.93 8.05,86.93 10.23,89.12 10.23,90.79 11.34,91.9 12.51,91.9 12.75,92.14 14.01,92.14 15.42,93.55 15.42,94.32 15.63,94.54 OR148.2 OR149.2 OR150.1 14.55,96.97 v1(14.32,96.74) ; v1(11.61,102.2) 11.61,102.79 OR72.2 ; v1(29.56,87.59) 30.7,87.59 v1(30.94,87.82) 31.53,87.82 SR674.1 ; R4818.1 v1(168,41.74) ; R6501.1 30.68,32.37 30.45,32.15 30.45,30.55 30.2,30.29 30.2,28.99 v1(30.3,28.89) ; v1(14.89,70.37) 14.89,70.86 R7216.1 ; M1Q9.1 138.01,161.34 v1(138.4,161.73) ; SR7838.2 29.42,77.89 v1(29.67,77.65) ; R70300.1 85.91,74.46 86.19,74.74 86.19,74.74 86.53,75.08 89.67,75.08 v1(90.24,74.51) 89.61,74.51 89.13,74.03 86.48,74.03 84.29,71.84 84.29,70.96 84.3,70.95 D4R5.1 D4R6.1 ; v1(150.52,160.04) 150.52,160.11 M1Q7.1 ; v1(30.61,81.17) 30.3,81.17 29.83,80.7 SR16.1 ; SR7902.1 103.63,169.81 101.34,167.53 101.34,166.89 101.66,166.58 102.6,166.58 102.84,166.33 v1(103.16,166.33) 103.66,166.33 103.98,166.65 C941645.1 103.98,167.75 104.07,167.85 SR7906.1 ; v1(66.41,124.63) 67.05,123.98 67.05,120.72 67.51,120.26 67.51,119.73 66.78,118.99 66.78,117.46 70.24,114 70.24,110.13 71.45,108.92 HR399.1 ; v1(151.38,159.5) 151.38,160.04 151.79,160.44 153.06,160.44 153.21,160.29 153.21,159.22 151.97,157.98 151.97,156.76 151.32,156.11 144.54,156.11 v1(143.99,156.66) Q9432.5 ; v1(14.74,114.52) 14.29,114.06 11.86,114.06 v1(11.68,113.88) 11.57,113.77 9.36,113.77 8.28,112.69 v1(8.02,112.69) 6.98,112.69 6.37,113.3 v1(5.13,113.3) ; R70279.1 5.88,86.57 v1(5.84,86.53) ; v1(144.68,161.31) 144.4,161.31 143.99,160.9 Q9432.2 ; SR7943.1 31.55,98.06 v1(31.46,98.15) ; R40.1 41.43,109.45 v1(41.18,109.69) 40.89,109.98 40.84,109.98 SR264.1 ; PR89105.1 88.26,168.94 86.57,168.94 v1(86.08,169.43)
  TOP w0.305: 112.85,164.9 112.08,164.9 M1R21.1 ; DIMM1.255 92.38,58.2 92.78,58.6 92.78,59.42 v1(93.13,59.76) ; DIMM2.255 92.37,71.78 D4C7.1
  TOP w0.432: OR146.2 OR147.2 17,99.84 v1(16.94,99.9)
  TOP w0.457: PR29.1 52.64,140.06 ; v1(160.73,78.09) FR1.1 ; v1(32.36,23.54) 32.09,23.54 R70299.1 ; v1(30.3,28.89) 30.3,28.59 30.9,27.99 32.05,27.99 R70292.2 ; D4C6.1 D4C8.1 D4C7.1
  TOP w0.508: L120.1 22.11,29.88 AR40.2 23.21,30.98 v1(23.21,31.38) ; v1(119.76,166.41) 115.7,166.41 114.18,164.9 112.85,164.9 ; Q93041.2 v1(103.16,166.33) ; v1(112.6,47.21) 112.6,46.66 112.14,46.21 95.46,46.21 95.05,46.61 91.2,46.61 89.86,47.95 89.86,50.93 91.22,52.29 v1(91.41,52.29) ; v1(90.24,74.51) 90.73,74.03 D4C6.1
  IN1 w0.203: v1(19.02,145.71) 18.95,145.79 15.93,145.79 14.17,144.02 14.17,143.27 14.58,142.86 14.58,139.31 15.39,138.5 v1(15.72,138.5)
  IN1 w0.229: v1(35.57,79.47) 35.57,79.47 35.57,79.42 35.12,78.97 34.52,78.97 34.27,79.23 32.93,79.23 32.49,78.78 30.91,78.78 30.63,79.06 30.23,79.06 29.67,78.5 v1(29.67,77.65)
  IN1 w0.254: v1(30.61,81.17) 30.91,81.17 31.31,81.57 31.31,83.66 30.2,84.77 30.2,86.95 v1(29.56,87.59) ; v1(32.36,23.54) 32.36,23.04 30.86,21.54 26.26,21.54 25.68,22.13 24.29,22.13 23.07,23.35 21.61,23.35 20.94,22.68 19.52,22.68 19.34,22.5 19.34,19.49 19.68,19.14 v1(20.61,19.14) ; v1(35.27,107.91) 36.26,108.91 38.98,108.91 v1(40.87,107.02) ; v1(47.01,150.51) 46.71,150.21 42.19,150.21 41.78,149.8 33.98,149.8 32.31,148.12 29.11,148.12 27.86,146.88 24.1,146.88 22.21,144.99 19.75,144.99 v1(19.02,145.71) ; v1(17.77,64.24) 15.66,66.34 15.66,69.31 14.89,70.09 v1(14.89,70.37) ; 12.88,52.14 9.38,55.63 9.38,56.57 9.07,56.88 v1(8.51,56.88) ; v1(52.96,71.03) 51.39,71.03 50.69,70.34 48.84,70.34 48.65,70.14 46.76,70.14 42.63,74.27 41.44,74.27 41.28,74.12 38.84,74.12 38.59,73.87 38.59,73.07 36.32,70.81 33.69,70.81 33.19,71.31 30.85,71.31 30.08,72.08 v1(29.68,72.08) ; v1(30.94,87.82) 30.94,89.67 31.37,90.11 31.37,91.02 31.08,91.32 31.08,92.16 v1(31.37,92.45) 30.89,92.93 30.89,94.95 31.06,95.12 v1(31.06,95.35)
  IN1 w0.508: v1(41.5,111.7) 41.5,111.65 41.85,111.31 45.4,111.31 45.83,111.74 45.83,114.43 46.18,114.77 46.18,120.25 45.18,121.24 38.95,121.24 v1(36.27,123.92) ; v1(2.59,28.49) 3.81,27.27 7.31,27.27 7.89,27.85 9.96,27.85 10.84,26.97 16.69,26.97 19.47,29.75 21.37,29.75 23,31.38 v1(23.21,31.38) 23.33,31.38 23.48,31.54 26.98,31.54 27.59,30.93 28.26,30.93 v1(30.3,28.89) ; v1(105.64,38.14) 105.64,39.89 v1(107.31,41.57) 111.83,46.09 112.11,46.09 112.6,46.57 v1(112.6,47.21)
  IN1 w0.762: 44.96,130.36 44.96,135.22 46.58,136.85 46.58,140.97 v3(46.07,141.48) ; 45.59,129.81 46.79,131.01 46.79,134.43 48.34,135.99 48.34,137.17 47.98,137.53 47.98,138.55 48.44,139 51.99,139 52.73,139.74
  IN1 w1.27: 14.48,49.57 16.34,47.7
  IN2 w0.127: 16.86,102.86 17.12,103.11
  IN2 w0.254: v1(91.41,52.29) 91.41,53.19 89.54,55.06 88.76,55.06 85.92,57.89 85.92,58.59 84.78,59.73 82.29,59.73 80.3,57.73 v1(74.59,57.73) ; v1(165.63,32.88) 166.34,33.59 166.34,35.52 167.33,36.52 167.33,41.07 v1(168,41.74) ; v1(144.68,161.31) 144.46,161.31 144.17,161.59 138.54,161.59 v1(138.4,161.73) ; v1(11.61,102.2) 11.28,102.53 11.28,108.17 12.61,109.5 12.61,112.33 11.68,113.26 v1(11.68,113.88) 11.92,113.88 12.27,114.23 12.27,116.03 v1(15.91,119.68) ; v1(143.99,156.66) 144.34,156.31 146.09,156.31 146.61,156.82 v1(146.61,156.86) ; v1(8.51,56.88) 8.91,57.28 8.91,59.78 9.66,60.53 9.66,63.1 8.43,64.33 8.15,64.61 8.15,65.34 v1(7.58,65.9) ; v1(56.51,54.3) 56.72,54.5 56.72,55.62 57.5,56.4 58.1,56.4 58.41,56.71 58.41,58.03 58.32,58.12 58.32,59.4 57.78,59.93 57.4,59.93 57.11,60.23 57.11,60.84 55.73,62.22 55.73,66.66 53.75,68.65 53.75,70.34 53.05,71.03 v1(52.96,71.03) ; v1(31.46,98.15) 31.44,98.15 30.97,97.67 30.97,95.45 v1(31.06,95.35) ; v1(119.76,166.41) 120.38,165.79 122.06,165.79 122.72,166.45 128.06,166.45 129.2,165.31 131.74,165.31 v1(131.9,165.14) ; v1(37.82,88.59) 37.87,88.64 v1(37.87,92.75)
  IN2 w0.508: 103.16,165.29 v1(103.16,166.33) ; 103.16,165.29 102.62,164.75 102.11,164.75 101.82,165.04 100.23,165.04 98.6,166.66 96.81,166.66 96.24,166.09 95.11,166.09 94.91,165.89 90.59,165.89 89.95,166.53 85.56,166.53 85.29,166.26 v1(81.96,166.26) ; 103.16,165.29 103.95,164.51 109.87,164.51 110.54,163.83 111.48,163.83 112.15,164.51 117.85,164.51 v1(119.76,166.41) ; v1(30.3,28.89) 30.62,29.21 34.48,29.21 v1(35.36,28.34) ; v1(129.74,28.11) 130.59,28.11 133,30.52 133.78,30.52 135.55,32.3 145.87,32.3 148.23,34.66 157.81,34.66 v3(158.27,34.2) ; v1(2.59,28.49) 2.61,28.46 2.61,26.58 2.01,25.98 2.01,24.26 3.53,22.75 5.79,22.75 7.22,24.18 v1(7.22,24.42) ; v1(111.24,59.14) 111.24,56.72 110.5,55.98 110.5,50.47 112.76,48.22 112.76,47.37 v1(112.6,47.21) ; v1(160.73,78.09) 160.09,77.46 160.09,66.28 161.9,64.48 v1(161.9,55.51) ; v1(44.73,129.48) 45.79,128.41 61.21,128.41 61.58,128.78 61.58,130.84 62.95,132.21 63.63,132.21 64.52,132.21 64.88,131.85 64.88,131.84 65.73,130.99 65.73,130.64 v1(66.29,130.09)
  IN2 w0.762: v3(128.19,33.95) 125.02,33.95 124.23,34.74 114.4,34.74 112.58,36.55 109.56,36.55 v3(109.29,36.29) ; v3(44.3,159.88) 44.96,160.54 45.46,160.54 51.23,166.31 63.22,166.31 64.46,167.55 80.67,167.55 v1(81.96,166.26)
  IN2 w1.27: v3(109.29,36.29) 108.56,35.55 107.01,35.55 105.89,34.43 96.29,34.43 95.02,35.7 95.02,37.15 89.54,42.63 85.39,42.63 84.29,41.53 77.32,41.53 74.08,44.77 74.08,46.21 72.79,47.49 ; 39.6,38.17 47.42,38.17 ; 70.43,45.79 69.92,45.28 69.92,45.28 62.19,37.56 53.34,37.56 52.81,37.02
  BOTTOM w0.191: O2CB8.1 26.02,105.27 25.07,105.27 24.78,105.56 U104.4
  BOTTOM w0.203: O2CB8.1 26.08,105.82 26.08,106.44 26.54,106.9 26.54,107.33 ; SR71.1 50.77,81.32 50.77,80.1 50.81,80.06 50.81,79.48 50.67,79.35 50.67,78.65 SR70.1
  BOTTOM w0.254: v1(29.67,77.65) 29.67,79.14 30.42,79.9 30.42,80.98 v1(30.61,81.17) ; v1(81.96,166.26) 81.66,166.57 81.66,167.54 82.52,168.4 83.98,168.4 84.39,168.81 PR89008.1 86.08,169.24 v1(86.08,169.43) ; R2354.1 43.31,104.01 R2353.1 ; OR136.2 15.6,113.78 OR134.2 14.65,114.28 14.74,114.38 v1(14.74,114.52) ; OR77.2 11.55,114.02 v1(11.68,113.88) 13.03,113.88 13.13,113.78 OR37.2 ; OR77.2 O2R12.1 ; OR77.2 10.87,113.61 10.92,113.56 OR78.2 10.92,112.66 10.87,112.61 OR79.2 ; v1(31.46,98.15) 31.55,98.24 34.67,98.24 34.81,98.38 34.81,98.63 34.97,98.8 R2341.1 35.34,98.3 35.44,98.2 SR7841.1 SR7847.1 ; 5.56,117.74 4.47,116.65 4.47,115.45 4.78,115.14 ; 5.56,117.74 5.56,118.68 5.02,119.22 5.02,123.58 5.73,124.29 Q9433.2 ; 5.56,117.74 5.61,117.74 OR76.2 ; v1(151.38,159.5) 151.05,159.5 v1(150.52,160.04) 150.39,160.04 149.12,161.31 v1(144.68,161.31) ; v1(31.37,92.45) 31.76,92.06 31.8,92.06 32.07,91.79 SR7897.1 ; v1(138.4,161.73) 138.4,161.58 137.31,160.49 134.54,160.49 v2(133.85,161.18) 131.9,163.13 v1(131.9,165.14) ; v1(56.51,54.3) 56.27,54.05 SR7887.1 ; SR777.1 8.53,56.9 v1(8.51,56.88) ; v1(74.59,57.73) 74.44,57.89 71.49,57.89 70.71,57.11 70.71,56.46 71.34,55.83 SR7953.1 ; v1(5.13,113.3) 4.74,113.3 4.46,113.58 4.46,114.81 4.78,115.14 ; v1(19.02,145.71) 19.21,145.71 R4001.1 ; OR73.2 OR74.2 OR75.2 7.72,112.44 7.97,112.69 v1(8.02,112.69) ; 4.78,115.14 RO1.1 ; O2R15.1 14.63,118.58 O2R13.2 15.13,119.83 15.76,119.83 15.9,119.69 15.9,119.69 v1(15.91,119.68) ; R39.1 41.44,106.62 41.27,106.62 v1(40.87,107.02) ; v1(16.94,99.9) 16.73,99.9 15.14,101.49 14.09,101.49 13.25,100.65 12.61,100.65 11.61,101.65 v1(11.61,102.2) ; v1(5.84,86.53) 6.95,87.64 7.18,87.64 v1(7.75,88.2) ; 32.36,22.21 32.63,21.94 PR93170.1 ; 32.36,22.21 v1(32.36,23.54) ; 32.36,22.21 29.81,19.66 29.81,18.82 29.03,18.05 AR29.1 ; v1(15.72,138.5) 15.61,138.38 R4009.1 ; SR7896.1 36.19,79.17 35.89,79.47 v1(35.57,79.47) ; v1(37.87,92.75) 37.87,93.26 37.22,93.91 37.21,93.91 SR258.1 36.35,94.35 35.82,94.88 34.86,94.88 34.05,95.7 31.63,95.7 31.29,95.35 v1(31.06,95.35) ; SR34.1 40.43,88.65 40.14,88.94 39.57,88.94 SR7895.1 38.73,89.09 38.25,89.09 37.96,88.8 37.96,88.8 37.82,88.66 v1(37.82,88.59) ; v1(35.27,107.91) 35.27,108.42 34.02,109.67 33.47,109.67 32.98,109.18 R2345.1 32.98,107.38 33.02,107.34 R2350.1 33.02,106.87 32.66,106.52 32.21,106.52 31.85,106.87 31.85,108.02 31.6,108.27 30.88,108.27 30.73,108.42 30.73,108.57 30.35,108.96 R2349.1 29.69,108.96 29.51,108.78 27.76,108.78 26.54,107.56 26.54,107.33 ; v1(107.31,41.57) 107.56,41.32 R93110.1 ; v1(20.85,111.75) 20.93,111.67 SR7794.2
  BOTTOM w0.305: SR70.1 51.27,78.05 51.27,77.38 SR108.1 51.37,76.97 51.37,76.54 51.3,76.46 51.29,76.46 50.98,76.15 50.98,75.27 51.78,74.48 SR345.1 SR344.1 52.75,74.06 SR7834.2 52.32,73.15 SR39.1 52.3,72.63 52.31,72.65 SR40.1 52.75,72.65 53.22,72.18 53.22,71.3 v1(52.96,71.03) 52.47,71.03 52.2,70.75 SR7848.1 ; v1(29.67,77.65) 29.67,77.64 29.5,77.47 29.5,75.5 29.35,75.36 29.35,72.72 29.68,72.39 v1(29.68,72.08) 29.46,71.86 29.46,70.11 28.21,68.85 28.21,67.07 SR134.1 26.99,67.66 21.44,67.66 20.66,66.88 20.66,65.63 19.27,64.24 v1(17.77,64.24)
  BOTTOM w0.432: R7217.1 7.31,65.64 v1(7.58,65.9)
  BOTTOM w0.457: v1(93.13,59.76) 93.13,56.56 92.75,56.18 92.75,55.48 92.18,54.9 D4R16.1 91.5,52.38 v1(91.41,52.29) 90.95,52.29 D4R17.1 ; v1(41.18,109.69) 41.18,107.33 v1(40.87,107.02) ; v1(105.64,38.14) 105.64,38.28 R99531.1 ; v1(90.24,74.51) 90.56,74.2 90.56,73.52 91.84,72.24 91.84,67.51 92.88,66.46 D4C19.1 92.07,64.97 92.07,62.26 D4C18.1 92.58,61.05 D4C17.1 ; v1(32.36,23.54) 32.36,25.99 31.41,26.94 29.92,26.94 29.46,27.4 R70293.2 29.84,27.97 30.3,28.43 v1(30.3,28.89) ; v1(111.24,59.14) 111.56,59.14 111.99,59.57 111.99,60.16 112.18,60.35 D4R7.1
  BOTTOM w0.508: v1(35.36,28.34) 35.36,33.8 35.68,34.12 35.68,35.63 35.18,36.13 35.18,38.45 35.81,39.08 38.48,39.08 v3(38.99,39.59) ; v1(93.13,59.76) 92.94,59.95 D4C17.1 ; v1(66.41,124.63) 66.41,129.92 66.27,130.06 66.27,130.09 v1(66.29,130.09) ; AC88.1 21.11,18.64 v1(20.61,19.14) ; v1(41.18,109.69) 41.18,111.38 v1(41.5,111.7) ; v1(105.64,38.14) 105.64,36.97 106.32,36.29 v3(109.29,36.29) ; R62.2 160.73,63.62 161.9,62.45 v1(161.9,55.51) 161.9,52.36 158.93,49.39 158.93,45.06 157.84,43.98 157.84,34.62 v3(158.27,34.2)
  BOTTOM w0.635: 39.35,127.48 P110.P1 ; P110.P1 40.17,126.65 ; P110.P1 40.17,128.31 ; 41.44,126.65 P110.P2 41.44,128.31
  BOTTOM w0.762: v3(46.07,141.48) 45.87,141.68 45.87,142.38 47.01,143.53 v1(47.01,150.51) 47.01,152.76 43.03,156.75 43.03,159.2 43.71,159.88 v3(44.3,159.88) ; 130.4,28.97 130.4,32.59 129.03,33.95 v3(128.19,33.95)
  vias: v1(12.67,88.08) v1(13.31,88.08) v1(16.89,77.92) v1(17.4,78.43) v1(43.46,129.48) v1(44.09,129.48) v1(52.68,139.99) v3(14.71,52.06) v3(14.83,51.17) v3(15.59,51.88) v3(16.38,60.34) v3(17.02,61.19) v3(17.32,60.35) v3(32.61,122.18) v3(32.74,123.08) v3(33.16,41.71) v3(33.62,42.48) v3(34.15,41.71) v3(39.75,39.11) v3(39.85,40.02) v3(53.31,139.44)
