# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SDI0: length 95.8
  TOP w0.127: U1.BE11 40,99.05 37.16,99.05 37.03,98.92 36.12,98.92 34.67,100.37 34.67,100.48 34.16,100.99 34.16,101.77 33.76,102.17 33.76,103.32 33.48,103.6 33.12,103.6 32.87,103.34 32.87,102.99 32.61,102.73 32.21,102.73 32.08,102.61 30.99,102.61 30.63,102.25 29.49,102.25 29.11,101.87 28.97,101.87 28.68,101.58 28.68,101.39 24.71,97.42 24.71,96.99 24.24,96.53 24.24,93.78 24.36,93.67 24.36,91.63 23.39,90.67 23.39,89.98 v2(23.29,89.88) 23.39,89.78 23.39,89.44 21.56,87.61 21.56,86.36 20.33,85.13 20.33,84.44 20.33,79.16 16.88,75.7 16.88,70.49 18.06,69.31 19.1,69.31 20.29,68.11 20.29,64.49 19,63.2 19,61.37 19.45,60.91 19.45,57.11 19.91,56.65 19.91,55.48 19.91,55.48 19.91,53.05 19.81,52.95 19.81,51.57 20.47,50.91 20.47,42.96 20.75,42.68 20.75,37.79 v1(19.86,36.9) ; SC87.1 19.45,34.64 19.76,34.94 v1(19.81,34.94) 20.22,34.53 SR7795.1
  BOTTOM w0.127: v1(19.81,34.94) 19.12,34.94 18.97,35.09 18.97,36.44 19.43,36.9 v1(19.86,36.9)
HDA_SDI0_R: length 13.1
  TOP w0.127: U6.8 17.29,25.11 17.22,25.18 17.22,27.69 19.48,29.95 19.48,30.6 19.94,31.05 19.94,32.42 20.41,32.9 20.41,32.97 20.65,33.21 SR7795.2 20.36,33.7 v1(20.03,33.37)
  BOTTOM w0.127: v1(20.03,33.37) 20.78,33.37 v2(21.59,32.55)
HDA_SDO: length 88.6
  TOP w0.127: U6.5 18.49,25.47 19.37,26.34 19.37,27.83 20.19,28.65 20.19,29.24 20.56,29.6 20.56,30.56 20.85,30.85 21.02,30.85 21.94,31.78 21.94,34.74 20.78,35.91 20.62,35.91 20.27,36.26 20.27,36.51 21.18,37.43 21.18,42.86 20.9,43.14 20.9,51.07 20.85,51.12 20.85,52.34 20.78,52.42 20.78,56.4 19.89,57.29 19.89,63.47 20.72,64.31 20.72,68.29 19.27,69.74 18.23,69.74 17.31,70.66 17.31,75.52 20.76,78.98 20.76,84.95 22,86.19 22,87.42 22.45,87.87 v2(22.83,87.87) 22.91,87.87 23.82,88.79 23.82,90.49 24.79,91.45 24.79,93.85 24.67,93.96 24.67,96.35 25.14,96.81 25.14,97.24 28.56,100.66 29.22,100.66 29.75,101.2 SR124.1
HDA_SDO_R: length 11.1
  TOP w0.127: U1.BF12 39.2,98.72 39.09,98.82 37.51,98.82 37.39,98.69 35.81,98.69 34.19,100.32 v2(34.11,100.32) 33.83,100.6 33.83,100.68 33.72,100.79 SC16.1 33.29,101.84 32.56,101.84 32.04,101.32 SR7812.1 31.33,101.32 30.91,101.74 SR124.2
HDA_SYNC: length 88.5
  TOP w0.127: v1(20.85,36.34) 20.85,36.44 21.61,37.2 21.61,43.04 21.34,43.32 21.34,50.11 21.87,50.65 21.87,51.67 21.44,52.1 21.44,54.85 21.21,55.08 21.21,56.57 20.32,57.47 20.32,63.29 21.16,64.13 21.16,69.11 20.1,70.17 19.12,70.17 v2(18.97,70.32) 18.26,70.32 17.74,70.84 17.74,75.35 21.19,78.8 21.19,84.77 22.59,86.17 22.59,86.78 24.26,88.44 24.26,90.31 25.22,91.28 25.22,94.03 25.11,94.14 25.11,96.17 25.45,96.51 25.75,96.51 26,96.77 26,97.47 28.04,99.5 29.14,99.5 29.18,99.46 29.75,99.46 30.11,99.81 SR125.1 ; U6.10 16.49,25.07 16.36,25.2 16.36,27.44 18.95,30.03 18.95,35.02 v1(19.4,35.47)
  BOTTOM w0.127: v1(20.85,36.34) 20.27,36.34 v1(19.4,35.47)
HDA_SYNC_R: length 9
  TOP w0.127: SR125.2 31.42,100.42 31.47,100.47 SC15.1 32.35,100.04 32.66,100.04 33.03,99.67 33.82,99.67 34.42,99.08 v2(34.54,99.08) 34.93,99.08 35.54,98.47 37.48,98.47 37.61,98.59 38.89,98.59 U1.BG13
HDD_LED+: length 10
  TOP w0.102: R69695.2 12.05,13.73 13.93,13.73 C248.1 14.65,13.02 19.13,13.02 20.25,11.9 CR15.1
HDD_LED-_EMI-: length 97.4
  TOP w0.102: v1(6.15,33.92) 6.58,33.49 6.58,29.67 6,29.1 5.01,29.1 4.14,28.22 4.14,25.2 4.82,24.51 4.82,22.69 4.47,22.33 4.47,20.82 4.81,20.48 4.81,17.23 5.91,16.13 5.91,14.55 6.8,13.66 9.13,13.66 9.51,14.03 16.09,14.03 C249.1 16.91,13.22 19.28,13.22 19.73,12.77 22.02,12.77 CR15.2 ; Q9435.3 29.09,50.07 29.59,49.57 29.59,46.64 30.22,46.01 31.3,46.01 32.29,45.02 32.29,43.82 32.6,43.51 32.6,40.29 33.85,39.03 33.85,37.73 34.14,37.45 34.14,32.07 33.85,31.79 33.85,31.07 33.21,30.43 32.79,30.43 32.17,29.81 32.17,29.37 v1(31.39,28.59)
  IN1 w0.102: v1(6.15,33.92) 9.51,37.28 15.05,37.28 20.37,31.97 27.25,31.97 27.81,31.41 28.57,31.41 v1(31.39,28.59)
  BOTTOM w0.102: Q9437.3 31.13,28.34 v1(31.39,28.59)
HDMI2_CABLE_DETECT: length 144.9
  TOP w0.102: J69.21 53.66,140.62 53.24,141.05 53.24,141.7 52.13,142.8 50.43,142.8 50.11,143.12 47.1,143.12 46.46,142.48 41.83,142.48 40.84,143.47 37.5,143.47 37.48,143.46 37.14,143.46 37.12,143.47 37.08,143.47 36.69,143.87 v1(36.69,144.18)
  IN1 w0.102: v1(44.51,77.35) 44.16,76.99 40.31,76.99 40.13,76.81 v1(37.39,76.81) ; v1(36.69,144.18) 36.58,144.18 32.12,139.72 32.12,135.88 28.76,132.53 28.76,132.13 26.26,129.63 25.01,129.63 24.4,129.02 24.4,124.2 27.13,121.47 27.13,119.65 26.38,118.9 26.38,118.26 27.2,117.44 27.2,115.66 26.73,115.19 26.73,113 27.32,112.42 27.32,111.37 27.07,111.13 27.07,110.19 28.75,108.51 28.75,107.78 29.03,107.5 29.03,105.84 29.03,105.25 28.64,104.85 28.64,104.33 29.41,103.55 29.41,102.36 30.04,101.73 31.38,101.73 32.26,100.85 32.26,100.21 32.65,99.82 32.65,98.81 33.36,98.1 33.36,96.19 33.97,95.58 33.97,93.54 34.31,93.21 34.62,93.21 35.02,92.8 35.02,92.47 36.88,90.61 36.88,88.74 36.64,88.5 36.64,87.78 36.83,87.59 36.83,86.96 36.49,86.61 35.38,86.61 35.12,86.35 35.12,86 35.97,85.15 36.01,85.15 36.55,84.6 36.55,83.97 36.36,83.77 v1(35.66,83.77)
  IN2 w0.102: v1(35.66,83.77) 36.25,83.19 37.23,83.19 37.91,82.5 37.91,80.83 37.64,80.56 37.64,78.76 37.18,78.3 37.18,77.56 37.39,77.36 v1(37.39,76.81) ; v1(58.8,78.15) 58.38,78.56 57.72,78.56 57.31,78.16 56.84,78.16 56.13,78.86 56.13,80 54.58,81.55 53.24,81.55 52.09,82.7 51.92,82.7 51.45,83.17 49.95,83.17 49.59,82.81 48.92,82.81 48.86,82.74 48.34,82.74 48.03,83.05 48.03,83.94 47.75,84.23 47.75,84.69 46.94,85.5 46.94,85.86 46.65,86.14 45.99,86.14 45.74,85.89 44.95,85.89 44.37,85.31 44.37,84.92 44.35,84.91 44.35,84.87 43.78,84.29 43.78,84.03 43.48,83.73 43.48,83.29 43.29,83.1 43.29,80.98 44.04,80.23 44.04,79.31 44.3,79.05 44.3,77.56 v1(44.51,77.35)
  BOTTOM w0.102: SR7977.2 58.8,78.16 v1(58.8,78.15) ; v2(34.8,84.11) 35.14,83.77 v1(35.66,83.77)
HDMI2_CABLE_DETECT_R: length 9.6
  TOP w0.102: v1(58.15,78.15) 57.61,78.15 57.41,77.95 56.92,77.95 56.75,77.95 55.7,79 55.7,81.02 55.6,81.12 55.6,81.36 55.36,81.6 U1.P47
  BOTTOM w0.102: SR7931.2 59.99,77.97 59.9,78.06 SR7977.1 58.6,77.12 v2(58.22,77.12) 58.15,77.18 v1(58.15,78.15)
HDMI_CTRL_CLK_LS: length 5.5
  TOP w0.102: Q9432.3 143.34,160.79 144.31,161.76 144.97,161.76 M1R26.1 146.15,161.49 146.15,161.61 J125.15
HDMI_CTRL_DATA_LS: length 14.7
  TOP w0.102: J125.16 146.94,163.44 147.68,162.71 147.68,161.57 M1R25.1 148.28,161.04 148.74,160.58 148.74,159.02 148.65,158.93 148.65,157.13 147.97,156.44 144.77,156.44 144.64,156.57 Q9432.6
HDMI_HPD_CON: length 14
  TOP w0.102: J125.19 148.44,161.52 148.94,161.02 148.94,158.69 149.28,158.35 149.86,158.35 150.02,158.19 D4310.1 150.02,157.09 150.15,156.96 M2R1.1 150.63,157.09 151.3,157.09 151.41,157.2 151.41,158.23 150.94,158.7 150.94,160.28 151.61,160.95 M1R14.2
HDMI_PD: length 15.3
  TOP w0.254: 134.54,158.89 134.8,159.15 RN134.2 ; RN134.8 132.22,159.45 132.92,158.76 ; RN133.2 141.98,158.86 141.37,158.26 ; RN134.6 133.11,158.9 ; RN133.4 141.09,158.28 ; RN134.4 133.91,158.84 ; RN133.8 139.4,158.91 140.03,158.28 ; M1Q9.3 v1(137.81,157.94) ; RN133.6 140.29,158.26
  IN2 w0.254: v1(133.75,158.13) 133.94,157.94 v1(137.81,157.94) 140.5,157.94 v1(140.66,158.1)
HDMI_TMDS_CLK_N: length 23.3
  TOP w0.127: M1C124.2 131.98,158.37 131.98,158.53 131.77,158.74 131.52,158.74 131.19,159.07 131.19,160.06 131.73,160.6 132.49,160.6 132.54,160.65 132.54,161.02 RN134.7 132.22,161.93 132.54,162.25 132.54,162.71 134.59,164.76 135.39,164.76 136.32,165.68 138,165.68 140.1,167.78 142.95,167.78 143.41,167.33 144.91,167.33 145.29,166.94 145.29,166.28 145.44,166.13 J125.12
HDMI_TMDS_CLK_P: length 23.3
  TOP w0.127: J125.10 143.94,165.93 144.17,166.16 144.83,166.16 145.03,166.36 145.03,166.84 144.8,167.07 143.3,167.07 142.84,167.53 140.21,167.53 138.11,165.43 136.42,165.43 135.5,164.51 134.69,164.51 132.8,162.61 132.8,162.29 133.11,161.97 RN134.5 133.11,161.12 132.79,160.8 132.79,160.54 132.59,160.35 131.83,160.35 131.44,159.96 131.44,159.17 131.62,158.99 131.88,158.99 132.23,158.64 132.23,158.47 M1C123.2
HDMI_TMDS_DATA0_N: length 8.6
  TOP w0.127: J125.9 143.33,162.4 143.18,162.24 143.18,161.66 142.91,161.39 141.82,161.39 141.68,161.25 141.68,161.15 141.98,160.85 RN133.1 141.98,160.56 141.55,160.14 141.55,160.04 141.63,159.97 142.54,159.97 142.82,159.68 142.82,158.13 M1C122.2
HDMI_TMDS_DATA0_P: length 8.7
  TOP w0.127: J125.7 142.92,161.92 142.92,161.77 142.81,161.65 141.72,161.65 141.43,161.36 141.43,161.2 141.09,160.87 RN133.3 141.09,160.47 141.3,160.26 141.3,159.93 141.52,159.71 142.44,159.71 142.57,159.58 142.57,158.24 142.13,157.8 141.73,157.8 141.55,157.62 141.4,157.62 M1C121.2
HDMI_TMDS_DATA1_N: length 19.2
  TOP w0.127: M1C120.2 135.1,158.55 135.1,158.77 135.3,158.96 135.3,160.27 135.17,160.39 134.46,160.39 134.23,160.62 134.23,160.73 133.91,161.05 RN134.3 133.91,161.92 134.29,162.3 134.29,162.71 134.56,162.98 135.21,162.98 136.43,161.76 137.22,161.76 138.43,162.97 138.43,164.66 140.63,166.87 142.09,166.87 142.44,166.52 J125.6
HDMI_TMDS_DATA1_P: length 19.3
  TOP w0.127: M1C119.2 135.36,158.3 135.36,158.66 135.55,158.86 135.55,160.37 135.28,160.64 134.57,160.64 134.49,160.73 134.49,160.87 134.8,161.18 RN134.1 134.8,162.01 134.54,162.27 134.54,162.6 134.67,162.73 135.1,162.73 136.32,161.51 137.33,161.51 138.68,162.86 138.68,164.56 140.74,166.61 141.98,166.61 142.19,166.41 142.19,166.18 142.03,166.03 141.07,166.03 140.94,165.9 J125.4
HDMI_TMDS_DATA2_N: length 7.4
  TOP w0.127: J125.3 140.36,161.82 140.36,161.45 140.29,161.38 RN133.5 140.29,160.4 140.1,160.21 140.1,159.93 139.89,159.71 138.99,159.71 138.73,159.45 138.73,158.22 139.14,157.81 139.56,157.81 139.77,157.6 139.91,157.6 M1C118.2
HDMI_TMDS_DATA2_P: length 7.5
  TOP w0.127: M1C117.2 138.48,158.12 138.48,159.56 138.89,159.97 139.78,159.97 139.85,160.04 139.85,160.12 139.4,160.57 RN133.7 139.4,161.34 139.5,161.43 139.98,161.43 140.1,161.56 140.1,161.74 J125.1
HPOUT1_JD: length 28.5
  TOP w0.127: v1(26.8,12.39) 26.8,12.72 D4308.2 27.16,12.75 27.6,12.32 J301.5 ; v1(10.91,23.17) 10.47,23.62 R69692.2
  BOTTOM w0.127: v1(10.91,23.17) 11.16,22.93 11.93,22.93 12.41,23.4 14.27,23.4 15.01,22.67 15.01,20.44 14.38,19.81 14.38,18.74 15.21,17.91 15.21,17.72 16.44,16.5 17.53,16.5 18.28,15.75 v2(19.48,15.75) 21.81,13.42 26.22,13.42 26.8,12.84 v1(26.8,12.39)
HPOUT1_JD_R: length 9.8
  TOP w0.127: R69692.1 R70263.1 8.47,24.07 11.07,24.07 11.81,24.81 12.4,24.81 AC98.1 13.22,24.53 v1(13.89,24.53) 14.38,24.04 U6.13
  BOTTOM w0.127: v2(14.58,23.92) 14.5,23.92 v1(13.89,24.53)
HPOUT1_L: length 8.4
  TOP w0.203: HR69.2 19.73,16.35 19.73,16.78 19.18,17.34 19.18,17.64 18.49,18.33 U6.32
  TOP w0.254: HR69.2 21.1,14.98 R70275.1 22.03,15.48 22.74,15.48 AR22.1 23.14,14.32 v2(23.26,14.19)
HPOUT1_R: length 34.8
  TOP w0.203: U6.33 18.89,18.36 19.75,17.5 19.75,17.22 20.27,16.7 20.27,16.65 20.85,16.07 21.33,16.07
  TOP w0.254: 21.33,16.07 23.93,16.07 AR23.1 24.61,15.39 v1(24.61,13.86) ; R70274.1 9.45,14.85 v1(9.5,14.8)
  IN1 w0.254: v1(9.5,14.8) 10.07,15.37 17.07,15.37 17.67,14.77 18.49,14.77 19.25,14.01 19.52,14.01 19.87,13.66 24.03,13.66 24.23,13.86 v1(24.61,13.86)
  BOTTOM w0.254: v1(24.61,13.86) 24.61,14.67 v2(23.47,15.81) 20.65,15.81 HR70.2
HPOUT2_L_B: length 9.2
  TOP w0.254: J89.2 44.32,9.03 44.32,12.16 44.18,12.3 D4301.2 44.18,14.11 C4301.1 43.51,13.9 43.51,13.22 43.35,13.06 L122.2
HPOUT2_R_B: length 5.8
  TOP w0.254: J89.3 40.37,11.8 D4302.2 40.7,13.58 41.21,13.58 C4302.1 41.48,14.39 41.32,14.54 L123.2
I2C0_SCL_R: length 14.4
  TOP w0.089: U1.BC22 40.75,93.88 39.49,93.88 39.48,93.87 38.42,93.87 37.91,94.38
  TOP w0.127: v2(29.68,95.39) 30.07,95.79 31.25,95.79 31.49,95.54 31.93,95.54 32.39,96.01 32.39,97.15 32.54,97.3 33.2,97.3 SR7935.2 34.07,96.43 34.08,96.43 34.53,95.98 35.12,95.98 35.91,95.19 36.32,95.19 37.13,94.38 37.91,94.38
I2C0_SDA_R: length 6.9
  TOP w0.089: 37.62,94.15 37.87,94.15 38.34,93.68 38.98,93.68 39.08,93.57 39.52,93.57 U1.BF23
  TOP w0.127: SR7934.2 33.89,95.65 34.98,95.65 35.77,94.86 35.93,94.86 v2(36.36,94.43) 36.64,94.15 37.62,94.15
INTRUDER: length 130.4
  TOP w0.127: v1(41.85,83.82) 41.57,83.54 U1.BB44 ; P305.4 v1(71.45,6.49) P305.3 ; v1(34.13,45.78) 35.87,44.05 35.89,44.03 35.89,41.42 38.58,38.72 38.69,38.72 49.78,27.63 49.78,22.5 51.88,20.4 52.43,20.4 52.97,20.94 58.42,20.94 v1(58.98,20.39) ; v1(32.55,64.87) 32.55,65.5 SR257.2 31.89,65.31 SC25.1
  IN1 w0.127: v1(34.13,45.78) 33.45,46.46 33.45,46.78 32.82,47.41 32.82,47.95 32.45,48.31 27.79,48.31 27.04,49.06 v1(24.61,49.06)
  BOTTOM w0.127: v1(58.98,20.39) 58.98,21.35 59.43,21.81 61.7,21.81 62.25,21.25 62.25,20.35 67.49,15.11 67.49,8.68 69.67,6.49 v1(71.45,6.49) ; v1(24.61,49.06) 26.77,51.22 28.39,51.22 28.72,50.89 29.19,50.89 29.44,51.14 29.44,51.55 28.85,52.14 28.85,56.88 29.61,57.64 29.61,58.22 30.09,58.7 30.09,60.46 31.47,61.84 32.36,61.84 v2(32.49,61.97) 32.79,62.27 32.79,64.63 v1(32.55,64.87) 32.55,67.39 33.25,68.09 36.24,68.09 36.8,68.65 36.8,73.27 36.22,73.85 36.22,75.02 38.76,77.56 38.76,77.62 38.76,78.58 39.04,78.86 39.04,79.01 38.31,79.73 38.31,80.11 38.49,80.29 38.57,80.29 38.99,80.71 39.52,80.71 40.12,81.31 40.12,81.81 41.07,82.77 41.07,82.9 41.35,83.18 41.35,83.32 v1(41.85,83.82)
INTRUDER_DET: length 21.2
  TOP w0.102: P305.1 v1(66.15,6.25)
  BOTTOM w0.102: SR7990.2 60.08,21.24 60.21,21.36 R3106.1 61.23,21.36 61.89,20.7 61.89,19.54 v2(62.66,18.76) 63.43,17.99 64.15,17.99 67.24,14.89 67.24,8.22 66.15,7.12 v1(66.15,6.25)
INTRUDER_DET_R: length 94.9
  TOP w0.102: v1(54.3,84.83) 54.3,84.55 53.95,84.19 52.04,84.19 51.66,83.81 51.66,83.24 U1.W46
  IN1 w0.102: v1(58.52,21.45) 58.89,21.82 58.89,25.18 64.49,30.79 64.49,34.91 65.1,35.52 65.1,37 64.84,37.25 64.84,40.35 67.09,42.6 67.09,48.93 67.47,49.31 68.19,49.31 68.44,49.56 68.44,57.91 69.32,58.79 69.32,59.42 69.07,59.67 66.83,59.67 v1(66.52,59.98)
  IN2 w0.102: v1(54.3,84.83) 54.3,83.91 54.89,83.33 55.8,83.33 56.39,83.91 56.72,83.91 57.02,83.61 57.02,83.38 57.38,83.02 59.23,83.02 59.89,83.68 60.4,83.68 61.47,82.61 61.47,80.35 62.46,79.36 62.97,79.36 63.26,79.66 64.58,79.66 66.48,77.75 66.48,72.41 66.64,72.25 67.41,72.25 68.18,71.48 68.18,68.04 68.18,67.3 67.52,66.64 67.52,64.16 66.09,62.72 66.09,60.41 v1(66.52,59.98)
  BOTTOM w0.102: v1(58.52,21.45) 58.52,20.03 58.8,19.75 59.51,19.75 59.69,19.93 SR7990.1 ; v1(54.3,84.83) 53.97,85.16 SR118.2 ; v1(66.52,59.98) v2(67.84,59.98)
IO_SMI_N: length 7.3
  BOTTOM w0.102: U104.126 21.51,109.31 21.82,109.62 21.82,111.11 22.35,111.65 23.19,111.65 v2(23.67,112.13) 23.03,112.77 OR29.2 ECR149.2
ITP_PMODE: length 154.9
  TOP w0.127: U1.AL3 46.56,103.47 46.56,103.95 46.71,104.1 46.71,105.65 46.81,105.75 46.81,106.31 46.4,106.71 v1(46.05,106.71)
  IN2 w0.127: v1(51.69,101.23) 51.46,101.46 51.46,101.87 52.17,102.58 52.17,103.29 51.66,103.8 50.8,103.8 49.93,104.66 47.09,104.66 46.91,104.84 46.91,106.37 46.57,106.71 v1(46.05,106.71) 44.33,108.43 42.83,108.43 42,109.26 40.98,109.26 39.57,110.67 38.73,110.67 38.18,111.22 33.56,111.22 32.26,109.92 32,109.92 30.42,108.34 29.39,108.34 27.82,106.77 26.49,106.77 26.05,106.33 26.05,105.95 24,103.91 24,101.54 22.39,99.93 22.39,99.12 21.77,98.5 21.77,97.8 20.92,96.95 20.92,95.54 21.31,95.15 21.31,93.55 20.44,92.68 20.44,90.18 19.99,89.73 19.99,88.7 20.44,88.25 20.44,86.61 21.12,85.94 21.12,78.4 20.43,77.71 20.43,74.25 21.09,73.59 21.09,73.13 20.97,73 20.97,63.79 21.64,63.12 21.64,62.31 v1(21.2,61.88) ; v1(88.05,123.38) 88.05,122.73 88.11,122.68 88.11,121.96 87.58,121.43 87.3,121.43 86.64,120.77 86.64,120.18 83.97,117.52 79.27,117.52 78.56,118.23 77.56,118.23 76.14,119.65 71.7,119.65 70.82,118.77 v1(70.43,118.77)
  BOTTOM w0.127: v1(51.69,101.23) 51.08,101.23 50.75,101.56 50.75,102.89 50.93,103.06 51.84,103.06 53.11,104.34 53.11,107.05 53.52,107.46 55.14,107.46 55.39,107.7 55.39,108.64 55.65,108.9 55.65,109.09 56.28,109.72 56.28,110.07 57.57,111.36 57.57,112.3 58.16,112.89 59.76,112.89 62.71,115.84 v2(62.71,116.17) 63.21,116.67 63.21,116.97 65.11,118.88 66.18,118.88 66.85,119.55 68.74,119.55 69.52,118.77 v1(70.43,118.77) ; v1(21.2,61.88) 20.37,61.88 18.63,60.14 17.91,60.14 17.55,59.78 15.59,59.78 15.18,60.2 12.22,60.2 SR165.1 ; v1(88.05,123.38) 87.73,123.7 87.72,123.7 HR377.2
ITP_PMODE_PCH_XDP: length 10.5
  TOP w0.127: v1(9.91,59.43) 10.08,59.26 v1(10.08,55.82)
  BOTTOM w0.127: SR165.2 10.07,59.58 v1(9.91,59.43) 9.73,59.61 v2(9.73,60.12) ; XDP3.46 10.65,55.25 v1(10.08,55.82) 10.59,56.33 10.59,56.91 10.4,57.1 SR758.2 SR823.1
ITPCLK/HOOK4: length 6.9
  BOTTOM w0.102: XDP3.40 12.15,55.85 12.5,56.2 13.23,56.2 13.81,56.78 13.81,57.82 13.71,57.92 13.71,57.99 SR167.2 13.1,58.59 v2(13.1,59.22)
J219_P70: length 3
  TOP w0.102: v2(20.52,105.4) 20.48,105.44 R3138.2 20.48,106.77 20.94,107.23 J219.70
KB_CLK: length 115.6
  TOP w0.127: J68.20 79.4,150.15 79.6,149.95 79.6,148.2 79.7,148.1 79.7,146.43 80.03,146.1 80.03,144.02 v1(80.01,143.99)
  IN2 w0.127: v1(14.91,105.53) 15.98,106.59 15.98,111.66 20.05,115.74 20.46,115.74 22.41,117.69 22.41,118.86 23.01,119.45 23.01,119.49 23.01,119.89 24.55,121.43 24.55,121.57 24.55,121.91 25.67,123.03 27.39,123.03 28.4,124.03 28.4,125.9 28.12,126.18 26.19,126.18 25.48,126.89 25.48,127.78 25.96,128.26 31.7,128.26 33.79,130.36 35.46,132.02 36.36,132.02 39.75,135.41 40.94,135.41 43.77,138.24 46.62,138.24 47.89,139.51 49.5,139.51 49.88,139.89 49.88,140.17 50.14,140.43 51.56,140.43 51.62,140.49 53.63,140.49 54.51,139.61 58.19,139.61 59.18,138.62 65.38,138.62 66.6,139.84 68.11,139.84 71.78,143.51 75.49,143.51 75.73,143.27 77.05,143.27 77.51,142.81 79.27,142.81 80.01,143.55 v1(80.01,143.99)
  BOTTOM w0.127: v2(16.79,114.9) 16.79,114.04 OR68.1 16.34,113.59 16.34,113.21 16.09,112.95 16.09,112.16 15.83,111.91 15.83,109.6 16.31,109.12 U104.113 16.31,107.61 16.18,107.48 14.95,107.48 14.69,107.23 14.69,106.87 14.97,106.59 15.34,106.59 15.57,106.37 15.57,105.89 15.2,105.53 v1(14.91,105.53)
KB_DATA: length 106.3
  TOP w0.127: J68.22 79.27,151.15 79.88,150.54 79.88,148.3 79.96,148.22 79.96,146.53 80.31,146.19 80.31,144.3 80.44,144.17 80.44,143.24 v1(80.48,143.21)
  IN2 w0.127: v1(80.48,143.21) 80.31,143.04 80.31,141.99 80.04,141.72 77.52,141.72 76.78,142.46 75.46,142.46 75.17,142.75 72.1,142.75 68.43,139.08 66.93,139.08 65.63,137.78 58.8,137.78 57.73,138.85 55.32,138.85 54.51,138.04 53.03,138.04 52.34,138.74 48.21,138.74 45.68,136.21 42.9,136.21 41.34,134.65 40.06,134.65 36.6,131.18 35.89,131.18 35.23,130.51 35.23,129.61 35.85,128.99 35.85,127.71 34.37,126.23 29.37,126.23 29.17,126.03 29.17,123.71 27.6,122.14 25.86,122.14 25.31,121.59 25.31,121.11 23.77,119.57 23.77,117.97 23.18,117.38 20.77,114.98 20.39,114.98 17.88,112.46 17.88,110.36 18.27,109.97 18.27,109.41 17.87,109 17.15,109 v1(16.5,109.66)
  BOTTOM w0.127: v1(80.48,143.21) 80.56,143.21 81.29,142.47 82.18,142.47 v2(82.45,142.74) ; U104.114 16.71,109.14 16.5,109.35 v1(16.5,109.66) 16.09,110.07 16.09,111.8 16.34,112.06 16.34,112.68 OR69.1
KBRST_N: length 68.6
  TOP w0.089: 38.89,85.53 39.42,85.53 39.59,85.58 40.05,85.58 U1.BE39
  TOP w0.102: 35.8,83.32 36.01,83.32 36.58,83.88 36.58,84.12 36.88,84.43 37.58,84.43 38.51,85.36 38.72,85.36 38.89,85.53
  TOP w0.127: SR16.2 30.95,80.69 32.25,80.69 32.8,81.23 32.8,81.74 33.69,82.63 34.45,82.63 v1(34.49,82.67) 35.06,82.67 35.71,83.32 35.8,83.32
  IN1 w0.127: v1(26.11,116.58) 26.11,116.07 25.3,115.26 25.3,112.59 25.91,111.98 25.91,110.26 27.98,108.19 27.98,107.46 28.26,107.18 28.26,106.16 28.26,105.57 27.86,105.18 27.86,103.97 28.59,103.25 28.59,102.06 28.32,101.79 28.32,99.95 29.13,99.14 29.13,96.02 30.3,94.86 30.3,90.94 30.14,90.78 30.14,88.49 30.25,88.38 30.25,87.35 31.46,86.13 31.46,85.09 33.88,82.67 v1(34.49,82.67)
  BOTTOM w0.127: v1(26.11,116.58) 26.11,117.01 24.79,118.33 22.88,118.33 v2(21.99,117.44) 20.75,116.19 20.38,116.19 19.95,115.76 18.4,115.76 17.99,115.36 17.99,114.85 17.99,114.85 17.99,109.98 18.31,109.67 U104.118
L23_1: length 0.9
  BOTTOM w0.254: v2(6.96,17.41) 6.78,17.24 v1(6.16,17.24)
L_AD0: length 34
  TOP w0.127: v1(41.76,85.13) 41.76,85.3 U1.BB39
  BOTTOM w0.127: ECR73.1 25.88,71.67 26.07,71.48 26.17,71.48 26.31,71.34 26.31,70.61 ECR110.1 25.63,69.93 25.63,69.54 v2(25.8,69.36) 26.07,69.09 26.91,69.09 27.79,69.97 27.79,71.82 28.5,72.54 28.5,75.71 28.65,75.86 28.65,79.29 29.59,80.24 29.59,82.38 31.29,84.07 31.61,84.07 32.13,84.6 32.54,84.6 C17.1 33.09,85.14 33.18,85.14 33.39,85.35 34.07,85.35 34.47,84.95 36.07,84.95 36.81,84.21 37.66,84.21 38.12,84.67 40,84.67 40.41,85.08 40.56,85.08 40.92,85.43 41.46,85.43 v1(41.76,85.13)
L_AD0_SIO: length 39.4
  BOTTOM w0.127: U104.8 23.27,103.96 20.75,101.43 20.75,95.11 21.84,94.02 22.27,94.02 22.73,93.56 23.02,93.56 23.52,93.07 23.52,92.26 24.65,91.13 24.65,88.85 25.42,88.08 27.29,88.08 28.27,87.1 28.27,85.7 28.83,85.14 28.83,80.56 27.89,79.61 27.89,78.73 v2(27.02,77.87) 26.74,77.58 26.74,77.08 26.26,76.6 26.26,75.53 26.82,74.97 26.82,74.1 26.08,73.37 26.08,73.1 ECR73.2
L_AD1: length 33.7
  TOP w0.127: v1(42.78,85.91) 42.79,85.91 U1.AW37
  BOTTOM w0.127: v1(42.78,85.91) 41.9,85.91 41.66,85.67 40.83,85.67 40.47,85.31 40.32,85.31 39.91,84.9 38.02,84.9 37.56,84.44 36.91,84.44 36.17,85.18 34.75,85.18 34.06,85.87 C18.1 33.4,85.66 33.3,85.66 33.07,85.44 32.61,85.44 31.75,84.57 31.43,84.57 29.34,82.48 29.34,80.35 28.4,79.4 28.4,75.96 28.24,75.81 28.24,73.07 28.25,73.07 28.25,72.65 28.24,72.64 27.53,71.93 27.53,70.45 27.29,70.21 ECR109.1 27.28,70.64 27.28,71.63 ECR74.1 27.21,72.06 27.43,72.28 27.43,72.54 v2(27.74,72.86)
L_AD1_SIO: length 38.1
  BOTTOM w0.127: ECR74.2 27.89,73.94 v2(27.89,76.37) 28.14,76.62 28.14,79.51 29.09,80.45 29.09,85.25 28.52,85.81 28.52,87.21 27.4,88.33 25.53,88.33 24.9,88.96 24.9,91.24 23.77,92.37 23.77,93.18 23.13,93.82 22.83,93.82 22.38,94.27 21.94,94.27 21,95.21 21,101.33 23.23,103.56 U104.9
L_AD2: length 37.6
  TOP w0.127: v1(43.42,85.96) 43.52,86.06 U1.AV37
  BOTTOM w0.127: v1(43.42,85.96) 43.42,85.85 42.02,84.46 41.55,84.46 41.08,83.99 40.31,83.99 40.09,84.22 38.31,84.22 37.9,83.8 37.9,83.54 37.47,83.11 35.08,83.11 34.89,83.3 34.16,83.3 33.93,83.07 C15.1 33.12,82.64 31.75,82.64 31.52,82.41 30.35,82.41 30.1,82.17 30.1,80.03 29.16,79.08 29.16,75.65 29.01,75.5 29.01,72.33 29.01,72.32 28.29,71.61 28.29,69.75 27.12,68.58 24.83,68.58 v2(24.05,69.36) 23.93,69.48 ECR108.1 24.36,70.61 24.36,71.34 23.93,71.77 ECR75.1
L_AD2_SIO: length 38.9
  TOP w0.127: v1(21.97,94.86) 21.97,93.35 v1(22.83,92.49) v2(21.93,92.49)
  BOTTOM w0.127: ECR75.2 23.93,73.32 24.08,73.47 24.08,73.93 23.82,74.18 23.82,74.89 25.5,76.56 25.5,76.56 26.19,77.26 26.19,78.21 27.38,79.39 27.38,79.82 28.32,80.77 28.32,84.93 27.76,85.49 27.76,86.89 27.1,87.55 25.23,87.55 24.14,88.64 24.14,90.92 22.83,92.23 v1(22.83,92.49) ; U104.10 23.26,103.16 21.26,101.16 21.26,95.32 21.72,94.86 v1(21.97,94.86)
L_AD3: length 35.8
  TOP w0.127: v1(42.31,85.46) 42.14,85.62 U1.BA38
  BOTTOM w0.127: ECR76.1 24.92,71.77 25.37,71.31 25.37,70.64 ECR107.1 24.76,70.03 24.76,69.15 25.08,68.84 27.02,68.84 28.04,69.86 28.04,71.72 28.76,72.43 28.76,75.6 28.9,75.75 28.9,79.19 29.85,80.13 29.85,82.27 30.37,82.79 30.83,82.79 v2(31.44,83.4) 31.55,83.51 31.8,83.51 31.99,83.7 32.32,83.7 C16.1 33.07,83.5 33.93,83.5 33.96,83.53 34.99,83.53 35.18,83.34 37.38,83.34 37.63,83.59 37.63,83.86 38.21,84.44 40.18,84.44 40.41,84.22 40.99,84.22 41.45,84.69 41.93,84.69 42.31,85.06 v1(42.31,85.46)
L_AD3_SIO: length 37
  TOP w0.127: v1(21.74,95.45) 21.99,95.45 22.4,95.04 22.4,94.48 v2(22.58,94.3) 22.58,93.4 v1(22.86,93.12)
  BOTTOM w0.127: ECR76.2 25.14,73.13 25.14,73.26 25.47,73.59 25.47,74.56 26.01,75.09 26.01,76.71 26.48,77.18 26.48,78.11 27.63,79.26 27.63,79.72 28.58,80.66 28.58,85.03 28.01,85.6 28.01,87 27.21,87.8 25.34,87.8 24.4,88.75 24.4,91.02 23.26,92.15 23.26,92.71 v1(22.86,93.12) ; U104.11 23.24,102.76 21.51,101.03 21.51,95.68 v1(21.74,95.45)
L_FRAME_N_R: length 21.9
  TOP w0.089: 39.06,85.93 39.07,85.94 39.56,85.94 39.59,85.94 39.8,86.15 U1.BE38
  TOP w0.102: 39.06,85.93 38.51,85.93 38.35,85.77 38.34,85.77 37.69,85.12 v1(37.17,85.12)
  TOP w0.127: ECR77.1 26.45,91.14 26.36,91.05 26.36,90.91 25.63,90.17 25.63,89.58 25.88,89.32 26.24,89.32 26.36,89.45 26.36,90.21 26.5,90.35 ECR106.1 27.39,90.35 27.43,90.31 v1(27.74,90.31)
  BOTTOM w0.127: v1(37.17,85.12) 36.57,85.71 35.33,85.71 35.11,85.94 35.11,86.9 34.57,87.44 34.24,87.44 34.1,87.58 34.1,88.29 33.09,89.3 32.99,89.3 32.71,89.57 32.71,90.13 32.33,90.52 31.18,90.52 31,90.69 30.31,90.69 29.91,90.29 v2(29.26,90.29) 28.3,90.29 28.28,90.31 v1(27.74,90.31)
L_FRAME_N_R_SIO: length 41.3
  TOP w0.127: ECR77.2 26.4,91.98 26.29,92.09 26.29,93.27 26.7,93.69 27.15,93.69 27.24,93.59 27.24,93.35 26.97,93.08 26.97,92.66 27.11,92.52 28.14,92.52 28.32,92.34 28.32,92.12 28.17,91.96 27.81,91.96 27.66,91.81 27.66,91.58 28.27,90.97 v1(28.55,90.97)
  BOTTOM w0.127: v1(28.55,90.97) 28.15,91.38 27.62,91.38 27.6,91.4 27.42,91.4 27.39,91.38 27.38,91.38 27.15,91.15 27.15,90.49 26.91,90.25 26.91,90.02 27.28,89.65 27.28,89.47 27.15,89.35 26.49,89.35 26.31,89.52 26.31,90.22 26.16,90.37 25.86,90.37 25.7,90.22 25.7,89.63 25.55,89.47 25.3,89.47 25.16,89.61 25.16,91.34 24.89,91.61 24.89,91.91 25.04,92.06 25.58,92.06 25.73,91.91 25.73,90.92 25.88,90.77 26.62,90.77 26.77,90.92 26.77,91.15 26.62,91.3 26.34,91.3 26.19,91.45 v2(26.19,92.22) 25.93,92.47 25.3,92.47 25.13,92.64 24.95,92.64 24.52,92.21 24.29,92.21 24.03,92.47 24.03,92.74 24.18,92.89 24.48,92.89 24.63,93.05 24.63,93.25 24.48,93.4 24.13,93.4 23.98,93.55 23.98,93.92 23.81,94.09 22.92,94.09 22.56,94.45 22.56,94.66 22.7,94.8 22.9,94.8 23.04,94.94 23.04,95.33 22.83,95.54 22.83,95.81 22.64,96 22.43,96 22.22,95.8 22,95.8 21.77,96.04 21.77,97.86 21.98,98.07 21.98,98.28 21.84,98.41 21.84,98.72 21.99,98.87 22.2,98.87 22.35,99.02 22.35,99.23 22.2,99.38 21.92,99.38 21.77,99.53 21.77,99.77 21.92,99.92 22.17,99.92 22.32,100.07 22.32,100.28 21.89,100.71 21.89,100.98 23.27,102.36 U104.12
LAD0_DEBUG: length 82.3
  TOP w0.127: v1(25.46,84.06) 25.46,82.68 25.17,82.39 25.17,82.18 23.53,80.55 23.53,77.78 23.09,77.33 v2(23.09,74.65) 23.09,73.55 23.45,73.18 24.04,73.18 24.23,73.37 24.23,74.01 24.8,74.57 v1(26.18,74.57) ; v1(6.48,126.1) P12.2
  IN1 w0.127: v1(25.46,84.06) 26.02,84.62 26.84,84.62 27.63,85.41 27.63,87.94 25.94,89.63 25.94,91.48 24.08,93.34 24.08,93.98 24.08,94.4 24.08,96.06 23.91,96.23 23.91,97.11 23.6,97.43 23.6,100.92 23.48,101.04 23.48,104.47 23.62,104.62 23.62,108.07 21.83,109.86 21.83,110.94 22.5,111.62 22.5,113.02 23.16,113.68 23.16,115.78 22.48,116.47 22.48,120.81 20.45,122.83 19.93,122.83 18.54,124.22 18.54,125.48 16.88,127.14 15.51,127.14 15.02,126.66 7.52,126.66 6.95,126.1 v1(6.48,126.1)
  BOTTOM w0.127: v1(26.18,74.57) 25.86,74.25 25.86,73.61 25.42,73.18 25.42,71.77 25.88,71.31 ECR110.2
LAD1_DEBUG: length 81.9
  TOP w0.127: v1(26.57,85.05) 27.84,83.78 27.84,82.55 27.55,82.26 26.82,82.26 26.35,81.79 25.85,81.79 24.41,80.34 24.41,78.51 24.49,78.42 24.49,75.76 25.17,75.08 26.33,75.08 26.43,75.19 26.43,75.84 v1(26.72,76.12) ; P12.4 6.31,125.1 v1(6.48,125.26)
  IN1 w0.127: v1(6.48,125.26) 7.62,126.41 15.13,126.41 15.61,126.89 16.78,126.89 18.29,125.38 18.29,124.11 19.82,122.58 20.35,122.58 22.2,120.73 22.2,116.34 22.91,115.63 22.91,113.79 22.25,113.13 22.25,111.72 21.57,111.05 21.57,109.76 23.37,107.97 23.37,104.72 23.22,104.58 23.22,100.93 23.34,100.82 23.34,97.33 23.66,97.01 23.66,96.12 23.81,95.97 23.81,93.25 25.69,91.37 25.69,89.47 27.29,87.88 27.29,85.44 26.89,85.05 v1(26.57,85.05)
  BOTTOM w0.127: v1(26.72,76.12) 27.32,75.52 v2(27.32,74.69) 27.32,73.98 26.82,73.47 26.64,73.47 26.39,73.22 26.39,71.72 26.59,71.52 26.59,71.3 ECR109.2
LAD2_DEBUG: length 81.7
  TOP w0.127: v1(23.63,73.75) 23.72,73.84 v2(23.72,76.9) 23.72,77.54 23.79,77.6 23.79,80.44 25.42,82.08 25.42,82.21 25.96,82.74 27.08,82.74 27.09,82.73 v1(27.41,82.73) ; v1(6.3,123.51) 5.71,124.1 P12.6
  IN1 w0.127: v1(6.3,123.51) 5.79,124.02 5.79,126.79 6.52,127.52 7.6,127.52 7.95,127.17 14.81,127.17 15.29,127.65 17.09,127.65 19.05,125.7 19.05,124.43 20.14,123.34 20.66,123.34 23.1,120.9 23.1,117.5 23.67,116.93 23.67,112.02 24.36,111.34 24.36,108.1 24.13,107.87 24.13,104.4 23.98,104.26 23.98,101.25 24.1,101.13 24.1,97.64 24.42,97.33 24.42,96.44 24.61,96.25 24.61,94.77 24.61,94.48 24.61,94.4 24.61,94.19 24.61,93.53 26.45,91.69 26.45,89.84 28.14,88.15 28.14,83.46 v1(27.41,82.73)
  BOTTOM w0.127: ECR108.2 23.37,71.58 23.37,73.48 v1(23.63,73.75)
LAD3_DEBUG: length 83.2
  TOP w0.127: P12.8 5.96,123.1 v1(6.32,122.73) ; v1(26.14,82.31) 26.02,82.31 24.15,80.45 24.15,78.4 24.24,78.31 24.24,74.82 v1(24.32,74.73)
  IN1 w0.127: v1(26.14,82.31) 26.21,82.31 26.65,82.74 26.81,82.74 27.29,83.22 27.29,83.38 27.88,83.98 27.88,88.05 26.2,89.73 26.2,91.58 24.36,93.42 24.36,93.98 24.36,94.4 24.36,96.14 24.17,96.33 24.17,97.22 23.85,97.54 23.85,101.03 23.73,101.14 23.73,104.37 23.87,104.51 23.87,107.97 24.1,108.2 24.1,111.23 23.42,111.92 23.42,115.89 22.73,116.57 22.73,120.91 20.56,123.09 20.03,123.09 18.79,124.32 18.79,125.59 16.99,127.4 15.4,127.4 14.92,126.91 7.85,126.91 7.49,127.27 6.63,127.27 6.04,126.69 6.04,124.5 6.46,124.08 6.46,124.07 6.73,123.81 6.73,123.33 6.32,122.92 v1(6.32,122.73)
  BOTTOM w0.127: ECR107.2 24.92,71.31 24.46,71.77 24.46,73.22 24.55,73.31 24.83,73.31 25.22,73.7 25.22,74.06 24.84,74.44 24.62,74.44 v1(24.32,74.73) 24.89,75.3 v2(25.5,75.3)
LAN1_GND: length 5.2
  TOP w0.457: C3102.2 16,167.5 15.99,167.49 J8.13 13.08,165.95 13.08,165.95 v2(13.05,165.95)
LAN2_GND: length 3.8
  TOP w0.457: J8.14 C3101.2 37.03,168.26 37.08,168.32 v2(37.74,168.32)
LAN_ACT#: length 32
  TOP w0.102: v1(15.44,146.55) 15.05,146.94 15.05,150.47 15.53,150.95 LC5.1 17.74,150.95 17.79,151.01 D3106.1 21.09,151.01 21.55,151.46 J8.10
  BOTTOM w0.102: U114.27 22.29,138.89 23.39,139.99 23.39,142 22.5,142.89 22.33,142.89 22.19,143.04 22.19,143.92 23.53,145.27 23.53,146.16 22.97,146.73 21.44,146.73 20.42,147.74 18.89,147.74 18.2,147.05 18.2,146.53 17.95,146.28 15.71,146.28 v1(15.44,146.55)
LAN_CLKREQ#_R: length 3.5
  BOTTOM w0.127: R4011.2 15.06,139.64 15.09,139.61 R4009.2 15.62,139.22 16.75,138.09 U114.12
LAN_DISABLE_N: length 168.2
  TOP w0.102: v1(96.57,7.84) 96.69,7.72 ECR156.1 ; U1.BF41 38.68,84.67 37.37,83.35 36.94,83.35 36.23,82.64 35.98,82.64 35.44,82.1 35.44,81.43 v1(35.03,81.01) 34.51,81.01 33.95,80.44 SR251.2 ; v1(22.38,33.16) 22.38,34.91 21.91,35.38 21.91,36.02 22.69,36.81 22.69,43.66 22.87,43.84 22.87,44.94 22.41,45.39 22.41,49.74 22.9,50.22 22.9,52.1 22.47,52.53 22.47,54.76 22.69,54.99 22.69,57.43 22.86,57.6 22.86,58.77 22.19,59.45 22.19,64.55 22.43,64.79 v1(22.43,65.37) ; v1(91.57,24.55) 90.63,25.49 88.57,25.49 84.81,29.25 79.09,29.25 78.28,28.44 v1(78.28,27.09)
  IN1 w0.102: v1(91.57,24.55) 91.57,19.32 95.73,15.15 95.73,14.09 97.46,12.36 97.46,8.73 v1(96.57,7.84)
  IN2 w0.102: v1(22.38,33.16) 22.6,32.93 26.72,32.93 26.87,32.79 46.19,32.79 52.93,26.05 62.9,26.05 63.17,25.78 68.46,25.78 69.8,27.12 75.51,27.12 75.67,26.96 78.15,26.96 v1(78.28,27.09)
  BOTTOM w0.102: v1(35.03,81.01) 34.83,80.81 34.3,80.81 33.87,80.38 33.51,80.38 33.24,80.64 31.95,80.64 31.92,80.67 31.41,80.67 30.98,80.24 30.98,79.67 30.86,79.55 30.86,78.42 30.12,77.68 30.12,77.46 29.81,77.14 29.81,75.38 29.66,75.23 29.66,72.97 30.1,72.53 30.1,71.44 29.97,71.31 29.97,68.64 29.65,68.33 29.65,66.4 28.68,65.42 27.63,65.42 26.78,64.57 23.76,64.57 22.96,65.37 v1(22.43,65.37) ; v2(90.78,25.14) 90.98,25.14 v1(91.57,24.55)
LAN_GATE#: length 0.9
  BOTTOM w0.457: v1(24.22,133.86) 23.96,133.86 v2(23.49,133.39)
LAN_ISOLATEB: length 7.6
  BOTTOM w0.102: v2(20.81,145.81) 20.6,145.6 20.6,144.26 20.33,144 R4001.2 20.09,143.47 R4002.1 20.27,143.21 20.43,143.04 20.43,142.25 20.15,141.96 19.68,141.96 19.15,141.43 19.15,140.83 18.95,140.64 U114.20
LAN_LED1: length 64.1
  TOP w0.102: Q2.1 37.86,160.68 v2(37.44,161.1) 37.34,161.2 R1.2 36.85,161.72 v1(36.85,161.61)
  IN2 w0.102: v1(36.85,161.61) 36.75,161.61 36.27,161.13 36.27,158.31 35.43,157.48 35.43,156.35 33.58,154.5 33.58,153.74 31.09,151.25 18.41,151.25 17.19,152.47 14.7,152.47 11.86,149.63 11.86,145.67 v1(12.51,145.02)
  BOTTOM w0.102: U114.26 22.39,139.29 23.19,140.1 23.19,141.92 22.45,142.65 22.28,142.65 21.98,142.95 21.98,144 23.33,145.35 23.33,146.08 22.88,146.52 21.35,146.52 20.34,147.54 18.97,147.54 18.4,146.97 18.4,146.44 18,146.04 14.8,146.04 14.65,145.89 13.77,145.89 12.9,145.02 v1(12.51,145.02)
LAN_LED1_R: length 32.4
  TOP w0.102: v1(35.71,163.87) 35.81,163.97 D3104.1 R1.1 ; J8.11 31.65,156.01 31.65,152.95 29.46,150.76 LC7.1 27.27,151.26 26.87,151.65 v2(26.67,151.65)
  IN1 w0.102: v1(35.71,163.87) 36.78,163.87 37.72,162.93 37.72,160.01 39.72,158 39.72,156.71 39.19,156.17 34.64,156.17 34.24,155.77 31.88,155.77 J8.11
LAN_LED2: length 62.9
  TOP w0.102: v1(35.99,161.55) 36.07,161.62 R2.2 36.42,161.85 36.42,161.38 36.49,161.32 Q2.2
  IN2 w0.102: v1(35.99,161.55) 35.99,158.32 35.23,157.56 35.23,156.44 33.37,154.58 33.37,153.82 31,151.45 18.59,151.45 17.35,152.69 14.64,152.69 11.61,149.66 11.61,145.25 v1(12.52,144.34)
  BOTTOM w0.102: U114.25 22.48,139.69 22.99,140.2 22.99,141.83 22.37,142.45 22.15,142.45 21.78,142.82 21.78,144.09 23.13,145.43 23.13,145.99 22.8,146.32 20.88,146.32 20.15,147.04 v2(19.18,147.04) 19.18,146.67 18.34,145.84 14.88,145.84 14.73,145.68 14.3,145.68 12.95,144.34 v1(12.52,144.34)
LAN_LED2_R: length 15.9
  TOP w0.102: R2.1 36.54,163.05 36.68,162.91 v1(36.7,162.91) ; v1(39.22,157.2) 39.11,157.3 LR11.1 37.9,156.73 37.9,156.65 LR10.2 LC8.1 35.96,156.16 35.95,156.15 D3103.1 33.8,156.15 J8.12
  IN1 w0.102: v1(39.22,157.2) 37.31,159.11 37.31,162.3 v1(36.7,162.91)
  BOTTOM w0.102: v1(39.22,157.2) 39.65,156.77 39.76,156.77 40.16,156.38 v2(40.16,156.38)
LAN_MDI0_N: length 25.2
  TOP w0.102: CM3104.3 15.01,126 14.78,125.77 14.78,125.22 v1(14.89,125.12)
  IN2 w0.102: v1(14.89,125.12) 14.89,125.97 15.35,126.43 16.2,126.43 16.31,126.33 16.31,126.06 16.61,125.76 17.25,125.76 17.6,126.11 17.6,127.75 17.84,127.99 18.45,127.99 18.82,128.36 18.82,130.29 18.16,130.95 18.16,131.28 19.07,132.2 20.34,132.2 20.67,132.53 20.67,133.26 20.37,133.57 20.37,134.48 20.67,134.79 21.77,134.79 21.99,134.56 21.99,133.54 21.89,133.44 v5(21.53,133.44)
  BOTTOM w0.102: v5(21.53,133.44) 21.86,133.44 22.01,133.58 22.01,133.94 22.12,134.06 22.12,134.4 22.01,134.51 20.88,134.51 20.25,135.14 20.25,135.93 20.15,136.02 U114.2
LAN_MDI0_N_C: length 20.3
  TOP w0.102: 15.21,136.92 15.21,135.04 14.5,134.33 14.5,133.47 14.78,133.19 14.78,132.56 14.92,132.41 D3101.1 14.92,131.98 14.99,131.91 14.99,130.71 14.92,130.65 D3101.10 14.92,129.86 14.78,129.71 14.78,128.26 15.01,128.03 CM3104.4 ; 15.21,136.92 v2(15.49,136.92) ; 15.21,136.92 15.21,140.1 15.37,140.25 15.37,142.56 13.92,144 13.92,145.43 14.21,145.72 LU3.12
LAN_MDI0_P: length 25.2
  TOP w0.102: CM3104.2 14.21,125.98 14.48,125.72 14.48,125.39 14.23,125.14 v1(14.08,125.14)
  IN2 w0.102: v1(22.43,133.77) 22.43,134.05 22.3,134.18 22.3,134.69 21.89,135.09 20.55,135.09 20.06,134.61 20.06,133.44 20.37,133.14 20.37,132.65 20.22,132.5 18.95,132.5 17.85,131.41 17.85,130.83 18.52,130.16 18.52,128.49 18.33,128.3 17.71,128.3 17.3,127.88 17.3,126.23 17.13,126.06 16.73,126.06 16.61,126.19 16.61,126.46 16.33,126.74 15.22,126.74 14.58,126.1 14.58,125.45 14.28,125.14 v1(14.08,125.14)
  BOTTOM w0.102: U114.1 20.55,135.27 21,134.81 22.14,134.81 22.43,134.52 v1(22.43,133.77)
LAN_MDI0_P_C: length 20.4
  TOP w0.102: CM3104.1 14.21,128.02 14.47,128.28 14.47,129.71 14.32,129.86 D3101.9 14.32,130.65 14.26,130.71 14.26,131.88 14.32,131.94 D3101.2 14.32,132.43 14.47,132.57 14.47,133.06 14.2,133.34 14.2,134.46 14.91,135.17 14.91,140.22 15.06,140.38 15.06,141.87 ; v2(14.78,141.87) 15.06,141.87 ; 15.06,141.87 15.06,142.43 13.61,143.88 13.61,145.33 13.21,145.73 LU3.11
LAN_MDI0N_T: length 14.8
  TOP w0.102: v1(13.99,153.69) 13.84,153.84 13.84,154.6 14.21,154.97 LU3.13
  IN1 w0.102: J8.2 23.25,154.54 22,154.54 21.85,154.6 21.84,154.61 21.8,154.63 21.49,154.63 21.16,154.95 16.69,154.95 16.52,154.78 16.52,154.07 16.24,153.79 15.68,153.79 15.4,154.07 15.4,154.78 15.23,154.95 14.48,154.95 13.99,154.47 v1(13.99,153.69)
LAN_MDI0P_T: length 14.7
  TOP w0.102: LU3.14 13.21,154.97 13.54,154.65 13.54,153.89 v1(13.35,153.7)
  IN1 w0.102: v1(13.35,153.7) 13.69,154.04 13.69,154.59 14.35,155.25 15.35,155.25 15.7,154.9 15.7,154.19 15.8,154.09 16.11,154.09 16.21,154.19 16.21,154.9 16.56,155.25 21.29,155.25 21.61,154.93 21.86,154.93 21.96,154.89 21.96,154.89 22.06,154.85 22.46,154.85 22.54,154.93 J8.1
LAN_MDI1_N: length 24.4
  TOP w0.102: RN127.3 12.75,125.93 12.54,125.71 12.54,125.09 v1(12.9,124.73)
  IN2 w0.102: v1(12.9,124.73) 12.9,124.73 12.9,124.73 12.76,124.73 12.57,124.92 12.57,125.24 12.67,125.34 12.98,125.34 13.69,126.05 13.69,126.99 14.4,127.7 15.52,127.7 17.22,129.4 17.22,130.01 16.79,130.44 16.05,130.44 14.91,129.3 14.53,129.3 14.4,129.43 14.4,130.11 15.59,131.31 16.51,131.31 17.44,132.24 17.44,134.05 17.78,134.38 18.36,134.38 18.67,134.08 v1(18.67,133.84)
  BOTTOM w0.102: U114.5 18.95,136 19.02,135.93 19.02,134.71 18.85,134.53 18.85,134.01 v1(18.67,133.84)
LAN_MDI1_N_C: length 21.2
  TOP w0.102: 13.72,135.42 v2(13.92,135.22) ; 13.72,135.42 14.04,135.75 14.04,142.21 10.96,145.3 10.96,145.44 11.21,145.7 LU3.9 ; 13.72,135.42 12.85,134.56 12.85,132.6 13.02,132.43 D3101.4 13.02,131.97 13.09,131.9 13.09,130.71 13.02,130.65 D3101.7 13.02,129.86 12.85,129.69 12.85,129.15 12.52,128.82 12.52,128.26 12.75,128.03 RN127.4
LAN_MDI1_P: length 24.4
  TOP w0.102: RN127.1 11.95,125.96 12.23,125.68 12.23,124.8 v5(12.13,124.69)
  IN2 w0.102: v1(19.33,134.41) 18.77,134.41 18.49,134.69 17.65,134.69 17.14,134.17 17.14,132.37 16.38,131.61 15.47,131.61 14.1,130.24 14.1,129.3 14.4,129 15.03,129 16.18,130.14 16.66,130.14 16.92,129.88 16.92,129.53 15.39,128.01 14.27,128.01 13.38,127.12 13.38,126.18 12.85,125.64 12.55,125.64 12.27,125.36 12.27,124.83 v5(12.13,124.69)
  BOTTOM w0.102: U114.4 19.35,136 19.33,135.98 v1(19.33,134.41)
LAN_MDI1_P_C: length 21.2
  TOP w0.102: v2(13.46,140.66) 13.74,140.66 ; 13.74,140.66 13.74,135.88 12.55,134.68 12.55,132.5 12.42,132.38 D3101.5 12.42,131.95 12.36,131.88 12.36,130.71 12.42,130.65 D3101.6 12.42,129.86 12.55,129.74 12.55,129.28 12.22,128.95 12.22,128.31 11.95,128.05 RN127.2 ; 13.74,140.66 13.74,142.08 10.59,145.23 10.59,145.3 10.21,145.68 LU3.8
LAN_MDI1N_T: length 22.1
  TOP w0.102: LU3.16 11.21,153.38 10.93,153.1 10.59,153.1 v1(10.46,152.97)
  IN1 w0.102: v1(10.46,152.97) 10.56,153.08 11.25,153.08 11.73,152.59 16.74,152.59 17.92,153.78 20.63,153.78 20.99,153.42 21.66,153.42 22.04,153.33 22.48,153.33 22.96,152.85 25.35,152.85 26.73,154.23 J8.6
LAN_MDI1P_T: length 22
  TOP w0.102: LU3.17 10.21,154.57 10.31,154.47 10.79,154.47 10.91,154.36 10.91,153.51 10.81,153.41 10.56,153.41 v1(10.36,153.61)
  IN1 w0.102: J8.3 24.58,153.76 24.68,153.66 25.04,153.66 25.24,153.46 25.24,153.25 25.14,153.15 23.09,153.15 22.6,153.63 22.07,153.63 21.69,153.72 21.12,153.72 20.76,154.09 17.8,154.09 16.61,152.9 11.86,152.9 11.38,153.38 10.59,153.38 v1(10.36,153.61)
LAN_MDI2_N: length 22.3
  TOP w0.102: RN126.3 10.52,125.59 10.48,125.55 v1(10.48,125.18)
  IN2 w0.102: v1(10.48,125.18) 10.48,125.95 10.37,126.05 10.11,126.05 9.89,125.83 9.61,125.83 9.37,126.07 9.37,127.24 9.65,127.52 10.18,127.52 11.37,126.34 12.02,126.34 12.47,126.79 12.47,127.6 11.83,128.23 11.83,128.56 12.01,128.74 12.95,128.74 13.23,129.02 13.23,129.78 12.95,130.06 12.95,130.36 v1(15.46,132.87)
  BOTTOM w0.102: U114.7 18.15,135.99 18.39,135.75 18.39,135.13 16.75,133.49 15.67,133.49 15.46,133.28 v1(15.46,132.87)
LAN_MDI2_N_C: length 23.3
  TOP w0.102: RN126.4 10.52,128.66 10.42,128.76 10.12,128.76 10.02,128.86 10.02,129.29 10.39,129.66 10.71,129.66 10.81,129.76 D3102.10 10.81,130.59 10.9,130.67 10.9,131.94 10.81,132.03 D3102.1 10.81,132.59 10.74,132.65 10.74,134.1 12.88,136.24 12.88,138.04 ; 12.88,138.04 v2(13.16,138.04) ; 12.88,138.04 12.88,141.72 9.37,145.22 8.34,145.22 8.21,145.35 LU3.6
LAN_MDI2_P: length 22.4
  TOP w0.102: RN126.1 9.72,125.63 9.83,125.52 v1(9.83,125.19)
  IN2 w0.102: v5(16.24,132.86) 15.72,133.38 15.61,133.38 15.37,133.38 14.96,132.96 14.96,132.8 12.65,130.49 12.65,129.94 12.93,129.66 12.93,129.15 12.83,129.05 11.89,129.05 11.53,128.69 11.53,128.11 12.17,127.47 12.17,126.91 11.89,126.64 11.5,126.64 10.31,127.83 9.52,127.83 9.07,127.37 9.07,125.95 v1(9.83,125.19)
  BOTTOM w0.102: U114.6 18.55,136.02 18.69,135.88 18.69,135 16.88,133.19 16.56,133.19 v5(16.24,132.86)
LAN_MDI2_P_C: length 23.3
  TOP w0.102: 10.44,133.47 10.44,134.23 12.57,136.36 12.57,141.6 9.25,144.92 8.22,144.92 7.96,145.17 7.37,145.17 7.21,145.33 LU3.5 ; 10.44,133.47 v2(10.16,133.47) ; 10.44,133.47 10.44,132.82 10.21,132.59 D3102.2 10.21,132.02 10.13,131.94 10.13,130.67 10.21,130.6 D3102.9 10.21,129.91 9.72,129.42 CM3102.1
LAN_MDI2N_T: length 23.8
  TOP w0.102: LU3.19 8.21,154.96 7.87,154.63 7.87,154.02 8.25,153.63 v1(8.48,153.63)
  IN1 w0.102: J8.5 26.35,155.06 25.88,155.06 25.75,155.18 25.75,155.9 25.24,156.42 11.14,156.42 9.19,154.47 9.19,153.44 9.06,153.3 8.81,153.3 v1(8.48,153.63)
LAN_MDI2P_T: length 23.8
  TOP w0.102: LU3.20 7.21,154.99 7.57,154.63 7.57,153.89 8.13,153.33 v1(8.46,153)
  IN1 w0.102: v1(8.46,153) 9.18,153 9.5,153.31 9.5,154.35 11.27,156.12 25.11,156.12 25.45,155.78 25.45,155.06 25.6,154.9 J8.4
LAN_MDI3_N: length 20.1
  TOP w0.102: RN125.3 8.28,124.68 v1(8.2,124.6)
  IN2 w0.102: v1(8.2,124.6) 7.87,124.93 7.87,125.72 8.18,126.03 8.18,128.26 9.22,129.3 9.83,129.3 14.43,133.9 14.43,134.28 14.96,134.81 15.87,134.81 15.98,134.71 15.98,134.47 v1(15.76,134.25)
  BOTTOM w0.102: U114.10 17.01,137.29 16.69,136.97 16.69,135.38 15.98,134.67 15.98,134.47 v1(15.76,134.25)
LAN_MDI3_N_C: length 25.8
  TOP w0.102: 11.71,139.49 11.71,141.21 9.17,143.75 5.7,144.73 5.47,144.8 5.08,144.8 4.8,145.07 4.8,145.33 4.95,145.48 4.95,145.48 5.21,145.74 LU3.3 ; 11.71,139.49 v2(11.99,139.49) ; 11.71,139.49 11.71,136.74 8.76,133.8 8.76,132.86 8.91,132.71 D3102.4 8.91,131.94 8.98,131.87 8.98,130.66 8.91,130.59 D3102.7 8.91,129.86 8.79,129.73 8.79,128.95 8.02,128.18 8.02,127.7 8.28,127.44 CM3101.4
LAN_MDI3_P: length 20.1
  TOP w0.102: v1(7.4,124.6) 7.48,124.68 RN125.1
  IN2 w0.102: v1(7.4,124.6) 7.57,124.77 7.57,125.85 7.87,126.15 7.87,128.39 9.09,129.61 9.7,129.61 14.12,134.03 14.12,134.41 14.83,135.12 16,135.12 16.28,134.84 16.28,134.47 v1(16.39,134.36)
  BOTTOM w0.102: U114.9 17.04,136.89 16.99,136.85 16.99,135.26 16.34,134.6 16.34,134.41 v1(16.39,134.36)
LAN_MDI3_P_C: length 25.8
  TOP w0.102: LU3.2 4.21,145.71 4.49,145.43 4.49,144.95 4.95,144.49 5.43,144.49 9.01,143.48 11.4,141.09 11.4,136.87 8.46,133.92 8.46,132.86 8.31,132.71 D3102.5 8.31,131.94 8.24,131.87 8.24,130.66 8.31,130.59 D3102.6 8.31,129.85 8.48,129.68 8.48,129.07 8.13,128.72 ; CM3101.1 7.48,127.44 7.72,127.68 7.72,128.31 8.13,128.72 ; 8.13,128.72 v2(7.92,128.92)
LAN_MDI3N_T: length 30.3
  TOP w0.102: v1(5.71,154.37) 5.47,154.13 5.12,154.13 4.85,154.4 4.85,154.6 5.21,154.96 LU3.22
  IN1 w0.102: v1(5.71,154.37) 6.27,154.37 9.49,157.59 28.07,157.59 29.79,155.87 29.79,155.01 29.68,154.9 J8.8
LAN_MDI3P_T: length 30.4
  TOP w0.102: LU3.23 4.21,154.96 4.55,154.63 4.55,154.27 5.08,153.74 v1(5.69,153.74)
  IN1 w0.102: v1(5.69,153.74) 6.02,154.07 6.4,154.07 9.62,157.29 27.95,157.29 29.49,155.74 29.49,155.13 29.41,155.06 28.94,155.06 J8.7
LAN_RSET: length 3.3
  BOTTOM w0.102: U114.31 21.25,137.29 21.33,137.38 22.01,137.38 R4010.1 21.69,135.92 v2(21.69,135.68)
LAN_WAKE#_R: length 7.5
  BOTTOM w0.102: U114.21 19.35,141.34 19.77,141.76 20.23,141.76 20.64,142.17 20.64,142.79 R4004.2 R4007.1 21.4,144 22.63,145.23 v2(22.63,145.79)
LAN_XTAL_IN: length 4.5
  BOTTOM w0.127: R4008.2 C4023.2 23.58,137.75 22.91,138.42 v2(22.91,138.8) 22.66,138.55 21.56,138.55 21.51,138.49 U114.28
LAN_XTAL_IN_R: length 2.7
  BOTTOM w0.127: v2(24.74,139.54) R4008.1 25.92,138.58 Y4000.3
LAN_XTAL_OUT: length 8.8
  BOTTOM w0.127: U114.29 21.67,138.09 21.88,138.3 22.57,138.3 22.95,137.92 22.95,137.82 v2(23.85,136.92) 23.96,136.81 C4022.2 24.9,136.81 25.47,137.38 27.73,137.38 Y4000.1
LANCLK_REQ_N: length 273.6
  TOP w0.127: U1.AR32 44.85,88.93 v1(44.85,88.66)
  IN1 w0.127: v1(37.01,81.68) 37.01,81.83 36.86,81.98 36.86,82.52 37.13,82.79 37.57,82.79 38.33,83.56 38.33,83.98 40.04,85.69 40.04,86.89 41.63,88.48 42.47,88.48 43.05,89.07 44.45,89.07 v1(44.85,88.66) ; v1(29.07,59.11) 30.5,59.11 30.95,58.66 32.79,58.66 33.69,59.55 35.76,59.55 36.5,58.82 36.5,58.28 37.66,57.11 38.8,57.11 40.17,55.74 42.97,55.74 43.74,54.98 44.1,54.98 45.22,56.1 48,56.1 48.44,56.53 48.67,56.53 49,56.86 50.15,56.86 50.69,57.39 50.69,57.98 51.71,59.01 52.55,59.01 53.04,59.5 55.8,59.5 56.24,59.95 58.33,59.95 59.18,60.8 60.48,60.8 60.65,60.62 61.64,60.62 62.65,61.64 64.28,61.64 66.08,63.44 v1(68.4,63.44) ; v1(43.75,144.68) 44.15,144.27 46.44,144.27 48.02,142.69 52.55,142.69 56.44,138.8 56.92,138.8 57.37,138.35 57.37,135.01 56.98,134.62 56.98,131.4 58.68,129.7 58.68,127.18 57.83,126.33 56.95,126.33 54.99,124.37 54.99,121.3 54.13,120.44 54.13,119.09 55.6,117.62 55.6,114.29 55.78,114.11 v1(55.78,114.1)
  IN2 w0.127: v1(55.78,114.1) 56.72,113.16 56.72,109.57 57.2,109.08 57.2,105.1 58.01,104.28 59.89,104.28 60.31,104.28 61,103.59 61,102.62 61.42,102.2 61.42,101.21 62.75,99.88 65.86,99.88 66.68,99.05 68.05,99.05 71.45,95.65 71.45,95.09 72.38,94.16 72.67,94.16 72.99,94.48 76.88,94.48 77.95,95.55 81.75,95.55 88.53,88.78 88.53,79.78 86.14,77.4 86.14,63.43 84.89,62.17 v1(84.12,62.17) ; v1(17.6,144.62) 18.9,143.32 19.58,143.32 20.75,142.15 29.1,142.15 29.31,142.36 31.09,142.36 32.15,141.29 35.44,141.29 35.83,140.91 37.26,140.91 40.74,144.39 42.07,144.39 42.36,144.68 v1(43.75,144.68)
  BOTTOM w0.127: R4011.1 14.88,141.02 14.88,141.77 14.36,142.3 14.36,142.98 14.1,143.25 14.1,143.92 14.94,144.76 15.66,144.76 15.87,144.54 17.52,144.54 v1(17.6,144.62) ; v1(29.07,59.11) 29.07,61.22 v2(29.82,61.97) 29.82,62.6 31.39,64.18 31.39,67.48 33.07,69.15 34.9,69.15 35.71,69.97 35.71,72.22 34.26,73.66 34.26,79.43 34.72,79.89 35.49,79.89 35.83,80.23 36.1,80.23 SR7896.2 36.73,79.61 36.83,79.61 SR7878.2 37.43,80.06 38.19,80.83 38.35,80.83 38.45,80.93 38.45,81.64 SR911.2 37.63,81.68 v1(37.01,81.68) ; v1(84.12,62.17) 84.35,61.94 84.35,61.17 81.95,58.77 77.48,58.77 76.06,60.19 72.59,60.19 69.33,63.44 v1(68.4,63.44)
LANLED2: length 11.8
  BOTTOM w0.102: LR9.2 LC6.1 15.25,147.21 15.76,147.21 D3105.1 16.49,147.09 16.49,147.58 17.1,148.19 17.1,148.96 16.01,150.05 16.01,150.63 17.91,152.53 J8.9
LANWAKE_R_N: length 108.5
  TOP w0.089: U1.BG44 38.83,83.05 38.44,82.66 38.44,82.11 37.9,81.57 37.9,81.47
  TOP w0.102: SR254.2 33.34,77.43 33.34,77.56 v1(33.76,77.98) 34.35,78.58 36.07,78.58 37.69,80.2 37.69,80.47 37.9,80.68 37.9,81.47
  IN1 w0.102: v1(33.76,77.98) 33.18,77.41 31.78,77.41 31.06,76.69 29.32,76.69 27.8,78.2 24.53,78.2 23.12,79.61 23.12,85.87 23.44,86.19 23.44,86.93 21.68,88.69 21.68,90.28 20.05,91.9 20.05,94.64 19.62,95.07 19.62,101.46 18.74,102.34 18.74,107.5 17.16,109.07 17.16,112.8 18.84,114.48 18.84,116.3 19.08,116.54 19.08,118.67 19.84,119.42 v1(19.84,120.18)
  IN2 w0.102: v1(33.98,135.24) 32.91,134.17 31.43,134.17 30.54,133.28 29.56,133.28 29.12,132.84 29.12,131.86 27.4,130.14 25.2,130.14 23.61,128.55 23.61,126.44 23.53,126.36 23.53,124.05 21.97,122.49 21.97,122.09 20.06,120.18 v1(19.84,120.18)
  BOTTOM w0.102: Q4001.3 23.77,143.55 24.13,143.91 24.13,144.39 24.89,145.15 26.16,145.15 26.44,144.87 26.44,143.11 27.43,142.12 27.43,140.04 27.83,139.64 29.06,139.64 30.33,138.37 30.33,138.05 32.34,136.03 v2(32.92,136.03) 33.2,136.03 v1(33.98,135.24)
LDO1_CAP: length 0.8
  BOTTOM w0.254: v2(16.94,17.19) 16.54,17.6 v1(16.32,17.6)
LDO2_CAP: length 4.9
  TOP w0.203: 21.58,20.39 21.23,20.39 21.18,20.44 U6.39
  TOP w0.254: 21.58,20.39 21.98,20.39 v1(22.27,20.09)
  BOTTOM w0.254: v1(22.27,20.09) 22.67,20.09 23.01,19.75 23.2,19.75 23.46,19.48 AC89.1 24.48,19.91 v2(24.48,20.49)
LDO3_CAP: length 6.5
  TOP w0.203: v1(17.65,25.4) 17.69,25.36 U6.7
  BOTTOM w0.508: AC82.1 21.38,25.29 21.24,25.43 20.2,25.43 19.72,24.95 18.1,24.95 v1(17.65,25.4) 17.65,25.18 v2(17.18,24.71)
LINE1-L: length 3.6
  TOP w0.203: U6.22 14.33,20.44 13.69,19.8 13.13,19.8 v4(12.97,19.97)
  TOP w0.254: v4(12.97,19.97) 12.49,20.44 AC100.2
LINE1-L_C: length 19
  TOP w0.254: v1(9.7,18) 9.98,18.28 9.98,19.32 9.97,19.33 10.27,19.62 AC100.1 ; R70275.2 22.37,14.57 22.12,14.32 20.73,14.32 v2(20.06,14.98) 19.18,14.98 18.48,14.28 v1(17.73,14.28)
  BOTTOM w0.254: v1(9.7,18) 10.42,18.72 13.37,18.72 14.51,17.57 14.51,17.43 16.19,15.76 16.74,15.76 17.73,14.77 v1(17.73,14.28)
LINE1-R: length 7.5
  TOP w0.203: v1(13.65,20.44) 13.88,20.44 14.27,20.84 U6.21
  TOP w0.254: AC99.2 9.04,19.4 v1(9.42,19.78)
  BOTTOM w0.254: v1(9.42,19.78) 9.89,19.31 11.57,19.31 v2(12.11,19.85) 13.06,19.85 v1(13.65,20.44)
LINE1-R_C: length 2.7
  TOP w0.254: R70274.2 9.04,16.65 AC99.1 9.04,17.85 v1(8.94,17.95)
  BOTTOM w0.254: v1(8.94,17.95) 9.07,18.07 v2(9.07,18.71)
LINE1-VREFO-L: length 3.5
  TOP w0.203: HR69.1 19.28,16.7 v2(18.6,17.38) 18.43,17.55 18.43,17.95 18.16,18.23 18.16,18.62 18.13,18.65 18.13,18.66 18.09,18.7 U6.31
LINE1-VREFO-R: length 4.6
  TOP w0.203: v1(18.44,16.68) 18.41,16.68 18.06,17.03 18.06,17.87 17.85,18.08 17.85,18.5 17.69,18.67 U6.30
  TOP w0.254: v1(18.44,16.68) v2(18.44,15.59)
  BOTTOM w0.254: HR70.1 18.45,17.18 18.45,16.69 v1(18.44,16.68)
LINE2-L: length 6.2
  TOP w0.203: v1(14.01,17.24) 13.84,17.4 13.84,18.68 14.8,19.64 U6.24
  TOP w0.254: AC203.2 13.19,16.74 13.45,16.99 13.76,16.99 v1(14.01,17.24)
  BOTTOM w0.254: v1(14.01,17.24) 14.01,17.36 13.73,17.64 v2(13.18,17.64)
LINE2-L_C: length 36.9
  TOP w0.254: v1(11.5,17.57) 11.52,17.56 11.52,17.2 10.65,16.33 AC203.1 ; AR15.1 42.45,16.58 v1(42.2,16.32)
  IN1 w0.254: v1(42.2,16.32) 40.03,16.32 39.63,15.92 38.9,15.92 38.66,16.17 37.69,16.17 36.84,17.02 33.84,17.02 33.09,16.27 23.92,16.27 23.29,15.64 20.6,15.64 20.32,15.92 20.04,15.92 17.87,18.09 16.02,18.09 15.82,17.9 12.57,17.9 12.24,17.57 v1(11.5,17.57)
  BOTTOM w0.254: v2(43.03,16.4) 42.95,16.32 v1(42.2,16.32)
LINE2-L_C_R: length 5.6
  TOP w0.254: v1(42.72,13.73) L122.1 42.98,14.4 43.51,14.93 44.11,14.93 C4307.1 44.13,15.61 R124.1 AR15.2
  BOTTOM w0.254: v2(43.24,14.38) 43.24,14.25 v1(42.72,13.73)
LINE2-R: length 6.4
  TOP w0.254: v1(11.99,17.01) 12.47,17.01 13.19,17.73 AC202.2 13.19,18.72 14.51,20.04 U6.23
  BOTTOM w0.254: v1(11.99,17.01) 11.36,17.01 10.78,17.59 v2(10.77,17.59)
LINE2-R_C: length 33.2
  TOP w0.254: AR14.1 39.28,15.57 38.56,16.3 v1(38.56,16.68) ; AC202.1 v1(11.5,18.22)
  IN1 w0.254: v1(11.5,18.22) 11.69,18.4 15.52,18.4 15.72,18.6 17.65,18.6 18.08,18.6 20.25,16.42 20.55,16.42 20.83,16.14 23.06,16.14 23.69,16.77 32.86,16.77 33.63,17.54 37.06,17.54 37.92,16.68 v1(38.56,16.68)
  BOTTOM w0.254: v1(38.56,16.68) 39.02,16.68 v2(39.84,15.86)
