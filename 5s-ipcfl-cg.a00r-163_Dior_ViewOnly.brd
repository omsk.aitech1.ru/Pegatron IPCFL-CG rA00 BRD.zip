# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ26: length 43.3
  TOP w0.102: v1(138.22,95.09) 138.17,95.09 XU1.AV35
  TOP w0.127: DIMM2.79 138.37,68.01 v1(138.33,67.96)
  IN2 w0.127: v1(138.33,67.96) 137.9,67.53 137.9,64.33 137.64,64.07 136.83,64.07 136.46,64.45 136.46,64.8 136.59,64.93 136.98,64.93 137.11,65.06 137.11,65.44 136.98,65.56 136.59,65.56 136.46,65.69 136.46,66.07 136.59,66.2 136.98,66.2 137.11,66.33 137.11,66.71 136.98,66.83 136.59,66.83 136.46,66.96 136.46,91.08 135.86,91.68 135.86,94.45 136.78,95.37 137.94,95.37 v1(138.22,95.09)
  BOTTOM w0.127: v2(137.62,67.96) v1(138.33,67.96)
M_A_DQ27: length 42.2
  TOP w0.102: v1(137.72,93.75) 137.74,93.78 XU1.AW35
  TOP w0.127: v1(137.37,70.6) DIMM2.83
  IN2 w0.127: v1(137.37,70.6) 137.94,70.6 138.23,70.32 138.23,68.47 137.28,67.52 137.04,67.52 136.84,67.72 136.84,68.06 137.08,68.3 137.08,68.67 136.84,68.91 136.84,69.24 136.97,69.37 137.46,69.37 137.59,69.49 137.59,69.88 137.46,70 136.97,70 136.84,70.13 136.84,91.18 136.35,91.68 136.35,91.96 136.52,92.14 137.16,92.14 137.31,92.29 137.31,92.62 137.16,92.78 136.32,92.78 136.14,92.95 136.14,93.21 136.35,93.41 136.85,93.41 137.03,93.59 137.03,94.02 136.88,94.17 136.88,94.58 137.13,94.83 137.69,94.83 137.87,94.66 138.5,94.66 138.68,94.48 138.68,93.92 138.52,93.75 v1(137.72,93.75)
  BOTTOM w0.127: v2(138.09,70.6) v1(137.37,70.6)
M_A_DQ28: length 43.8
  TOP w0.102: XU1.AU37 139.99,96.86 v1(139.99,96.87)
  TOP w0.127: v1(141.75,59.78) 141.62,59.9 DIMM2.66
  IN2 w0.127: v1(141.75,59.78) 140.99,60.53 140.99,61.79 141.22,62.02 141.22,66 141.04,66.18 140.28,66.18 140.13,66.33 140.13,66.75 140.28,66.89 141.02,66.89 141.22,67.1 141.22,67.99 140.29,68.92 140.29,71.38 138.94,72.73 138.94,79.63 139.7,80.39 139.7,91.3 140.49,92.09 140.49,96.36 v1(139.99,96.87)
  BOTTOM w0.127: v1(141.75,59.78) 142.07,59.78 v2(142.39,59.45)
M_A_DQ29: length 42.6
  TOP w0.102: v1(140.93,93.48) 140.02,94.4 140.02,95.07 XU1.AV37
  TOP w0.127: DIMM2.67 v1(141.37,70.55)
  IN2 w0.127: v1(141.37,70.55) 141.37,69.03 141.2,68.85 140.9,68.85 140.67,69.08 140.67,72.3 140.44,72.53 139.68,72.53 139.39,72.81 139.39,73.07 139.55,73.22 140.38,73.22 140.52,73.36 140.52,73.74 140.38,73.88 139.44,73.88 139.32,74.01 139.32,74.39 139.44,74.51 140.31,74.51 140.44,74.64 140.44,75.02 140.31,75.15 139.44,75.15 139.32,75.28 139.32,75.66 139.44,75.78 140.23,75.78 140.36,75.91 140.36,76.29 140.23,76.42 139.44,76.42 139.32,76.55 139.32,76.93 139.44,77.05 140.23,77.05 140.36,77.18 140.36,77.56 140.23,77.69 139.44,77.69 139.32,77.82 139.32,78.2 139.44,78.32 140.23,78.32 140.36,78.45 140.36,78.83 140.23,78.96 139.44,78.96 139.32,79.09 139.32,79.47 139.47,79.62 139.88,79.62 140.08,79.82 140.08,91.1 140.93,91.95 v1(140.93,93.48)
  BOTTOM w0.127: v2(140.66,70.55) v1(141.37,70.55)
M_A_DQ30: length 45.1
  TOP w0.102: XU1.AT35 137.74,97.35 v1(138.2,96.89)
  TOP w0.127: DIMM2.84 137.12,59.93 136.94,59.74 v1(136.94,59.73)
  IN2 w0.127: v1(138.2,96.89) 137.77,96.46 135.94,96.46 134.72,95.24 134.72,91.86 135.7,90.88 135.7,66.05 135.57,65.92 134.85,65.92 134.72,65.8 134.72,65.41 134.85,65.29 135.57,65.29 135.7,65.16 135.7,64.13 136.23,63.6 136.23,60.44 v1(136.94,59.73)
  BOTTOM w0.127: v2(136.41,60.26) v1(136.94,59.73)
M_A_DQ31: length 43.9
  TOP w0.102: v1(137.33,96) 137.33,96.03 XU1.AU35
  TOP w0.127: v1(138.2,62.37) 138.12,62.3 DIMM2.80
  IN2 w0.127: v1(137.33,96) 136.59,96 135.28,94.68 135.28,91.81 136.08,91.01 136.08,64.29 136.61,63.76 136.61,62.64 136.74,62.51 137.44,62.51 137.56,62.39 137.56,62 137.44,61.88 136.84,61.88 136.61,61.65 136.61,61.14 136.88,60.87 137.87,60.87 138.2,61.2 v1(138.2,62.37)
  BOTTOM w0.127: v2(138.2,61.66) v1(138.2,62.37)
M_A_DQ32: length 41.2
  TOP w0.102: v1(111.38,93.97) 111.38,94.08 XU1.AY8
  TOP w0.127: DIMM2.173 v1(112.87,70.54)
  IN2 w0.127: v1(111.38,93.97) 111.81,93.53 111.81,93.13 111.25,92.58 111.25,92.27 111.66,91.86 111.66,91.58 111.25,91.18 111.25,90.8 111.39,90.66 111.59,90.66 111.73,90.52 111.73,90.16 111.59,90.02 111.39,90.02 111.25,89.88 111.25,89.53 111.39,89.39 111.59,89.39 111.73,89.25 111.73,88.89 111.59,88.75 111.39,88.75 111.25,88.61 111.25,88.26 111.39,88.12 111.59,88.12 111.73,87.98 111.73,87.62 111.59,87.48 111.39,87.48 111.25,87.34 111.25,86.99 111.39,86.85 111.59,86.85 111.73,86.71 111.73,86.35 111.59,86.21 111.39,86.21 111.25,86.07 111.25,85.72 111.39,85.58 111.59,85.58 111.73,85.44 111.73,85.08 111.59,84.94 111.39,84.94 111.25,84.8 111.25,84.45 111.39,84.31 111.59,84.31 111.73,84.17 111.73,83.81 111.59,83.67 111.39,83.67 111.25,83.53 111.25,83.18 111.39,83.04 111.59,83.04 111.73,82.9 111.73,82.54 111.59,82.4 111.39,82.4 111.25,82.26 111.25,81.91 111.39,81.77 111.59,81.77 111.73,81.63 111.73,81.27 111.59,81.13 111.39,81.13 111.25,80.99 111.25,80.64 111.39,80.5 111.59,80.5 111.73,80.36 111.73,80 111.59,79.86 111.39,79.86 111.25,79.72 111.25,79.37 111.39,79.23 111.59,79.23 111.73,79.09 111.73,78.73 111.59,78.59 111.39,78.59 111.25,78.45 111.25,78.1 111.39,77.96 111.59,77.96 111.73,77.82 111.73,77.46 111.59,77.32 111.39,77.32 111.25,77.18 111.25,76.83 111.39,76.69 111.59,76.69 111.73,76.55 111.73,76.19 111.59,76.05 111.39,76.05 111.25,75.91 111.25,75.03 112.37,73.91 112.37,68.93 112.78,68.52 113.38,68.52 113.71,68.85 113.71,69.2 113.49,69.43 113.49,70.02 113.71,70.25 113.71,70.53 113.51,70.73 113.07,70.73 v1(112.87,70.54)
  BOTTOM w0.127: v2(112.36,70.02) v1(112.87,70.54)
M_A_DQ33: length 41.3
  TOP w0.102: XU1.AW8 111.31,95.06 v1(111.37,95.06)
  TOP w0.127: DIMM2.174 112.62,59.93 v1(112.75,59.81)
  IN2 w0.127: v1(112.75,59.81) 112.75,60.31 112.06,61 112.06,61.46 112.19,61.59 112.6,61.59 112.72,61.71 112.72,62.09 112.6,62.22 112.19,62.22 112.06,62.35 112.06,62.73 112.19,62.86 112.52,62.86 112.65,62.98 112.65,63.36 112.52,63.49 112.19,63.49 112.06,63.62 112.06,64 112.19,64.13 112.52,64.13 112.65,64.25 112.65,64.63 112.52,64.76 112.19,64.76 112.06,64.89 112.06,66.31 112.44,66.69 112.44,68.31 111.96,68.79 111.96,73.71 110.87,74.8 110.87,94.56 v1(111.37,95.06)
M_A_DQ34: length 41.5
  TOP w0.102: XU1.AV6 109.44,96.85 v1(109.44,96.91)
  TOP w0.127: DIMM2.186 109.62,59.82 v1(109.62,59.82)
  IN2 w0.127: v1(109.44,96.91) 108.36,95.83 108.36,93.85 107.78,93.26 107.78,74.88 109.42,73.24 109.42,70.29 109.88,69.83 109.88,62.6 109.62,62.35 v1(109.62,59.82)
  BOTTOM w0.127: v2(110.08,60.52) 110.08,60.28 v1(109.62,59.82)
M_A_DQ35: length 42.2
  TOP w0.102: XU1.AU6 109.45,97.77 v1(109.46,97.77)
  TOP w0.127: v1(109.37,68.01) DIMM2.187
  IN2 w0.127: v1(109.37,68.01) 109.37,69.78 108.91,70.25 108.91,73.21 107.4,74.73 107.4,93.21 108.13,93.94 108.13,96.69 108.53,97.09 108.53,97.63 108.13,98.03 108.13,101.34 108.35,101.56 108.76,101.56 109.01,101.32 109.01,98.23 v1(109.46,97.77)
  BOTTOM w0.127: v2(108.87,68.52) v1(109.37,68.01)
M_A_DQ36: length 44
  TOP w0.102: v1(111.37,96.89) 111.31,96.89 XU1.AU8
  TOP w0.127: v1(113.23,62.75) 113.23,62.75 113.62,62.36 DIMM2.170
  IN2 w0.127: v1(113.23,62.75) 115.09,62.75 115.34,63.01 115.34,63.44 115.09,63.69 114.04,63.69 113.92,63.82 113.92,64.2 114.04,64.33 115.03,64.33 115.24,64.53 115.24,64.94 114.53,65.65 114.53,65.7 114.53,65.7 114.53,71.31 113.69,72.15 113.69,73.85 112.5,75.04 112.5,90.88 112.8,91.19 112.8,96.07 112.44,96.43 112.12,96.43 111.66,96.89 v1(111.37,96.89)
  BOTTOM w0.127: v2(112.53,62.55) 112.73,62.75 v1(113.23,62.75)
M_A_DQ37: length 43.2
  TOP w0.102: v1(111.37,95.97) 111.31,95.97 XU1.AV8
  TOP w0.127: v1(113.66,67.88) 113.87,68.1 DIMM2.169
  IN2 w0.127: v1(111.37,95.97) 110.95,95.97 110.82,96.1 110.82,96.28 110.99,96.45 111.61,96.45 111.86,96.21 111.86,94.93 111.63,94.71 111.63,94.38 112.16,93.84 112.16,92.5 112.52,92.14 112.52,91.23 112.12,90.82 112.12,75.2 112.12,74.89 112.75,74.25 112.75,71.95 113.1,71.59 113.71,71.59 114.15,71.15 114.15,66.76 114.02,66.63 113.66,66.63 113.54,66.51 113.54,66.12 113.66,66 113.98,66 114.14,65.83 114.14,65.54 113.94,65.34 112.98,65.34 112.67,65.65 112.67,66.38 112.83,66.53 112.83,67.5 113.21,67.88 v1(113.66,67.88)
  BOTTOM w0.127: v2(114.04,68.73) 113.86,68.55 113.86,68.09 v1(113.66,67.88)
M_A_DQ38: length 41.5
  TOP w0.102: XU1.AW6 108.6,95.1 v1(108.6,93.25)
  TOP w0.127: v1(110.44,62.45) 110.62,62.26 DIMM2.182
  IN2 w0.127: v1(108.6,93.25) 108.16,92.81 108.16,75.04 109.8,73.4 109.8,70.45 110.54,69.71 110.54,66.89 110.89,66.54 111.5,66.54 111.68,66.36 111.68,65.9 111.56,65.78 111.15,65.78 111.02,65.65 111.02,65.27 111.15,65.14 111.56,65.14 111.68,65.01 111.68,64.63 111.56,64.51 111.15,64.51 111.02,64.38 111.02,64 111.15,63.87 111.56,63.87 111.68,63.74 111.68,62.98 111.56,62.85 110.84,62.85 v1(110.44,62.45)
  BOTTOM w0.127: v1(110.44,62.45) 109.68,63.21 v2(109.68,63.95)
M_A_DQ39: length 39.1
  TOP w0.102: XU1.AY6 109.02,94.35 v1(109.47,93.9)
  TOP w0.127: v1(110.31,70.55) 110.37,70.49 DIMM2.183
  IN2 w0.127: v1(109.47,93.9) 109.22,94.15 109.02,94.15 108.84,93.97 108.84,93.63 109.12,93.35 109.12,93.11 109.73,92.5 109.73,92.19 109.57,92.04 109.27,92.04 108.94,92.37 108.71,92.37 108.56,92.22 108.56,91.5 108.69,91.37 109.45,91.37 109.58,91.24 109.58,90.66 109.45,90.53 108.67,90.53 108.54,90.4 108.54,90.02 108.67,89.89 109.45,89.89 109.58,89.77 109.58,89.39 109.45,89.26 108.67,89.26 108.54,89.13 108.54,88.75 108.67,88.62 109.45,88.62 109.58,88.5 109.58,88.12 109.45,87.99 108.67,87.99 108.54,87.86 108.54,87.48 108.67,87.35 109.38,87.35 109.58,87.16 109.58,86.68 109.42,86.53 108.86,86.53 108.63,86.3 108.63,85.94 108.89,85.69 108.89,85.48 108.63,85.23 108.63,84.22 108.91,83.94 108.91,83.67 108.66,83.41 108.63,83.39 108.63,82.43 108.89,82.17 108.89,81.92 108.63,81.66 108.63,80.7 108.91,80.42 108.91,80.19 108.69,79.96 108.63,79.91 108.63,79 108.89,78.74 108.89,78.44 108.69,78.23 108.63,78.18 108.63,77.27 108.89,77.02 108.89,76.73 108.63,76.48 108.63,75.12 108.84,74.92 109.4,74.92 109.58,74.74 109.58,74.26 110.66,73.18 110.66,72.8 110.54,72.67 110.31,72.67 110.18,72.54 110.18,72.16 110.31,72.03 110.54,72.03 110.66,71.91 110.66,70.91 v1(110.31,70.55)
  BOTTOM w0.127: v2(110.31,69.84) v1(110.31,70.55)
M_A_DQ40: length 41.2
  TOP w0.102: XU1.AY4 106.86,94.28 106.86,94.15 v1(106.6,93.89)
  TOP w0.127: v1(108.62,62.34) 108.62,62.33 DIMM2.190
  IN2 w0.127: v1(108.62,62.34) 109.35,63.06 109.35,63.47 109.22,63.6 108.76,63.6 108.63,63.73 108.63,64.11 108.76,64.23 109.22,64.23 109.35,64.36 109.35,64.74 109.22,64.87 108.76,64.87 108.63,65 108.63,65.38 108.76,65.5 109.22,65.5 109.35,65.63 109.35,66.77 108.84,67.28 108.84,69.25 107.51,70.58 107.51,73.31 106.46,74.36 106.46,78.51 106.34,78.64 105.74,78.64 105.61,78.77 105.61,79.15 105.74,79.28 106.34,79.28 106.46,79.4 106.46,79.78 106.32,79.92 105.89,79.92 105.61,80.2 105.61,93.41 106.09,93.89 v1(106.6,93.89)
  BOTTOM w0.127: v1(108.62,62.34) 108.79,62.17 v2(109.55,62.17)
M_A_DQ41: length 42.8
  TOP w0.102: XU1.AV4 v1(107.65,95.98)
  TOP w0.127: v1(107.62,59.76) 107.62,59.76 DIMM2.194
  IN2 w0.102: 106.3,96.18 106.5,96.38 107.24,96.38 v1(107.65,95.98)
  IN2 w0.127: 106.3,96.18 106.3,95.83 106,95.53 105.63,95.53 104.85,94.76 104.85,77.76 105.7,76.91 105.7,73.87 106.75,72.81 106.75,64.2 107.62,63.34 v1(107.62,59.76)
  BOTTOM w0.127: v1(107.62,59.76) 107.5,59.87 v2(107.5,60.52)
M_A_DQ42: length 41.6
  TOP w0.102: XU1.AT1 v1(103.83,97.64)
  TOP w0.127: DIMM2.208 104.12,62.34 v1(104.11,62.35)
  IN2 w0.127: v1(103.83,97.64) 103.53,97.35 103.02,97.35 102.77,97.1 102.77,96.75 101.01,94.99 101.01,88.94 101.75,88.2 101.75,80.55 102.39,79.92 102.39,76.71 103.26,75.83 103.26,72.36 103.38,72.25 103.38,69.38 104.23,68.53 104.54,68.22 104.54,67 104.11,66.56 104.11,66.18 104.54,65.75 104.54,62.78 v1(104.11,62.35)
  BOTTOM w0.127: v2(104.11,61.64) v1(104.11,62.35)
M_A_DQ43: length 42.3
  TOP w0.102: v1(104.99,97.81) 104.99,97.89 XU1.AT2
  TOP w0.127: DIMM2.207 v1(104.37,70.55)
  IN2 w0.127: v1(104.99,97.81) 104.99,98.05 104.85,98.19 104.52,98.19 104.37,98.03 104.37,97.4 103.38,96.41 102.97,96.41 102.64,96.08 102.64,95.62 102.13,95.11 102.13,94.88 102,94.76 101.57,94.76 101.45,94.63 101.45,94.25 101.57,94.12 102,94.12 102.13,94 102.13,93.61 102,93.49 101.57,93.49 101.45,93.36 101.45,92.98 101.57,92.85 102,92.85 102.13,92.73 102.13,92.34 102,92.22 101.57,92.22 101.45,92.09 101.45,91.71 101.57,91.58 102,91.58 102.13,91.46 102.13,91.07 102,90.95 101.57,90.95 101.45,90.82 101.45,90.44 101.57,90.31 102,90.31 102.13,90.19 102.13,89.8 102,89.68 101.57,89.68 101.45,89.55 101.45,89.17 101.57,89.04 102,89.04 102.13,88.92 102.13,80.71 102.77,80.08 102.77,76.86 103.64,75.99 103.64,72.52 103.79,72.37 104.13,72.37 104.32,72.18 104.32,71.77 104.18,71.63 103.9,71.63 103.76,71.49 103.76,69.54 104.02,69.28 104.37,69.28 104.57,69.48 104.57,70.36 v1(104.37,70.55)
  BOTTOM w0.127: v2(105.09,70.55) v1(104.37,70.55)
M_A_DQ44: length 42.4
  TOP w0.102: XU1.AV3 106.28,96.42 v1(106.73,95.97)
  TOP w0.127: v1(108.37,70.54) DIMM2.191
  IN2 w0.127: v1(106.73,95.97) 107.04,95.97 107.27,95.74 107.27,94.86 107.06,94.66 107.06,93.94 107.24,93.77 107.24,93.39 106.53,92.68 106.22,92.68 106.09,92.55 106.09,92.17 106.22,92.05 106.74,92.05 106.86,91.92 106.86,91.54 106.74,91.41 106.22,91.41 106.09,91.28 106.09,90.9 106.22,90.78 106.74,90.78 106.86,90.65 106.86,90.27 106.74,90.14 106.22,90.14 106.09,90.01 106.09,89.63 106.22,89.51 106.74,89.51 106.86,89.38 106.86,89 106.74,88.87 106.22,88.87 106.09,88.74 106.09,88.36 106.22,88.24 106.74,88.24 106.86,88.11 106.86,87.73 106.74,87.6 106.22,87.6 106.09,87.47 106.09,87.09 106.22,86.97 106.74,86.97 106.86,86.84 106.86,86.46 106.74,86.33 106.22,86.33 106.09,86.2 106.09,85.82 106.22,85.7 106.74,85.7 106.86,85.57 106.86,85.19 106.74,85.06 106.22,85.06 106.09,84.93 106.09,84.55 106.22,84.43 106.74,84.43 106.86,84.3 106.86,83.92 106.74,83.79 106.22,83.79 106.09,83.66 106.09,83.28 106.22,83.16 106.74,83.16 106.86,83.03 106.86,82.65 106.74,82.52 106.22,82.52 106.09,82.39 106.09,82.01 106.22,81.89 106.74,81.89 106.86,81.76 106.86,81.38 106.74,81.25 106.22,81.25 106.09,81.12 106.09,80.74 106.22,80.62 106.74,80.62 106.86,80.49 106.86,74.5 107.9,73.47 107.9,73.08 108.02,72.96 108.2,72.96 108.33,72.83 108.33,72.45 108.2,72.32 108.02,72.32 107.9,72.19 107.9,70.78 108.14,70.54 v1(108.37,70.54)
  BOTTOM w0.127: v2(107.64,70.54) v1(108.37,70.54)
M_A_DQ45: length 41.9
  TOP w0.102: v1(106.73,95.06) 107.19,95.52 XU1.AW4
  TOP w0.127: DIMM2.195 v1(107.37,68.02)
  IN2 w0.127: v1(106.73,95.06) 106.23,94.55 105.64,94.55 105.23,94.14 105.23,77.92 106.08,77.07 106.08,74.21 107.13,73.15 107.13,70.35 108.46,69.02 108.46,66.89 108.71,66.64 108.71,66.06 108.25,65.6 108.25,64.35 107.97,64.07 107.42,64.07 107.14,64.36 107.14,64.68 107.49,65.04 107.49,65.52 107.14,65.88 107.14,66.16 107.29,66.31 107.6,66.31 107.81,66.52 107.81,67.59 v1(107.37,68.02)
  BOTTOM w0.127: v1(107.37,68.02) 107.37,68.43 v2(107.11,68.7)
M_A_DQ46: length 44.9
  TOP w0.102: v1(106.69,97.8) 106.73,97.8 XU1.AT4
  TOP w0.127: DIMM2.204 105.12,59.84 v1(105.11,59.82)
  IN2 w0.102: v1(106.69,97.8) 106.27,98.22 105.68,98.22 105.42,97.96 105.42,97.6 105.09,97.27
  IN2 w0.127: v1(105.11,59.82) 105.11,65.34 104.95,65.5 104.95,72.09 104.02,73.01 104.02,76.15 103.15,77.02 103.15,80.38 102.51,81.02 102.51,95.11 103.43,96.02 104.33,96.92 104.67,97.27 105.09,97.27
  BOTTOM w0.127: v2(104.4,59.82) v1(105.11,59.82)
M_A_DQ47: length 43.5
  TOP w0.102: v1(105.86,97.8) 105.86,97.84 XU1.AT3
  TOP w0.127: DIMM2.203 105.38,69.28 v1(105.38,68.02)
  IN2 w0.127: v1(105.38,68.02) 105.38,72.19 104.41,73.17 104.41,76.38 103.55,77.23 103.55,80.92 103.43,81.05 103.02,81.05 102.89,81.18 102.89,81.56 103.02,81.69 103.43,81.69 103.55,81.81 103.55,82.19 103.43,82.32 103.02,82.32 102.89,82.45 102.89,82.83 103.02,82.96 103.43,82.96 103.55,83.08 103.55,83.46 103.43,83.59 103.02,83.59 102.89,83.72 102.89,84.1 103.02,84.23 103.43,84.23 103.55,84.35 103.55,84.73 103.43,84.86 103.02,84.86 102.89,84.99 102.89,85.37 103.02,85.5 103.43,85.5 103.55,85.62 103.55,86 103.43,86.13 103.02,86.13 102.89,86.26 102.89,86.64 103.02,86.77 103.43,86.77 103.55,86.89 103.55,87.27 103.43,87.4 103.02,87.4 102.89,87.53 102.89,87.91 103.02,88.04 103.43,88.04 103.55,88.16 103.55,88.54 103.43,88.67 103.02,88.67 102.89,88.8 102.89,89.18 103.02,89.31 103.43,89.31 103.55,89.43 103.55,89.86 102.89,90.52 102.89,93.21 102.89,93.83 103.02,93.95 103.63,93.95 103.76,94.08 103.76,94.46 103.63,94.59 103.02,94.59 102.89,94.72 102.89,95.17 104.77,97.04 105.19,97.04 105.86,97.71 v1(105.86,97.8)
  BOTTOM w0.127: v2(105.38,68.78) v1(105.38,68.02)
M_A_DQ48: length 53.7
  TOP w0.102: XU1.AP2 104.96,99.69 v1(104.89,99.69)
  TOP w0.127: DIMM2.215 v1(102.37,70.54)
  IN2 w0.127: v1(104.89,99.69) 104.37,99.17 103.81,99.17 100.1,95.46 100.1,88.45 99.97,88.32 99.34,88.32 99.21,88.19 99.21,87.81 99.34,87.68 99.97,87.68 100.1,87.56 100.1,87.18 99.97,87.05 99.34,87.05 99.21,86.92 99.21,86.54 99.34,86.41 99.97,86.41 100.1,86.29 100.1,85.82 99.95,85.66 99.39,85.66 99.25,85.52 99.25,85.22 99.41,85.05 100.56,85.05 100.84,84.77 100.84,84.39 100.71,84.27 99.41,84.27 99.29,84.14 99.29,83.76 99.41,83.63 100.71,83.63 100.84,83.5 100.84,83.12 100.71,83 99.41,83 99.29,82.87 99.29,82.49 99.41,82.36 100.71,82.36 100.84,82.23 100.84,81.85 100.71,81.73 99.41,81.73 99.29,81.6 99.29,81.22 99.41,81.09 100.71,81.09 100.84,80.96 100.84,80.51 100.71,80.38 99.57,80.38 99.41,80.23 99.41,79.85 99.59,79.67 101.29,79.67 101.47,79.49 101.47,79.02 101.34,78.9 100.28,78.9 100.15,78.77 100.15,78.39 100.28,78.26 101.34,78.26 101.47,78.13 101.47,76.33 102.35,75.45 102.35,71.73 101.95,71.34 101.95,70.7 102.12,70.54 v1(102.37,70.54)
  BOTTOM w0.127: v2(102.37,69.83) v1(102.37,70.54)
M_A_DQ49: length 56
  TOP w0.102: XU1.AM4 106.74,101.47 v1(106.74,101.39)
  TOP w0.127: DIMM2.229 98.87,68.45 v1(99.39,67.93)
  IN2 w0.102: v1(106.74,101.39) 106.95,101.18 107.47,101.18 107.62,101.34 107.62,101.84 107.47,102 106.63,102 106.45,101.81 104.09,101.81 103.71,102.2
  IN2 w0.127: v1(99.39,67.93) 99.87,67.45 99.87,65.47 99.64,65.24 99.13,65.24 98.93,65.45 98.93,68.74 99.36,69.17 99.36,69.55 99.24,69.68 98.68,69.68 98.55,69.81 98.55,71.41 98.55,71.41 98.55,71.73 96.26,74.01 96.26,97.91 100.55,102.2 103.71,102.2
  BOTTOM w0.127: v2(98.68,67.93) v1(99.39,67.93)
M_A_DQ50: length 55
  TOP w0.102: XU1.AP3 105.88,99.69 v1(105.82,99.69)
  TOP w0.127: DIMM2.212 103.12,59.98 v1(103.3,59.81)
  IN2 w0.102: 102.34,97.07 103.39,98.12 104.02,98.12 104.31,98.41 104.31,98.65 104.74,99.07 104.74,99.07 104.75,99.08 105.62,99.08 105.82,99.29 v1(105.82,99.69)
  IN2 w0.127: 102.34,97.07 100.79,95.53 100.79,95.53 100.48,95.21 100.48,88.33 100.66,88.15 101.01,88.15 101.22,87.95 101.22,87.57 101.09,87.44 100.66,87.44 100.53,87.32 100.53,86.93 100.66,86.81 101.09,86.81 101.22,86.68 101.22,86.3 101.09,86.17 100.66,86.17 100.53,86.05 100.53,85.66 100.66,85.54 101.09,85.54 101.22,85.41 101.22,80.33 101.85,79.7 101.85,76.49 102.73,75.61 102.73,72.14 102.84,72.03 102.84,69.16 104.01,67.99 104.01,67.22 103.89,67.1 103.58,66.78 103.58,65.96 104.01,65.53 104.01,65.15 103.88,65.02 103.61,65.02 103.48,64.89 103.48,64.51 103.61,64.39 103.88,64.39 104.01,64.26 104.01,63.72 103.55,63.26 103.55,61.94 103.68,61.82 104.44,61.82 104.57,61.69 104.57,61.38 104.39,61.2 103.45,61.2 103.3,61.05 103.3,60.65 103.45,60.49 104.42,60.49 104.57,60.34 104.57,59.96 104.42,59.81 v1(103.3,59.81)
  BOTTOM w0.127: v2(102.59,59.81) v1(103.3,59.81)
M_A_DQ51: length 55.6
  TOP w0.102: v1(106.73,102.44) 106.73,102.37 XU1.AM3
  TOP w0.127: DIMM2.228 99.12,59.9 v1(98.98,59.76)
  IN2 w0.102: v1(106.73,102.44) 106.31,102.02 104.4,102.02 103.97,102.45 102.57,102.45
  IN2 w0.127: v1(98.98,59.76) 98.98,63.89 98.55,64.32 98.55,69.27 98.17,69.65 98.17,71.57 95.88,73.85 95.88,98.07 100.39,102.58 102.44,102.58 102.57,102.45
  BOTTOM w0.127: v1(98.98,59.76) 98.68,60.06 v2(98.68,60.44)
M_A_DQ52: length 55.6
  TOP w0.102: XU1.AP4 106.79,99.69 v1(106.74,99.69)
  TOP w0.127: DIMM2.216 102.12,62.19 102.33,62.4 v1(102.33,62.4)
  IN2 w0.102: 103.32,99.76 103.68,100.11 106.33,100.11 v1(106.74,99.69)
  IN2 w0.127: 103.32,99.76 99.34,95.77 99.34,89.65 98.32,88.64 98.32,77.61 98.63,77.31 99.13,77.31 99.36,77.08 99.36,76.57 101.19,74.74 101.19,73.37 101.45,73.12 101.45,72.44 101.19,72.18 101.19,69.83 101.93,69.1 101.93,66.54 101.8,66.41 100.91,66.41 100.73,66.23 100.73,65.95 100.91,65.78 101.7,65.78 101.85,65.62 101.85,65.29 101.7,65.14 100.91,65.14 100.73,64.96 100.73,64.68 100.91,64.51 101.7,64.51 101.87,64.34 101.87,64.04 101.7,63.87 100.91,63.87 100.73,63.69 100.73,63.31 100.91,63.13 101.5,63.13 101.7,62.93 101.7,61.71 101.88,61.53 102.16,61.53 102.33,61.71 v1(102.33,62.4)
  BOTTOM w0.127: v2(102.33,61.64) v1(102.33,62.4)
M_A_DQ53: length 54.3
  TOP w0.102: XU1.AM2 104.9,101.46 v1(104.9,101.39)
  TOP w0.127: DIMM2.225 v1(99.87,70.54)
  IN2 w0.127: v1(99.87,70.54) 99.87,72.43 99.72,72.58 99.44,72.58 99.21,72.35 99.01,72.35 98.71,72.65 98.71,72.85 99.83,73.97 99.83,74.17 99.58,74.42 99.38,74.42 98.26,73.3 98.06,73.3 97.81,73.55 97.81,73.75 98.94,74.87 98.94,75.07 98.68,75.32 98.49,75.32 97.36,74.2 97.17,74.2 97.03,74.34 97.03,75.4 97.17,75.54 97.45,75.54 97.59,75.68 97.59,76.04 97.45,76.18 97.17,76.18 97.03,76.32 97.03,91.64 97.2,91.82 97.2,92.18 97.03,92.36 97.03,93.37 97.23,93.57 97.23,93.88 97.03,94.09 97.03,95.1 97.2,95.28 97.2,95.63 97.03,95.81 97.03,97.55 97.67,98.19 98.22,98.19 98.36,98.32 98.36,98.88 98.86,99.38 99.49,99.38 99.67,99.56 99.67,100.2 100.1,100.62 100.48,100.62 100.66,100.8 100.66,101.23 100.84,101.41 101.17,101.41 101.34,101.23 101.34,100.64 101.97,100.02 102.44,100.02 102.59,100.17 102.59,100.4 102.11,100.88 102.11,101.26 102.41,101.56 102.69,101.56 102.83,101.42 102.83,101.05 103.15,100.73 103.66,100.73 103.88,100.96 104.26,100.96 104.49,100.73 104.68,100.73 104.86,100.92 104.86,101.35 v1(104.9,101.39)
  BOTTOM w0.127: v2(99.87,69.83) v1(99.87,70.54)
M_A_DQ54: length 53.5
  TOP w0.102: v1(103.98,99.69) 104.05,99.69 XU1.AP1
  TOP w0.127: v1(103.37,68.02) 103.37,69.28 DIMM2.211
  IN2 w0.127: v1(103.98,99.69) 103.8,99.69 99.72,95.61 99.72,89.49 98.7,88.48 98.7,79.42 98.83,79.29 99.46,79.29 99.64,79.11 99.64,78.78 99.49,78.63 98.83,78.63 98.7,78.5 98.7,78.09 98.92,77.88 100.92,77.88 101.09,77.71 101.09,77.31 100.96,77.19 99.97,77.19 99.85,77.06 99.85,76.68 99.97,76.55 100.96,76.55 101.09,76.42 101.09,76.17 101.97,75.29 101.97,71.89 101.57,71.5 101.57,69.99 101.77,69.79 102.23,69.79 102.46,69.56 102.46,68.9 102.72,68.65 102.72,68.29 102.31,67.88 102.31,63.74 102.46,63.59 102.84,63.59 102.97,63.72 102.97,67.62 v1(103.37,68.02)
  BOTTOM w0.127: v1(103.37,68.02) 103.67,68.02 v2(104.04,67.66)
M_A_DQ55: length 53.8
  TOP w0.102: XU1.AM1 v1(103.92,101.39)
  TOP w0.127: v1(99.92,62.6) 100.12,62.4 DIMM2.224
  IN2 w0.127: v1(103.92,101.39) 103.49,101.82 100.71,101.82 96.65,97.75 96.65,74.17 98.93,71.88 98.93,71.57 98.93,71.25 98.93,71.25 98.93,70.78 99.9,69.81 99.9,67.97 100.25,67.61 100.25,66.59 100.35,66.49 100.35,63.11 101.32,62.14 101.32,61.13 101.08,60.89 100.24,60.89 99.92,61.2 v1(99.92,62.6)
  BOTTOM w0.127: v1(99.92,62.6) v2(100.68,62.6)
M_A_DQ56: length 59.2
  TOP w0.102: XU1.AK3 106.69,103.34 v1(106.74,103.34)
  TOP w0.127: DIMM2.233 97.87,70.49 v1(97.71,70.65)
  IN2 w0.102: 104.65,102.86 105.33,102.86 105.43,102.76 105.43,102.33 105.53,102.22 105.99,102.22 106.12,102.35 106.12,102.53 105.94,102.71 105.94,102.85 106.17,103.09 106.38,103.09 106.61,102.86 106.88,102.86 107.08,103.06 107.33,103.06 107.53,102.86 107.82,102.86 108.1,102.58 108.3,102.58 108.41,102.68 108.41,102.94 108.15,103.19 108.15,103.36 108.4,103.61 108.4,103.76 108.18,103.98 108.02,103.98 107.8,103.75 107.16,103.75 v1(106.74,103.34)
  IN2 w0.127: v1(97.71,70.65) 97.59,70.53 97.59,69.31 97.38,69.1 97.12,69.1 96.9,69.33 96.9,69.59 96.72,69.76 96.46,69.76 96.32,69.91 96.32,70.35 96.42,70.45 96.72,70.45 96.87,70.6 96.87,70.98 96.75,71.11 96.44,71.11 96.31,71.23 96.31,71.61 96.44,71.74 96.77,71.74 96.9,71.87 96.9,72.08 95.35,73.63 95.35,98.29 95.75,98.69 95.75,98.87 95.4,99.22 95.4,99.4 95.67,99.67 95.85,99.67 96.2,99.32 96.38,99.32 96.65,99.59 96.65,99.77 96.35,100.07 96.35,100.25 96.61,100.52 96.79,100.52 97.1,100.22 97.27,100.22 100.17,103.11 102.31,103.11 102.75,102.68 104.46,102.68 104.65,102.86
  BOTTOM w0.127: v1(97.71,70.65) 98.17,71.11 v2(98.4,71.11)
M_A_DQ57: length 58.9
  TOP w0.102: XU1.AH1 104.12,105.91 v1(103.83,105.91)
  TOP w0.127: DIMM2.249 v1(93.87,70.54)
  IN2 w0.127: v1(93.87,70.54) 93.87,68.52 93.6,68.24 93.6,67.25 93.29,66.94 92.73,66.94 92.45,67.22 92.45,68.83 92.58,68.96 93.06,68.96 93.19,69.09 93.19,69.47 93.06,69.59 92.58,69.59 92.45,69.72 92.45,70.1 92.58,70.23 93.06,70.23 93.19,70.36 93.19,70.74 93.06,70.86 92.58,70.86 92.45,70.99 92.45,71.37 92.58,71.5 93.06,71.5 93.19,71.63 93.19,72.01 93.06,72.13 92.58,72.13 92.45,72.26 92.45,73.81 92.76,74.12 92.76,100.32 95.49,103.05 96.27,103.05 96.49,103.28 96.49,103.49 96.78,103.77 96.99,103.77 97.23,104.01 97.23,104.22 97.42,104.41 97.63,104.41 97.82,104.6 97.82,104.81 98,104.99 98.21,104.99 98.37,105.15 98.37,105.37 98.55,105.55 98.75,105.55 98.91,105.71 98.91,105.9 99.04,106.03 100.12,106.03 100.29,105.86 100.57,105.86 100.74,106.03 101.59,106.03 101.76,105.86 102.03,105.86 102.2,106.03 102.8,106.03 103.22,105.6 103.53,105.6 v1(103.83,105.91)
  BOTTOM w0.127: v2(94.59,70.54) v1(93.87,70.54)
M_A_DQ58: length 60
  TOP w0.102: v1(107.61,104.2) 107.61,104.17 XU1.AK4
  TOP w0.127: DIMM2.236 97.13,61.08 v1(97.13,59.81)
  IN2 w0.102: v1(107.61,104.2) 107.31,104.2 106.88,103.77 103.85,103.77 103.37,104.26 102.34,104.26
  IN2 w0.127: 102.34,104.26 99.7,104.26 98.22,102.78 97.83,102.78 96.8,101.75 96.03,101.75 94.05,99.78 94.05,73.23 95.17,72.11 95.17,71.62 95.17,69.44 96.01,68.6 96.01,65.44 97.43,64.02 97.43,62.39 97.13,62.09 v1(97.13,59.81)
  BOTTOM w0.127: v1(97.13,59.81) 97.13,60.29 v2(96.91,60.51)
M_A_DQ59: length 60
  TOP w0.102: v1(104.91,105.12) XU1.AH2
  TOP w0.127: DIMM2.245 94.87,68.02 v1(94.82,67.96)
  IN2 w0.102: 102.53,106.41 102.55,106.44 104.15,106.44 104.41,106.18 104.41,105.62 v1(104.91,105.12)
  IN2 w0.127: v1(94.82,67.96) 94.41,67.96 94.23,67.78 94.23,67 94.61,66.61 94.61,65.67 94.44,65.5 94.08,65.5 93.9,65.67 93.9,66.06 93.75,66.21 93.39,66.21 93.24,66.06 93.24,65.62 93.09,65.47 92.73,65.47 92.58,65.62 92.58,66.23 92.07,66.74 92.07,73.97 92.38,74.27 92.38,100.48 95.33,103.43 95.9,103.43 98.88,106.41 102.53,106.41
  BOTTOM w0.127: v2(94.05,67.96) v1(94.82,67.96)
M_A_DQ60: length 61.9
  TOP w0.102: v1(106.74,105.05) 106.74,105.13 XU1.AH4
  TOP w0.127: DIMM2.250 93.62,62.4 v1(93.57,62.45)
  IN2 w0.127: v1(93.57,62.45) 93.01,63.01 92.28,63.01 91.82,63.46 91.82,65.91 91.31,66.42 91.31,74.28 91.62,74.59 91.62,100.79 95.02,104.19 95.58,104.19 98.56,107.17 102.44,107.17 102.54,107.08 105.37,107.08 106.74,105.71 v1(106.74,105.05)
  BOTTOM w0.127: v2(92.76,62.68) 93.34,62.68 v1(93.57,62.45)
M_A_DQ61: length 58.4
  TOP w0.102: XU1.AK2 v1(104.94,103.32)
  TOP w0.127: v1(97.89,62.47) 98.12,62.24 DIMM2.232
  IN2 w0.127: v1(97.89,62.47) 97.89,61.94 97.74,61.79 97.74,60.57 97.92,60.39 98.32,60.39 98.45,60.52 98.45,63.67 98.02,64.1 98.02,68.06 97.44,68.64 97.05,68.64 95.93,69.75 95.93,70.4 95.93,72.11 95.93,72.43 94.97,73.39 94.97,99.62 96.34,100.99 97.12,100.99 98.15,102.02 98.54,102.02 100.01,103.49 102.41,103.49 103,102.91 104.08,102.91 104.5,103.32 v1(104.94,103.32)
  BOTTOM w0.127: v2(98.6,62.47) v1(97.89,62.47)
M_A_DQ62: length 61.4
  TOP w0.102: XU1.AH3 105.83,105.13 v1(105.83,105.05)
  TOP w0.127: DIMM2.246 94.62,62.84 v1(94.46,63.01)
  IN2 w0.102: v1(105.83,105.05) 105.35,105.53 105.35,106.14 104.65,106.83 102.62,106.83 102.58,106.79
  IN2 w0.127: 102.58,106.79 98.72,106.79 95.74,103.81 95.17,103.81 92,100.64 92,74.43 91.69,74.13 91.69,66.58 92.2,66.07 92.2,65.27 92.81,64.66 92.81,64.48 92.33,64 92.33,63.82 92.6,63.55 92.78,63.55 93.26,64.03 93.44,64.03 v1(94.46,63.01)
  BOTTOM w0.127: v2(94.46,62.3) v1(94.46,63.01)
M_A_DQ63: length 58.3
  TOP w0.102: v1(103.87,103.34) 104.04,103.34 XU1.AK1
  TOP w0.127: v1(96.87,68.02) DIMM2.237
  IN2 w0.102: v1(103.87,103.34) 103.6,103.62 103.6,103.74 103.31,104.03 103.05,104.03 102.89,103.88
  IN2 w0.127: v1(96.87,68.02) 97.47,68.02 97.64,67.86 97.64,67.58 97.33,67.27 97.33,66.94 97.64,66.64 97.64,66.39 97.51,66.27 97.23,66.27 97.1,66.14 97.1,65.76 97.23,65.63 97.51,65.63 97.64,65.51 97.64,64.91 97.48,64.76 97.23,64.76 96.39,65.6 96.39,68.76 95.55,69.6 95.55,70.56 95.55,72.27 94.44,73.39 94.44,73.8 94.59,73.95 94.59,74.44 94.44,74.59 94.44,75.08 94.59,75.23 94.59,75.71 94.44,75.86 94.44,76.35 94.59,76.5 94.59,76.98 94.44,77.13 94.44,77.62 94.59,77.77 94.59,78.25 94.44,78.4 94.44,78.89 94.59,79.04 94.59,79.52 94.44,79.67 94.44,80.16 94.59,80.31 94.59,80.79 94.44,80.94 94.44,81.43 94.59,81.58 94.59,82.06 94.44,82.21 94.44,82.7 94.59,82.85 94.59,83.33 94.44,83.48 94.44,83.97 94.59,84.12 94.59,84.6 94.44,84.75 94.44,85.24 94.59,85.39 94.59,85.87 94.44,86.02 94.44,86.51 94.59,86.66 94.59,87.14 94.44,87.29 94.44,87.78 94.59,87.93 94.59,88.41 94.44,88.56 94.44,89.05 94.59,89.2 94.59,89.68 94.44,89.83 94.44,90.32 94.59,90.47 94.59,90.95 94.44,91.1 94.44,91.59 94.59,91.74 94.59,92.22 94.44,92.37 94.44,92.86 94.59,93.01 94.59,93.49 94.44,93.64 94.44,94.13 94.59,94.28 94.59,94.76 94.44,94.91 94.44,95.4 94.59,95.55 94.59,96.03 94.44,96.18 94.44,96.67 94.59,96.82 94.59,97.3 94.44,97.45 94.44,97.94 94.59,98.09 94.59,98.57 94.44,98.72 94.44,99.21 94.59,99.36 94.59,99.78 96.18,101.37 96.96,101.37 97.99,102.4 98.38,102.4 99.86,103.88 102.41,103.88 102.56,103.72 102.74,103.72 102.89,103.88
  BOTTOM w0.127: v2(96.87,68.73) v1(96.87,68.02)
M_A_DQS0: length 58.5
  TOP w0.127: v1(140.03,105.97) 140.03,106.04 XU1.AF38 ; DIMM2.13 154.87,70.74 v1(154.86,70.75)
  IN2 w0.102: v1(140.03,105.97) 140.32,105.97 140.74,105.55 141.33,105.55 141.78,106 142.8,106 143.29,106.49 143.36,106.49
  IN2 w0.127: 143.36,106.49 143.53,106.67 144.22,106.67 144.68,106.21 145.2,106.21 145.43,106.44 146.17,106.44 156.79,95.81 156.79,95.12 156.67,94.99 155.99,94.99 155.73,94.73 155.73,94.16 155.99,93.9 156.67,93.9 156.79,93.78 156.79,93.39 156.67,93.27 155.99,93.27 155.73,93.01 155.73,92.44 155.99,92.18 156.67,92.18 156.79,92.05 156.79,91.67 156.67,91.54 155.99,91.54 155.73,91.28 155.73,90.71 155.99,90.45 156.67,90.45 156.79,90.32 156.79,89.94 156.67,89.81 155.99,89.81 155.73,89.55 155.73,88.98 155.99,88.72 156.67,88.72 156.79,88.59 156.79,88.08 156.67,87.95 155.99,87.95 155.73,87.69 155.73,87.12 155.99,86.86 156.67,86.86 156.79,86.73 156.79,75.28 155.29,73.78 155.29,72.08 155.29,71.7 155.29,71.34 155.19,71.24 155.11,71.16 155.11,71.16 155.11,71.01 v1(154.86,70.75)
M_A_DQS0#: length 58.6
  TOP w0.127: v1(155.74,70.74) 155.5,70.74 155.37,70.61 DIMM2.11 ; v1(140.94,105.97) 140.94,106.26 141.17,106.49 XU1.AF39
  IN2 w0.102: 143.26,106.72 143.26,106.7 143.25,106.7 143.2,106.7 142.71,106.2 141.7,106.2 141.27,105.78 141.13,105.78 v1(140.94,105.97)
  IN2 w0.127: 143.26,106.72 143.44,106.9 144.31,106.9 144.77,106.44 145.11,106.44 145.33,106.66 146.27,106.66 157.02,95.91 157.02,95.03 156.76,94.77 156.08,94.77 155.95,94.64 155.95,94.26 156.08,94.13 156.76,94.13 157.02,93.87 157.02,93.3 156.76,93.04 156.08,93.04 155.95,92.91 155.95,92.53 156.08,92.4 156.76,92.4 157.02,92.14 157.02,91.57 156.76,91.31 156.08,91.31 155.95,91.18 155.95,90.8 156.08,90.68 156.76,90.68 157.02,90.42 157.02,89.85 156.76,89.58 156.08,89.58 155.95,89.46 155.95,89.08 156.08,88.95 156.76,88.95 157.02,88.69 157.02,87.98 156.76,87.72 156.08,87.72 155.95,87.6 155.95,87.22 156.08,87.09 156.76,87.09 157.02,86.83 157.02,75.19 155.52,73.69 155.52,72.17 155.52,71.79 155.52,71.39 155.52,71.25 155.52,71.25 155.35,71.08 155.34,71.06 155.34,70.87 155.47,70.74 v1(155.74,70.74)
M_A_DQS1: length 53.9
  TOP w0.127: XU1.AK38 140.72,102.84 140.96,102.6 v1(140.96,102.4) ; DIMM2.34 149.62,61.99 149.68,62.04 149.68,62.27 v1(149.43,62.52)
  IN2 w0.102: 144.3,101.97 144.09,101.97 143.86,102.21 141.77,102.21 141.22,102.75 141.06,102.75 140.96,102.65 v1(140.96,102.4)
  IN2 w0.127: 144.3,101.97 144.63,101.97 145.84,100.76 145.84,100.76 145.94,100.66 148.89,97.7 148.89,97.09 149.58,96.41 150.19,96.41 151.61,94.99 151.61,92.8 150.75,91.94 150.75,91.18 151.18,90.74 151.18,89.4 150.9,89.12 150.9,84.12 149.91,83.13 149.91,82.08 150.47,81.52 150.47,75.4 149.45,74.39 149.45,70.32 150.11,69.66 150.11,69.05 149.55,68.49 149.55,67.81 150.14,67.22 150.14,66.86 150,66.72 149.27,66.72 148.99,66.45 148.99,65.9 149.27,65.63 150,65.63 150.14,65.49 150.14,63.97 149.78,63.61 149.78,62.88 v1(149.43,62.52)
M_A_DQS1#: length 53.9
  TOP w0.127: XU1.AK39 141.22,103.01 141.18,103.01 v1(140.93,103.26) ; DIMM2.32 150.12,62.33 v1(150.34,62.55)
  IN2 w0.102: 144.3,102.2 144.15,102.2 143.94,102.41 141.85,102.41 141.3,102.96 141.23,102.96 v1(140.93,103.26)
  IN2 w0.127: 144.3,102.2 144.72,102.2 149.12,97.8 149.12,97.19 149.67,96.64 150.28,96.64 151.84,95.08 151.84,92.71 150.98,91.84 150.98,91.27 151.41,90.84 151.41,89.3 151.13,89.02 151.13,84.03 150.14,83.04 150.14,82.18 150.7,81.62 150.7,75.31 149.68,74.29 149.68,70.42 150.34,69.76 150.34,68.95 149.78,68.39 149.78,67.9 150.37,67.32 150.37,66.76 150.09,66.49 149.36,66.49 149.22,66.35 149.22,66 149.36,65.86 150.09,65.86 150.37,65.58 150.37,63.87 150.01,63.51 150.01,62.88 v1(150.34,62.55)
M_A_DQS2: length 46.4
  TOP w0.127: v1(144.07,67.81) 144.37,68.11 DIMM2.55 ; XU1.AP38 140.93,98.73 v1(140.93,98.71)
  IN2 w0.102: v1(140.93,98.71) 141.23,98.71 141.66,98.28 142.22,98.28 142.51,97.99 142.51,97.49 142.72,97.28 142.72,96.19 142.69,96.16 142.69,96 142.69,95.92
  IN2 w0.127: 142.69,95.92 142.69,91.64 143.51,90.82 143.51,89.73 143.78,89.46 144.61,89.46 144.75,89.32 144.75,88.96 144.61,88.82 143.78,88.82 143.51,88.55 143.51,88 143.78,87.73 144.61,87.73 144.75,87.59 144.75,87.24 144.61,87.1 143.78,87.1 143.51,86.82 143.51,86.28 143.78,86 144.59,86 144.73,85.86 144.73,85.51 144.59,85.37 143.78,85.37 143.51,85.1 143.51,84.55 143.78,84.28 144.54,84.28 144.68,84.14 144.68,83.78 144.54,83.64 143.78,83.64 143.51,83.37 143.51,82.82 143.78,82.55 144.46,82.55 144.6,82.41 144.6,82.05 144.46,81.91 143.78,81.91 143.51,81.64 143.51,80.87 143.78,80.6 144.28,80.6 144.42,80.46 144.42,80.1 144.28,79.96 143.78,79.96 143.51,79.69 143.51,76.78 144.35,75.94 144.35,73.34 144.07,73.06 144.07,70.35 143.66,69.94 143.66,69.2 144.07,68.8 v1(144.07,67.81)
M_A_DQS2#: length 46.4
  TOP w0.127: v1(144.83,67.76) 144.6,67.98 144.6,68.21 144.87,68.49 DIMM2.53 ; v1(141.86,98.72) 141.52,98.72 141.4,98.84 XU1.AP39
  IN2 w0.102: 142.92,95.92 142.92,95.94 142.93,95.94 142.93,96.1 142.93,97.36 142.71,97.58 142.71,98.08 142.31,98.48 141.96,98.48 141.86,98.58 v1(141.86,98.72)
  IN2 w0.127: 142.92,95.92 142.92,91.73 143.74,90.91 143.74,89.83 143.88,89.69 144.71,89.69 144.98,89.41 144.98,88.87 144.71,88.59 143.88,88.59 143.74,88.45 143.74,88.1 143.88,87.96 144.71,87.96 144.98,87.69 144.98,87.14 144.71,86.87 143.88,86.87 143.74,86.73 143.74,86.37 143.88,86.23 144.68,86.23 144.96,85.96 144.96,85.41 144.68,85.14 143.88,85.14 143.74,85 143.74,84.64 143.88,84.51 144.63,84.51 144.91,84.23 144.91,83.69 144.63,83.41 143.88,83.41 143.74,83.27 143.74,82.92 143.88,82.78 144.56,82.78 144.83,82.5 144.83,81.96 144.56,81.69 143.88,81.69 143.74,81.55 143.74,80.97 143.88,80.83 144.38,80.83 144.65,80.55 144.65,80.01 144.38,79.73 143.88,79.73 143.74,79.59 143.74,76.88 144.58,76.04 144.58,73.24 144.3,72.97 144.3,70.26 143.89,69.85 143.89,69.3 144.3,68.89 144.3,68.29 v1(144.83,67.76)
M_A_DQS3: length 42.6
  TOP w0.127: XU1.AV36 138.91,95.52 139.09,95.34 v1(139.09,95.06) ; DIMM2.76 139.12,60.29 139.29,60.12 139.29,59.96 v1(139.09,59.76)
  IN2 w0.102: v1(139.09,95.06) 138.78,95.06 138.66,95.18 138.66,95.38 138.78,95.5 139.25,95.5 139.57,95.18 139.57,93.94 137.39,91.76 137.39,91.44 137.38,91.42 137.38,91.41
  IN2 w0.127: 137.38,91.41 137.38,72.13 137.82,71.69 138.76,70.75 138.76,63.53 138.76,63.53 138.76,63 138.76,63 138.76,62.9 139.88,61.79 139.88,59.57 139.69,59.39 139.51,59.39 139.35,59.56 139.29,59.56 v1(139.09,59.76)
M_A_DQS3#: length 42.6
  TOP w0.127: v1(139.11,95.92) 139.11,95.98 XU1.AU36 ; v1(139.17,59.13) 139.62,59.58 DIMM2.74
  IN2 w0.102: 137.61,91.41 137.61,91.42 137.59,91.44 137.59,91.68 139.78,93.86 139.78,95.27 139.12,95.92 v1(139.11,95.92)
  IN2 w0.127: 137.61,91.41 137.61,72.23 137.92,71.92 137.92,71.92 138.99,70.84 138.99,63.44 138.99,63 140.1,61.88 140.1,59.48 139.75,59.13 v1(139.17,59.13)
M_A_DQS4: length 40.9
  TOP w0.127: v1(109.44,96) 109.5,96 XU1.AV7 ; DIMM2.179 111.37,68.01 v1(111.1,67.73)
  IN2 w0.102: 110.11,90.79 110.11,90.81 110.12,90.82 110.12,90.88 110.14,90.9 110.14,94.24 109.93,94.45 109.09,94.45 108.74,94.8 108.74,95.32 108.95,95.53 109.23,95.53 109.44,95.74 v1(109.44,96)
  IN2 w0.127: v1(111.1,67.73) 111.1,69.2 111.2,69.3 111.2,73.4 110.11,74.49 110.11,75.33 109.98,75.45 109.45,75.45 109.19,75.71 109.19,76.28 109.45,76.55 109.98,76.55 110.11,76.67 110.11,77.05 109.98,77.18 109.48,77.18 109.22,77.44 109.22,78.01 109.48,78.27 109.98,78.27 110.11,78.4 110.11,78.78 109.98,78.91 109.48,78.91 109.22,79.17 109.22,79.74 109.48,80 109.98,80 110.11,80.13 110.11,80.51 109.98,80.64 109.45,80.64 109.19,80.9 109.19,81.47 109.45,81.73 109.98,81.73 110.11,81.85 110.11,82.24 109.98,82.36 109.45,82.36 109.19,82.62 109.19,83.19 109.45,83.45 109.98,83.45 110.11,83.58 110.11,84.05 109.98,84.18 109.43,84.18 109.17,84.44 109.17,85.01 109.43,85.27 109.98,85.27 110.11,85.4 110.11,90.79
M_A_DQS4#: length 40.8
  TOP w0.127: v1(111.87,67.76) 111.6,68.03 111.6,68.21 111.87,68.49 DIMM2.177 ; v1(109.44,95.08) 109.44,95.21 109.75,95.52 XU1.AW7
  IN2 w0.102: 110.34,90.79 110.34,94.32 110.01,94.65 109.17,94.65 108.94,94.88 108.94,95.23 109.03,95.32 109.2,95.32 v1(109.44,95.08)
  IN2 w0.127: 110.34,90.79 110.34,85.3 110.08,85.04 109.52,85.04 109.4,84.91 109.4,84.53 109.52,84.4 110.08,84.4 110.34,84.14 110.34,83.49 110.08,83.23 109.55,83.23 109.42,83.1 109.42,82.72 109.55,82.59 110.08,82.59 110.34,82.33 110.34,81.76 110.08,81.5 109.55,81.5 109.42,81.37 109.42,80.99 109.55,80.86 110.08,80.86 110.34,80.6 110.34,80.03 110.08,79.77 109.57,79.77 109.45,79.64 109.45,79.26 109.57,79.14 110.08,79.14 110.34,78.88 110.34,78.31 110.08,78.04 109.57,78.04 109.45,77.92 109.45,77.54 109.57,77.41 110.08,77.41 110.34,77.15 110.34,76.58 110.08,76.32 109.55,76.32 109.42,76.19 109.42,75.81 109.55,75.68 110.08,75.68 110.34,75.42 110.34,74.58 111.43,73.49 111.43,69.2 111.32,69.1 111.32,68.34 111.42,68.24 111.76,68.24 111.87,68.12 v1(111.87,67.76)
M_A_DQS5: length 41.6
  TOP w0.127: XU1.AU2 105.72,97.35 105.83,97.24 v1(105.83,96.93) ; DIMM2.200 106.12,61.87 106.37,62.12 106.37,62.37 106.25,62.5 v1(106.04,62.5)
  IN2 w0.102: v1(105.83,96.93) 105.83,96.71 105.73,96.61 104.64,96.61 103.63,95.6 103.63,95.05 104.11,94.57 104.11,94.1 104.1,94.08 104.1,94.02 104.09,94.01 104.09,93.99
  IN2 w0.127: 104.09,93.99 104.09,93.53 103.96,93.41 103.69,93.41 103.43,93.15 103.43,92.58 103.69,92.32 103.96,92.32 104.09,92.19 104.09,91.81 103.96,91.68 103.69,91.68 103.43,91.42 103.43,90.85 103.69,90.59 103.96,90.59 104.09,90.46 104.09,77.45 104.94,76.6 104.94,73.39 105.99,72.34 105.99,63.89 106.36,63.51 106.36,62.82 v1(106.04,62.5)
M_A_DQS5#: length 41.6
  TOP w0.127: v1(106.91,62.52) 106.62,62.24 DIMM2.198 ; v1(106.69,96.89) 106.69,96.93 XU1.AU3
  IN2 w0.102: 104.32,93.99 104.32,94.66 103.83,95.14 103.83,95.51 104.73,96.41 105.91,96.41 106.39,96.89 v1(106.69,96.89)
  IN2 w0.127: 104.32,93.99 104.32,93.44 104.06,93.18 103.78,93.18 103.66,93.05 103.66,92.67 103.78,92.54 104.06,92.54 104.32,92.28 104.32,91.71 104.06,91.45 103.78,91.45 103.66,91.32 103.66,90.94 103.78,90.82 104.06,90.82 104.32,90.56 104.32,77.54 105.17,76.69 105.17,73.48 106.22,72.43 106.22,63.98 106.59,63.61 106.59,62.84 v1(106.91,62.52)
M_A_DQS6: length 53.7
  TOP w0.127: XU1.AN2 105.75,101.39 v1(105.82,101.39) ; v1(100.72,67.94) 100.87,68.09 DIMM2.221
  IN2 w0.102: v1(105.82,101.39) 105.61,101.18 105.31,101.18 105.08,100.95 105.08,100.61 104.99,100.52 103.34,100.52 102.96,100.14 102.95,100.14 102.94,100.13 102.85,100.04
  IN2 w0.127: 102.85,100.04 102.29,99.48 101.74,99.48 101.16,100.07 100.56,100.07 100.21,99.71 100.21,99.19 100.71,98.69 100.71,98.51 100.44,98.24 100.25,98.24 99.66,98.83 99.19,98.83 98.89,98.53 98.89,98.06 99.43,97.51 99.43,97.33 99.16,97.06 98.98,97.06 98.39,97.66 97.89,97.66 97.56,97.33 97.56,96.03 97.82,95.77 98.45,95.77 98.58,95.65 98.58,95.26 98.45,95.14 97.82,95.14 97.56,94.88 97.56,94.31 97.82,94.05 98.45,94.05 98.58,93.92 98.58,93.54 98.45,93.41 97.82,93.41 97.56,93.15 97.56,92.58 97.82,92.32 98.45,92.32 98.58,92.19 98.58,91.81 98.45,91.68 97.82,91.68 97.56,91.42 97.56,90.85 97.82,90.59 98.45,90.59 98.58,90.46 98.58,90.08 98.45,89.96 97.82,89.96 97.56,89.7 97.56,77.3 100.43,74.43 100.43,69.52 100.94,69.01 100.94,68.16 v1(100.72,67.94)
M_A_DQS6#: length 53.7
  TOP w0.127: XU1.AN3 106.26,101.01 v1(105.8,100.55) ; v1(101.5,67.94) 101.37,68.06 DIMM2.219
  IN2 w0.102: 103.01,99.88 103.02,99.89 103.02,99.91 103.07,99.95 103.07,99.95 103.43,100.31 105.07,100.31 105.28,100.52 105.28,100.87 105.39,100.98 105.7,100.98 105.8,100.88 v1(105.8,100.55)
  IN2 w0.127: 103.01,99.88 102.39,99.25 101.65,99.25 101.07,99.84 100.65,99.84 100.43,99.62 100.43,99.28 100.93,98.78 100.93,98.41 100.53,98.01 100.16,98.01 99.57,98.6 99.29,98.6 99.12,98.43 99.12,98.15 99.66,97.61 99.66,97.24 99.26,96.84 98.89,96.84 98.3,97.43 97.98,97.43 97.79,97.24 97.79,96.13 97.92,96 98.54,96 98.8,95.74 98.8,95.17 98.54,94.91 97.92,94.91 97.79,94.78 97.79,94.4 97.92,94.27 98.54,94.27 98.8,94.01 98.8,93.44 98.54,93.18 97.92,93.18 97.79,93.05 97.79,92.67 97.92,92.55 98.54,92.55 98.8,92.29 98.8,91.72 98.54,91.45 97.92,91.45 97.79,91.33 97.79,90.95 97.92,90.82 98.54,90.82 98.8,90.56 98.8,89.99 98.54,89.73 97.92,89.73 97.79,89.6 97.79,77.39 100.66,74.52 100.66,69.61 101.19,69.08 101.19,68.24 v1(101.5,67.94)
M_A_DQS7: length 58
  TOP w0.127: DIMM2.242 95.62,62.39 v1(95.47,62.54) ; v1(104.94,104.2) 105.36,104.62 XU1.AJ2
  IN2 w0.102: 102.64,105.22 102.96,105.22 103.58,104.61 104.43,104.61 104.54,104.5 104.64,104.5 v1(104.94,104.2)
  IN2 w0.127: v1(95.47,62.54) 95.89,62.12 96.41,62.12 96.9,62.61 96.9,63.8 96.37,64.33 95.99,64.33 95.48,64.84 95.48,68.38 94.64,69.22 94.64,71.89 93.52,73.01 93.52,100 95.81,102.29 96.58,102.29 97.66,103.37 98,103.37 98.34,103.7 98.34,104.04 98.53,104.23 98.92,104.23 99.24,104.55 99.24,104.94 99.52,105.22 99.85,105.22 100.18,104.89 100.68,104.89 101.01,105.22 101.32,105.22 101.67,104.87 102.11,104.87 102.46,105.22 102.64,105.22
M_A_DQS7#: length 57.9
  TOP w0.127: XU1.AJ3 106.28,104.66 v1(105.82,104.21) ; DIMM2.240 96.12,62.45 v1(96.23,62.56)
  IN2 w0.102: v1(105.82,104.21) 105.32,104.7 104.62,104.7 104.52,104.81 103.66,104.81 103.05,105.43 102.74,105.43 102.73,105.44 102.67,105.44 102.65,105.45 102.64,105.45
  IN2 w0.127: 102.64,105.45 102.37,105.45 102.01,105.1 101.77,105.1 101.41,105.45 100.92,105.45 100.59,105.12 100.27,105.12 99.94,105.45 99.42,105.45 99.01,105.04 99.01,104.64 98.82,104.46 98.43,104.46 98.11,104.13 98.11,103.8 97.9,103.6 97.57,103.6 96.49,102.52 95.71,102.52 93.29,100.1 93.29,72.91 94.41,71.8 94.41,69.12 95.25,68.28 95.25,64.74 95.89,64.1 96.27,64.1 96.67,63.7 96.67,62.71 96.52,62.56 v1(96.23,62.56)
M_A_ODT0: length 41.4
  TOP w0.198: DIMM2.155 117.37,71.08 116.43,72.02 v2(116.05,72.02) 115.87,72.2 v1(115.34,72.2) ; XU1.AW11 115.52,94.88 v1(115.21,94.88)
  IN2 w0.211: v1(115.21,94.88) 114.79,94.88 114.58,95.09 114.58,96.23 115.37,97.02 115.37,97.96 115.36,97.96 115.36,99.93 114.92,100.37 114.5,100.37 114.12,99.99 114.12,97.35 113.49,96.71 113.49,75.46 114.68,74.26 114.68,74.24 114.7,74.21 114.7,72.63 115.13,72.2 v1(115.34,72.2)
M_A_ODT1: length 43.4
  TOP w0.198: XU1.AU14 118.54,96.67 118.31,96.89 v1(118.15,96.89) ; DIMM2.161 115.87,68.19 v1(116.05,68.01)
  IN2 w0.102: 115.04,91.91 115.84,92.71 115.84,94.37 116.1,94.63 116.39,94.63 116.69,94.92 116.69,95.22 116.93,95.47 117.18,95.47 117.58,95.87 117.58,97.17 117.77,97.37 118.01,97.37 118.15,97.23 v1(118.15,96.89)
  IN2 w0.211: v1(116.05,68.01) 116.21,67.85 116.25,67.85 116.52,67.58 116.52,67.54 116.53,67.53 116.53,65.45 116.84,65.14 117.51,65.14 117.83,65.46 117.83,69.38 116.97,70.25 116.97,74.13 116,75.09 116,75.83 116.61,76.44 116.61,77.08 116.25,77.43 115.47,77.43 115.04,77.87 115.04,91.91
  BOTTOM w0.198: v1(116.05,68.01) v2(116.05,68.73)
M_A_PAR: length 38.5
  TOP w0.198: v1(122.37,68.02) DIMM2.143 ; XU1.AY15 119.14,93.38 v1(119.14,93.17)
  IN2 w0.211: v1(122.37,68.02) 122.42,68.02 122.9,67.54 122.9,66.05 122.21,65.35 121.65,65.35 121.42,65.59 121.42,66.47 121.89,66.94 121.89,67.58 121.42,68.06 121.42,68.66 121.63,68.87 122.02,68.87 122.24,68.66 122.69,68.66 122.9,68.87 122.9,69.32 122.35,69.86 121.63,69.86 121.42,70.07 121.42,87.35 119.04,89.72 119.04,91.7 119.42,92.08 119.42,92.9 v1(119.14,93.17)
  BOTTOM w0.198: v2(122.37,68.75) v1(122.37,68.02)
M_B_A0: length 58.1
  TOP w0.198: v1(122.63,101.44) 123.11,101.92 XU1.AL19 ; v1(121.67,51.84) 122.13,51.37 DIMM1.144
  IN1 w0.102: v1(122.63,101.44) 123.25,100.81 123.25,97.22 123.4,97.07 123.4,93.12 122.67,92.39 122.67,91.72
  IN1 w0.211: 122.67,91.72 122.67,86.38 120.74,84.45 120.74,80.42 122.68,78.49 122.68,74.66 121.96,73.94 121.96,70.2 122.67,69.49 122.67,68.69 122.85,68.51 122.85,65.93 122.45,65.53 122.45,62.62 122.66,62.41 122.66,60.17 122.04,59.55 122.04,54.25 122.78,53.51 122.78,52.95 v1(121.67,51.84)
  BOTTOM w0.198: v2(122.18,52.35) v1(121.67,51.84)
M_B_A1: length 59
  TOP w0.198: DIMM1.133 124.88,55.16 125.65,54.39 v1(125.65,54.22) ; v1(126.29,101.46) 126.29,101.49 XU1.AL22
  IN1 w0.102: v1(126.29,101.46) 126.29,99.43 125.76,98.9 125.76,93.91 126.25,93.41 126.25,92.05 125.98,91.78 125.98,91.74
  IN1 w0.211: v1(125.65,54.22) 125.56,54.31 125.56,57.35 126.67,58.46 126.67,60.14 126.32,60.5 126.32,61.86 126.86,62.4 126.86,64.95 126.32,65.49 126.32,70.38 126.48,70.55 126.48,73.39 125.82,74.06 125.82,74.42 126.07,74.68 126.68,74.68 126.92,74.92 126.92,75.48 126.67,75.73 126.06,75.73 125.82,75.98 125.82,76.56 126.05,76.79 126.66,76.79 126.92,77.05 126.92,77.61 126.69,77.84 126.06,77.84 125.82,78.08 125.82,78.59 126.12,78.9 126.68,78.9 126.92,79.14 126.92,79.72 126.69,79.95 126.21,79.95 125.98,80.18 125.98,91.74
  BOTTOM w0.198: v1(125.65,54.22) 125.65,54.57 125.39,54.83 v2(125.39,55.09)
M_B_A2: length 56.5
  TOP w0.198: v1(125.71,52.1) 125.13,51.52 DIMM1.132 ; v1(125.37,101.46) 125.4,101.46 XU1.AM22
  IN1 w0.102: 125.4,91.99 125.31,92.07 125.31,93.49 125.55,93.73 125.55,99.05 125.85,99.35 125.85,101.29 125.68,101.46 v1(125.37,101.46)
  IN1 w0.211: 125.4,91.99 125.4,80.17 125.75,79.82 125.75,79.26 125.4,78.91 125.4,69.8 125.9,69.3 125.9,65.32 126.44,64.78 126.44,62.57 125.9,62.03 125.9,60.33 126.26,59.97 126.26,58.64 125.14,57.52 125.14,54.06 125.55,53.66 125.55,52.26 v1(125.71,52.1)
  BOTTOM w0.198: v1(125.71,52.1) 125.25,52.56 v2(125.25,52.69)
M_B_A3: length 56.6
  TOP w0.198: DIMM1.131 125.38,56.31 v1(126.37,55.32) ; v1(127.2,100.57) 126.77,101.01 XU1.AM23
  IN1 w0.102: 126.42,91.84 126.42,91.89 126.48,91.95 126.48,93.91 126.7,94.13 126.7,95.28 126.77,95.35 126.77,100.14 v1(127.2,100.57)
  IN1 w0.211: v1(126.37,55.32) 125.97,55.72 125.97,57.18 127.68,58.89 127.68,59.72 126.73,60.67 126.73,61.69 127.27,62.23 127.27,65.12 126.73,65.66 126.73,66.32 127.1,66.7 127.1,67.3 126.73,67.67 126.73,68.25 126.97,68.49 127.58,68.49 127.85,68.77 127.85,69.36 127.63,69.59 127.13,69.59 126.9,69.82 126.9,74.28 127.34,74.72 127.34,75.77 127.6,76.03 128,76.03 128.24,76.27 128.24,76.82 127.99,77.08 127.63,77.08 127.34,77.38 127.34,77.85 127.62,78.13 128,78.13 128.24,78.37 128.24,78.96 128.01,79.19 127.58,79.19 127.34,79.43 127.34,79.91 126.42,80.83 126.42,91.84
  BOTTOM w0.198: v2(126.48,54.03) 126.69,54.24 126.69,55 v1(126.37,55.32)
M_B_A4: length 54.7
  TOP w0.198: v1(125.76,50.75) 126.13,50.38 DIMM1.128 ; XU1.AP23 127.23,98.71 v1(127.24,98.71)
  IN1 w0.102: v1(127.24,98.71) 127.72,98.24 127.72,94 127.41,93.69 127.07,93.69 126.81,93.43 126.81,92.76 126.92,92.65 126.92,91.52
  IN1 w0.211: v1(125.76,50.75) 126.52,51.51 126.52,54.19 126.85,54.52 126.85,57.46 128.1,58.72 128.1,59.89 127.14,60.84 127.14,61.52 127.68,62.06 127.68,65.24 128.27,65.82 128.27,69.86 127.39,70.74 127.39,72 127.84,72.46 127.84,75.25 128.66,76.07 128.66,79.18 126.92,80.91 126.92,91.52
M_B_A5: length 59.3
  TOP w0.198: XU1.AL23 126.97,101.72 126.97,101.69 v1(127.2,101.46) ; DIMM1.126 126.63,50.55 v1(127.08,51)
  IN1 w0.102: 128.24,91.4 128.24,92.3 128.84,92.9 128.84,93.34 129.48,93.97 129.48,98.86 128.19,100.15 127.92,100.15 127.66,100.41 127.66,101 v1(127.2,101.46)
  IN1 w0.211: v1(127.08,51) 127.08,54.02 127.98,54.92 127.98,57.32 128.32,57.66 129.1,57.66 129.83,58.39 129.83,59.79 130.24,60.2 130.24,61.62 129.51,62.34 129.51,70.01 130.57,71.07 130.57,75.21 130.01,75.77 130.01,83.54 128.24,85.32 128.24,91.07 128.24,91.08 128.24,91.4
  BOTTOM w0.198: v2(126.42,51.78) 126.42,51.66 v1(127.08,51)
M_B_A6: length 49
  TOP w0.198: XU1.AW26 v1(129.05,94.15) ; v1(127.49,55.98) 126.56,55.98 126.38,56.16 DIMM1.127
  IN1 w0.102: 127.81,91.61 127.81,92.67 127.84,92.7 127.84,93.08 128.26,93.5 128.4,93.5 v1(129.05,94.15)
  IN1 w0.211: 127.81,91.61 127.81,84.09 128.08,83.82 129.12,83.82 129.44,83.5 129.44,83.1 129.1,82.76 128.11,82.76 127.81,82.46 127.81,81.96 128.09,81.68 129.11,81.68 129.6,81.19 129.6,75.6 130.16,75.04 130.16,71.24 129.1,70.18 129.1,62.17 129.82,61.44 129.82,60.37 129.41,59.97 129.41,58.56 128.93,58.08 128.04,58.08 127.26,57.29 127.26,56.22 v1(127.49,55.98)
  BOTTOM w0.198: v1(127.49,55.98) v2(126.69,55.98)
M_B_A7: length 49.4
  TOP w0.198: XU1.AY26 129.51,93.16 v1(129.78,92.88) ; DIMM1.122 127.63,52.06 128.51,52.94 v1(128.63,52.94)
  IN1 w0.102: v1(129.78,92.88) 130.22,92.45 130.22,91.88
  IN1 w0.211: v1(128.63,52.94) 129.13,52.94 129.94,53.75 129.94,54.97 130.22,55.24 130.22,56 132.19,57.98 132.19,60.43 132.7,60.94 132.7,66.09 132.96,66.34 132.96,83.32 130.22,86.06 130.22,91.88
  BOTTOM w0.198: v2(127.82,52.94) v1(128.63,52.94)
M_B_A8: length 50.5
  TOP w0.198: XU1.AU26 129.06,96.89 v1(129.03,96.89) ; v1(128.67,59.45) 128.14,59.45 126.88,58.19 DIMM1.125
  IN1 w0.102: v1(129.03,96.89) 128.59,96.45 128.59,94.88 128.6,94.87 128.6,93.98 128.32,93.71 128.18,93.71 127.64,93.17 127.64,92.79 127.38,92.53 127.38,91.31
  IN1 w0.211: 127.38,91.31 127.38,81.04 127.68,80.74 128.01,80.74 128.39,81.12 128.78,81.12 129.16,80.74 129.16,80.4 128.78,80.01 128.78,79.64 129.18,79.24 129.18,75.22 128.98,75.02 128.54,75.02 128.26,74.73 128.26,74.17 128.49,73.94 129.48,73.94 129.74,73.67 129.74,73.14 129.48,72.89 128.65,72.89 128.34,72.57 128.34,72.08 128.7,71.72 128.7,71.26 128.34,70.9 128.34,70.37 128.68,70.03 128.68,65.6 128.1,65.02 128.1,61.89 127.56,61.35 127.56,61.02 127.85,60.72 128.75,60.72 129,60.47 129,59.78 v1(128.67,59.45)
  BOTTOM w0.198: v2(129.6,59.87) 129.09,59.87 v1(128.67,59.45)
