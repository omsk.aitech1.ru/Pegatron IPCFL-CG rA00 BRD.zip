# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_CPU_RSVD_C40: length 19.7
  TOP w0.102: XU1.C40 142.62,127.83 142.62,130.09 v1(142.11,130.6)
  IN2 w0.102: v1(146.35,136.92) 145.96,137.31 145.52,137.31 144.75,136.55 144.75,133.24 v1(142.11,130.6)
  BOTTOM w0.102: v1(146.35,136.92) 146.47,137.04 146.47,137.44 146.98,137.95 146.98,141.58 HT33.1
TP_CPU_RSVD_D15: length 35.2
  TOP w0.102: XU1.D15 116.8,127.07 v1(116.8,127.05)
  IN2 w0.102: v1(116.8,127.05) 116.8,127.26 116.33,127.73 116.33,128.14 116.04,128.43 114.77,128.43 113.88,127.54 106.61,127.54 106.08,128.08 104.51,128.08 104.04,128.55 v1(103.14,128.55)
  BOTTOM w0.102: HT32.1 90.33,140.74 90.33,139.37 92.65,137.05 94.43,137.05 96.71,134.77 97.14,134.77 100.5,131.41 100.71,131.41 103.14,128.98 v1(103.14,128.55)
TP_CPU_RSVD_H8: length 27.3
  TOP w0.102: XU1.H8 110.42,124.3 v1(110.41,124.3)
  BOTTOM w0.102: v1(110.41,124.3) 110.03,123.92 109.3,123.92 109,124.22 109,124.51 108.24,125.27 106.6,126.91 105.97,126.91 104.23,128.65 104.23,129.21 100.69,132.76 100.31,132.76 97.45,135.61 97.04,135.61 94.79,137.86 93.2,137.86 92.35,138.71 HT40.1
TP_CPU_RSVD_J7: length 28.8
  TOP w0.102: XU1.J7 v1(109.5,122.51)
  IN1 w0.102: v1(102.6,123.54) 103.02,123.96 104.67,123.96 105.7,122.93 109.08,122.93 v1(109.5,122.51)
  BOTTOM w0.102: v1(102.6,123.54) 102.6,125.45 103.54,126.4 103.54,127.39 103.23,127.7 102.66,127.7 101.79,128.57 101.79,129.15 100.34,130.6 100.17,130.6 96.82,133.94 96.39,133.94 94.09,136.24 91.87,136.24 HT6.1
TP_CPU_RSVD_J8: length 35
  TOP w0.102: XU1.J8 v1(111.3,123.4)
  IN1 w0.102: v1(111.3,123.4) 111.2,123.31 105.94,123.31 105.08,124.16 102.56,124.16 101.22,122.82 94.21,122.82 v1(92.91,121.53)
  BOTTOM w0.102: v1(92.91,121.53) 92.01,122.43 92.01,127.06 89.38,129.68 88.75,129.68 87.82,130.61 87.82,131.68 88.27,132.13 HT7.1
TP_CPU_RSVD_J11: length 25.6
  TOP w0.102: v1(113.09,123.39) 113.16,123.39 XU1.J11
  BOTTOM w0.102: HT26.1 97.62,136.02 97.95,136.02 100.07,133.91 101.66,133.91 102.13,133.44 102.13,131.61 104.44,129.3 104.44,128.74 106.06,127.12 106.68,127.12 108.32,125.47 109.04,124.76 111.72,124.76 v1(113.09,123.39)
TP_CPU_RSVD_J13: length 2.8
  TOP w0.102: v1(114.96,122.54) 115.01,122.54 XU1.J13
  BOTTOM w0.102: v1(114.96,122.54) 115.42,122.09 115.42,121 HT31.1
TP_CPU_RSVD_J14: length 5.7
  TOP w0.102: XU1.J14 115.88,122.49 v1(115.87,122.49)
  BOTTOM w0.102: HT30.1 117.57,118.53 116.31,119.8 116.31,122.06 v1(115.87,122.49)
TP_CPU_RSVD_J15: length 3.7
  TOP w0.102: XU1.J15 117.12,122.82 116.79,122.49 v1(116.79,122.47)
  BOTTOM w0.102: v1(116.79,122.47) 117.3,121.96 117.3,120.34 HT17.1
TP_CPU_RSVD_J17: length 4.2
  TOP w0.102: v1(119.55,123.4) 119.53,123.4 XU1.J17
  BOTTOM w0.102: v1(119.55,123.4) 119.07,122.93 119.07,121.86 119.58,121.35 HT28.1
TP_CPU_RSVD_J19: length 43.3
  TOP w0.102: XU1.J19 121.36,123.4 v1(121.37,123.4)
  IN1 w0.102: v1(121.37,123.4) 121.6,123.4 122.06,123.86 122.4,123.86 122.73,124.19 122.73,124.48 123.04,124.79 123.34,124.79 123.65,125.1 123.65,125.4 123.91,125.67 124.24,125.67 124.54,125.96 124.54,126.31 124.24,126.61 123.98,126.61 123.65,126.94 123.65,127.27 123.39,127.53 122.89,127.53 121.39,129.03 121.39,130.42 117.93,133.87 106.13,133.87 105.49,133.23 101.74,133.23 v1(101.71,133.26)
  BOTTOM w0.102: v1(101.71,133.26) 101.27,133.7 99.98,133.7 97.87,135.82 97.13,135.82 94.82,138.13 93.64,138.13 HT15.1
TP_CPU_RSVD_K8: length 28.7
  TOP w0.102: v1(110.36,122.47) 110.42,122.47 XU1.K8
  BOTTOM w0.102: v1(110.36,122.47) 109.96,122.06 108.08,122.06 105.56,124.58 105.56,126.46 103.62,128.4 103.62,128.96 100.82,131.77 100.44,131.77 97.21,134.99 96.77,134.99 94.51,137.25 92.74,137.25 91.26,138.73 HT12.1
TP_CPU_RSVD_K10: length 32.9
  TOP w0.102: v1(112.21,122.51) XU1.K10
  BOTTOM w0.102: HT14.1 91.11,141.65 91.11,140.42 91.95,139.58 91.95,138.54 93.03,137.46 94.62,137.46 96.87,135.21 97.28,135.21 100.14,132.35 100.52,132.35 103.83,129.04 103.83,128.49 105.97,126.35 105.97,126 109.02,122.95 111.77,122.95 v1(112.21,122.51)
TP_CPU_RSVD_K11: length 3.1
  TOP w0.102: v1(114.02,121.61) 114.02,121.61 XU1.K11
  BOTTOM w0.102: HT16.1 113.41,120.31 113.58,120.48 113.58,121.16 v1(114.02,121.61)
TP_CPU_RSVD_K12: length 4.9
  TOP w0.102: XU1.K12 114.05,122.49 v1(114.04,122.49)
  BOTTOM w0.102: v1(114.04,122.49) 114.45,122.09 114.45,121.3 114.53,121.22 114.53,120.48 HT27.1
TP_CPU_RSVD_K13: length 39.6
  TOP w0.102: XU1.K13 114.97,121.58 v1(114.89,121.58)
  IN2 w0.102: v1(114.89,121.58) 114.53,121.95 114.53,122.8 114.39,122.94 111.08,122.94 110.82,123.21 105.05,123.21 104.3,123.96 102.43,123.96 102.18,123.72 102.18,122.85 v1(102.56,122.47)
  BOTTOM w0.102: HT29.1 90.04,137.24 91.25,136.03 94.01,136.03 96.3,133.74 96.74,133.74 100.08,130.4 100.26,130.4 101.59,129.06 101.59,128.4 102.51,127.47 102.51,127.2 103,126.72 103,126.25 102.18,125.44 102.18,122.85 v1(102.56,122.47)
TP_CPU_RSVD_L8: length 33
  TOP w0.102: v1(110.34,121.58) 110.39,121.58 XU1.L8
  IN2 w0.102: v1(110.34,121.58) 109.93,121.99 109.93,122.67 109.62,122.98 103.79,122.98 v1(103.23,123.54)
  BOTTOM w0.102: HT13.1 89.43,139.41 92.4,136.44 94.18,136.44 96.47,134.15 96.91,134.15 100.25,130.8 100.42,130.8 102,129.23 102,128.65 102.74,127.9 103.32,127.9 103.75,127.47 103.75,126.22 103,125.47 103,123.78 v1(103.23,123.54)
TP_CPU_RSVD_L10: length 34.3
  TOP w0.102: XU1.L10 112.68,121.13 v1(113.13,121.58)
  BOTTOM w0.102: v1(113.13,121.58) 112.63,122.08 112.63,122.68 111.49,123.82 110.52,123.82 110.21,123.51 108.75,123.51 106.17,126.09 106.17,126.43 104.03,128.57 104.03,129.13 100.6,132.56 100.22,132.56 97.37,135.41 96.96,135.41 94.71,137.66 93.12,137.66 92.15,138.63 92.15,139.66 91.31,140.5 91.31,141.44 HT8.1
TP_CPU_RSVD_L12: length 4.9
  TOP w0.102: XU1.L12 114.1,120.71 v1(114.1,120.69)
  BOTTOM w0.102: HT10.1 115.39,117.92 115.39,119.17 114.1,120.46 v1(114.1,120.69)
TP_DIMM_DQ0: length 34.9
  TOP w0.254: v1(148.19,84.58) 149.15,84.58 152.54,87.97 152.54,103.67 146.97,109.24 XU1.AC40
  BOTTOM w0.102: HT1.1 148.02,84.4 v1(148.19,84.58)
TP_EDP_DISP_UTIL: length 35
  TOP w0.102: v1(116.8,128.01) 116.8,127.99 XU1.D14
  IN2 w0.102: v1(116.8,128.01) 116.18,128.64 114.65,128.64 114.4,128.39 110.22,128.39 110.18,128.35 104.52,128.35 103.9,128.97 102.67,128.97 v1(102.62,128.91)
  BOTTOM w0.102: HT2.1 90.13,139.8 90.13,139.28 92.57,136.85 94.35,136.85 96.64,134.55 97.08,134.55 100.42,131.21 100.59,131.21 102.62,129.18 v1(102.62,128.91)
TP_GPP_H_15: length 6.2
  TOP w0.102: v1(50.35,82.15) 50.62,81.89 U1.AC47
  BOTTOM w0.102: v2(47.51,80.31) 47.82,80.62 48.9,80.62 49.01,80.73 49.01,81.08 49.47,81.54 SR297.1 50.08,81.88 v1(50.35,82.15) 50.62,82.42 50.62,83.21 R99519.2
TP_GPP_H_18: length 1.5
  TOP w0.102: U1.AE44 49.3,83.08 v1(49.15,83.23)
  BOTTOM w0.102: v1(49.15,83.23) 49.4,83.48 ST20.1
TP_GPP_H_23: length 6.3
  TOP w0.102: U1.AJ47 48.02,81.72 48.02,81.03 47.88,80.89 47.88,79.28 48.49,78.67 48.49,78.04 v1(48.98,77.55) 48.84,77.41 SR7853.2
  BOTTOM w0.102: v2(49.05,78.27) 48.98,78.21 v1(48.98,77.55)
TP_PCH_AL35: length 3.6
  TOP w0.102: v1(46.53,87.24) 46.7,87.24 U1.AL35
  BOTTOM w0.102: TP2601.1 48.04,85.63 47.67,85.99 47.26,85.99 47.01,86.24 47.01,86.75 v1(46.53,87.24)
TP_PCH_AN35: length 1.5
  TOP w0.102: v1(46.53,87.87) 46.27,87.87 U1.AN35
  BOTTOM w0.102: v1(46.53,87.87) 46.94,88.28 TP2602.1
TP_TPM_GPIO0: length 4.1
  BOTTOM w0.127: U7201.29 16.62,67.08 F3R70.1 17.76,68.21 19.15,68.21 v2(19.47,67.89)
TP_TPM_GPIO1: length 4.1
  BOTTOM w0.102: TP7201.1 19.05,66.56 18.26,66.56 17.84,66.98 17.23,66.98 16.83,66.58 U7201.30
TP_UART0_RXD: length 2.2
  TOP w0.102: U1.BB24 41.71,93.03 42.29,92.45 v1(42.54,92.45)
  BOTTOM w0.102: v1(42.54,92.45) 42.54,93 LT12.1
TP_UART0_TXD: length 7.1
  TOP w0.089: U1.BE23 39.83,93.38 39.01,93.38 38.9,93.49 38.26,93.49 37.82,93.93 37.4,93.93
  TOP w0.102: v1(34.42,94.3) 34.98,93.74 36.08,93.74 36.27,93.93 37.4,93.93
  BOTTOM w0.102: v1(34.42,94.3) 33.93,94.3 LT11.1
TPM_CLK_R: length 2.1
  BOTTOM w0.127: R7206.1 12.36,70.9 v2(12.36,70.58) 12.67,70.27 12.67,70.19 12.84,70.02 U7201.19
TPM_CS2#: length 96.4
  TOP w0.127: R7210.2 12.8,70.67 v1(13.1,70.37) 13.44,70.37 v2(13.77,70.04)
  IN1 w0.127: v1(13.1,70.37) 13.99,69.48 13.99,65.14 12.57,63.72 12.57,60.14 12.89,59.82 12.89,57.54 13,57.43 13,57.41 13.55,56.86 13.55,56.2 14.24,55.5 16.98,55.5 18.45,54.03 21.43,54.03 22.82,52.63 24.8,52.63 25.3,53.13 28.6,53.13 29.11,53.63 30.05,53.63 30.86,52.82 31.29,52.82 31.54,53.08 32.17,53.08 32.61,52.63 34.27,52.63 34.9,52.01 37.85,52.01 38.74,51.12 39.38,51.12 39.65,50.85 43.46,50.85 44.49,49.82 50.24,49.82 50.7,50.28 51.28,50.28 v1(51.75,50.75)
  IN2 w0.127: v1(51.75,50.75) 51.54,50.97 51.54,51.3 50.57,52.26 50.57,52.89 51.26,53.59 51.26,54.78 51.05,54.99 51,55.04 51,56.99 51.2,57.19 51.2,59.03 51,59.23 51,59.48 50.47,60.01 50.47,62.32 v1(48.34,64.46)
  BOTTOM w0.127: SR7785.1 45.57,80.63 45.74,80.46 45.74,79.24 45.35,78.84 45.35,78.64 45.08,78.37 44.57,78.37 44.25,78.05 44.25,77.89 44.25,77.7 44.08,77.52 44.08,77.19 43.88,76.99 43.88,76.38 44.35,75.91 44.35,74.72 45,74.07 45,73.55 45.13,73.42 45.13,72.55 46.21,71.47 46.21,70.79 47.13,69.87 47.13,69.3 47.93,68.5 47.93,68.23 48.11,68.06 48.11,66.97 48.74,66.33 48.74,64.97 48.34,64.56 v1(48.34,64.46) ; v1(13.1,70.37) 13.34,70.13 U7201.20
TPM_ID: length 6.3
  TOP w0.102: v1(41.75,87.58) 41.77,87.58 U1.BA36
  BOTTOM w0.102: v1(41.75,87.58) 41.45,87.87 40.28,87.87 40.14,88.01 v2(39.75,88.01) 39.52,87.78 39.52,87.57 SR7879.2 38.71,87.62 38.02,87.62 37.9,87.5 37.9,87.3 SR25.2
TPM_MISO_R: length 2.8
  BOTTOM w0.127: v2(16.91,68.8) 16.78,68.94 R7204.1 16.05,69.79 15.86,69.98 15.46,69.98 15.34,69.87 U7201.24
TPM_MOSI_R: length 3.4
  BOTTOM w0.127: v2(12.8,72.3) 13.28,71.82 13.35,71.82 R7205.1 13.46,71.09 13.46,70.61 13.84,70.23 U7201.21
TPM_PIN2: length 2.5
  BOTTOM w0.102: U7201.2 R99513.2 14.84,62.99 v2(14.47,62.62)
TPM_PIN8: length 2.9
  BOTTOM w0.457: 8.18,65.02 8.18,66.28 8.98,67.08 R7212.1
  vias: v2(10.71,62.83)
TPM_PIN9: length 3
  BOTTOM w0.102: v2(10.13,64.71) 9.59,65.26 R99511.2 9.94,65.58 10.19,65.33 10.58,65.33 10.83,65.58 U7201.9
TPM_PIN14: length 3.5
  BOTTOM w0.279: U7201.14 10.59,68.08 10.17,68.49 C7204.1
  BOTTOM w0.457: v2(9.65,66.69) 9.65,67.41 R7212.2 C7204.1
TPM_PIN22: length 5.5
  TOP w0.254: v2(15.59,71.24) 15.35,71.24 R7216.2
  TOP w0.457: R7215.2 14.5,73.03 14.5,72.09 R7216.2 15,71.88 15.21,72.1 v1(15.21,72.74)
  BOTTOM w0.279: C7210.1 14.81,71.03 14.34,70.57 U7201.22
TPM_PIN32: length 2.4
  BOTTOM w0.102: U7201.32 R7213.2 17.28,66.14 v2(17.63,66.49)
TPM_RST#: length 13.3
  TOP w0.127: v1(9.8,71.36) 9.77,71.33 R7209.1 R7203.1
  BOTTOM w0.127: v2(4.93,67.93) 5.58,68.59 Q7201.2 5.58,69.45 6.75,70.63 7.21,70.63 8.23,71.64 9.52,71.64 v1(9.8,71.36) 9.76,71.36 9.37,70.97 9.37,69.98 C7203.1 10.25,70.17 10.71,70.17 10.94,69.94 11.71,69.94 11.84,69.81 U7201.17
TRST#: length 119
  TOP w0.102: v1(40.75,112.33) 40.75,112.04 40.63,111.91 40.04,111.91 39.64,111.51 HR366.2 ; v1(114.03,125.23) 114.5,125.7 XU1.F12 ; v1(96.2,123.79) 95.86,123.79 93.61,126.04 90.23,126.04 90.04,125.85 89.53,125.85 89.14,126.24 86.19,126.24 85.78,126.65 84.67,126.65 84.04,126.02 83.88,126.02 82.36,124.51 82.36,122.62 82.12,122.38 81.77,122.38 81.75,122.39 v1(81.13,122.39)
  IN1 w0.102: v1(81.13,122.39) 80.65,121.92 80.65,120.66 80.29,120.29 80.29,118.45 77.89,116.05 77.89,113.57 77.19,112.87 77.19,111.34 75.77,109.92 75.31,109.92 v1(74.83,109.44) ; v1(96.2,123.79) 96.66,124.24 98.09,124.24 98.61,124.75 101.37,124.75 102.11,125.49 102.81,125.49 103.38,126.06 104.1,126.06 104.87,126.83 113.06,126.83 114.03,125.86 v1(114.03,125.23)
  IN2 w0.102: v1(40.75,112.33) 40.93,112.51 45.06,112.51 45.19,112.64 45.19,117.11 51.5,123.42 55.5,123.42 56.13,122.79 57.78,122.79 59.2,124.21 59.2,125.05 60.25,126.1 60.88,126.1 62.52,127.74 62.52,130.45 62.96,130.9 63.6,130.9 64.18,130.31 64.18,129.98 65.64,128.52 67.22,128.52 67.53,128.83 72.22,128.83 v1(72.22,128.82)
  BOTTOM w0.102: v1(81.13,122.39) 77.01,122.39 73.18,126.23 73.18,127.16 v2(72.22,128.11) v1(72.22,128.82) ; v1(74.83,109.44) 73.85,108.46 XDP1.54
UART_BT_WAKE_N: length 15.5
  TOP w0.089: U1.BE32 39.8,89.35 39.62,89.35 39.38,89.59 37.99,89.59
  TOP w0.102: v2(26.33,88.45) 26.49,88.61 27.52,88.61 27.66,88.47 27.92,88.47 27.98,88.42 R3111.1 28.65,88.04 SR672.2 29.25,88.22 29.32,88.29 30.37,88.29 30.53,88.45 32.44,88.45 32.67,88.67 35.8,88.67 36.63,89.5 36.63,89.51 37.16,90.05 37.53,90.05 37.99,89.59
UART_BT_WAKE_R_N: length 61.2
  TOP w0.102: J218.20 39.45,51.4 39.38,51.33 38.64,51.33 37.95,50.64 37.95,48.96 v1(37.9,48.91) ; R3111.2 26.92,87.82 25.41,87.82 24.4,86.81 24.4,86.21 22.43,84.24 22.43,78.24 20.19,76 20.19,75.53 v2(19.66,75) 19.2,75 18.97,74.77 18.97,72.51 19.86,71.62 21.29,71.62 23.29,69.62 23.29,68.54 22.85,68.09 22.85,64.59 22.39,64.14 22.39,60.53 v1(22.86,60.06)
  IN2 w0.102: v1(37.9,48.91) 36.42,48.91 35.09,50.24 33.06,50.24 32.35,50.94 31.05,50.94 28.73,53.27 28.73,55.65 24.31,60.06 v1(22.86,60.06)
UIM_PWR70: length 5.5
  TOP w0.305: J218.70 51.95,53.14 v1(52.37,53.56)
  BOTTOM w0.305: SR7887.2 55.14,52.65 v2(54.57,52.65) 53.59,52.65 R3136.2 52.92,52.45 52.37,53 v1(52.37,53.56)
USB2_COMP_W4S5L400MIL: length 9
  TOP w0.102: 59.21,104.72 59.21,104.27 59.31,103.84 59.31,103.74 59.31,103.67 59.4,103.37 U1.F4
  TOP w0.127: v2(60.83,110.2) 61.52,109.51 61.52,108.43 SR322.1 61.44,107.44 61.44,106.26 60.65,105.48 59.96,105.48 59.21,104.72
USB2ID: length 9.4
  TOP w0.102: U1.G3 58.97,103.35 59.08,103.64 59.08,103.83 59.03,103.94 58.98,104.1 58.98,104.8 59.88,105.7 60.3,105.7 60.88,106.29 v1(60.88,107.1) 60.88,107.48 61.06,107.66 R2104.1
  BOTTOM w0.102: v2(61.85,109.72) 61.36,109.24 61.36,108.46 R2102.2 61.05,107.18 60.96,107.18 v1(60.88,107.1)
USB2VBUSSENSE: length 8.7
  TOP w0.102: R2101.2 63.23,108.32 R2103.1 62.81,107.98 62.52,107.68 62.52,107.61 v1(62.27,107.37) 62.29,107.34 62.29,106.53 61.01,105.25 60.04,105.25 59.43,104.64 59.43,104.2 59.59,103.89 U1.F3
  BOTTOM w0.102: v2(62.76,107.97) 62.27,107.48 v1(62.27,107.37)
USB3_RXN1_F1: length 109.9
  TOP w0.102: U1.D11 60.22,99.47 60.57,99.47 60.81,99.23 64.17,99.23 64.63,99.68 64.75,99.68 64.76,99.7 64.8,99.7 64.84,99.73 64.85,99.73
  TOP w0.127: CM3302.3 80.11,20.85 79.99,20.96 79.99,25.86 v1(80.34,26.2) ; v1(67.81,99.79) 67.58,99.56 66.44,99.56 66.27,99.73 64.85,99.73
  IN1 w0.127: v1(67.81,99.79) 67.84,99.81 67.84,100.36 68.19,100.71 68.87,100.71 71.4,98.18 71.4,97.16 73.44,95.12 73.44,94.48 74.15,93.76 74.15,88.65 78.7,84.11 78.7,80.7 80.74,78.66 80.74,74.57 82.74,72.57 82.74,71.7 84.66,69.79 84.66,68.54 84.3,68.19 84.3,67.18 81.39,64.27 81.39,58.75 84.78,55.36 84.78,52.05 85.83,51 85.83,43.11 88.68,40.26 88.68,27.1 87.88,26.3 85.39,26.3 84.97,26.72 80.42,26.72 80.34,26.64 v1(80.34,26.2)
USB3_RXN1_F1_R: length 7.4
  TOP w0.127: CM3302.4 80.11,19.92 79.97,19.79 79.97,19.1 79.86,18.99 79.86,18.76 79.98,18.64 D3301.6 D3301.5 79.98,17.66 79.86,17.54 79.86,16.75 80.08,16.52 81.51,16.52 81.94,16.09 81.94,15.45 82.11,15.28 J133.5
USB3_RXN2_F2: length 104.1
  TOP w0.102: 64.34,100.67 63.73,100.07 61.44,100.07 61.35,100.11 61.07,100.23 U1.B9
  TOP w0.127: v1(65.17,23.31) 64.92,23.31 64.79,23.18 64.79,21.18 65.01,20.96 65.03,20.94 65.32,20.94 65.42,20.84 RN44.1 ; 64.34,100.67 64.44,100.78 65.37,100.78 65.45,100.86 65.45,101.01 v1(65.23,101.23)
  IN1 w0.127: v1(65.17,23.31) 64.96,23.52 62.73,23.52 61.97,24.28 61.97,26.43 65.87,30.33 65.87,34.26 66.39,34.78 66.39,39.79 69.98,43.37 69.98,46.93 70.72,47.68 71.47,47.68 72.64,48.86 72.64,58.35 78.04,63.75 78.04,65.69 78.88,66.53 78.88,71.15 79.18,71.46 79.18,73.18 78.32,74.05 78.32,78.56 76.46,80.42 76.46,83.57 71.89,88.14 71.89,90.81 71.36,91.35 71.36,93.87 69.38,95.85 69.38,96.73 67.88,98.22 66.52,98.22 65.59,99.15 65.59,100.74 65.51,100.83 65.38,100.83 65.28,100.73 65.15,100.73 65.02,100.85 65.02,101.03 v1(65.23,101.23)
USB3_RXN2_F2_R: length 8.6
  TOP w0.127: RN44.2 65.42,19.64 65.23,19.45 65.23,18.84 65.36,18.7 D4003.6 D4003.5 65.36,17.23 65.24,17.11 65.24,16.44 64.87,16.07 62.2,16.07 61.9,15.76 61.9,15.41 62.03,15.28 J200.5
USB3_RXN3_B1: length 70
  TOP w0.102: U1.B10 60.9,99.56 61.21,99.43 64.04,99.43 64.65,100.04 64.87,100.04
  TOP w0.127: v1(63.66,106.28) 63.66,106.04 63.78,105.91 65.61,105.91 66.83,104.7 66.83,102.2 67.11,101.92 67.11,101.01 66.14,100.04 64.87,100.04
  IN1 w0.127: v1(63.66,106.28) 63.5,106.12 63.32,106.12 62.79,106.65 62.79,106.9 62.97,107.08 62.97,108.27 63.18,108.49 63.18,119.59 67.07,123.48 67.07,127.2 66.52,127.74 66.52,129.03 65.85,129.7 65.85,133.14 63.76,135.24 63.76,136.81 62.28,138.29 62.28,139.51 62.41,139.64 62.69,139.64 62.81,139.77 v1(62.81,140.12)
  BOTTOM w0.127: v1(62.81,140.12) 62.81,139.79 62.69,139.66 62.53,139.66 62.41,139.54 62.41,139.21 62.56,139.05 63.4,139.05 63.73,139.38 63.73,140.42 64.7,141.39 67.67,141.39 69.84,143.56 69.84,145.46 ; RN93.3 69.47,148.2 69.6,148.07 69.71,148.07 69.84,147.94 69.84,145.46 ; 69.84,145.46 v2(69.56,145.46)
USB3_RXN3_B1_R: length 10.6
  BOTTOM w0.127: J12.14 67.94,157.13 68.07,157 68.07,156.05 68.6,155.51 69.52,155.51 69.87,155.16 69.87,152.24 70.19,151.92 70.19,151.79 70.09,151.69 D3601.1 D3601.10 70.09,150.12 69.63,149.66 69.63,149.23 RN93.4
USB3_RXN4_B2: length 69.2
  TOP w0.127: v1(57.2,96.57) 57.22,96.59 57.22,96.88 U1.K16 ; 68.96,132.75 66.58,132.75 66.06,132.22 62.08,132.22 60.27,130.42 v1(59.74,130.42) ; 68.96,132.75 72.1,132.75 72.67,133.32 72.67,144.05 70.53,146.19 70.53,148.48 70.09,148.92 70.09,149.92 69.74,150.27 RN90.1 ; 68.96,132.75 v2(68.96,133.01)
  IN1 w0.127: v1(59.74,130.42) 59.74,130.16 59.19,129.61 59.19,126.97 58.7,126.48 58.7,123.75 57.36,122.41 57.36,116.53 57.8,116.1 57.8,107.03 57.15,106.38 57.15,102.32 56.91,102.09 56.91,98.5 57.45,97.96 57.45,96.83 57.41,96.78 v1(57.2,96.57)
USB3_RXN4_B2_R: length 12.4
  TOP w0.127: J12.5 67.73,160.33 67.97,160.09 67.97,159.65 68.78,158.84 68.78,158.19 68.13,157.54 68.13,156.72 68.77,156.08 69.95,156.08 70.2,155.82 70.2,154.47 70.09,154.36 D3603.10 D3603.1 70.09,152.79 70.22,152.67 70.22,152.28 69.92,151.98 69.92,151.58 69.74,151.41 RN90.2
USB3_RXP1_F1: length 109.9
  TOP w0.102: U1.C11 60.39,99.13 60.5,99.02 60.73,99.02 60.73,99.02 64.26,99.02 64.71,99.48 64.85,99.48
  TOP w0.127: 64.85,99.48 66.16,99.48 66.34,99.3 68.48,99.3 68.55,99.38 68.55,99.7 68.48,99.77 v1(68.46,99.77) ; v5(79.53,26.2) 79.75,25.98 79.74,25.96 79.74,20.98 79.61,20.85 CM3302.2
  IN1 w0.127: v1(68.46,99.77) 68.46,99.79 68.11,100.15 68.11,100.25 68.3,100.45 68.76,100.45 71.13,98.07 71.13,97.05 73.17,95.01 73.17,94.37 73.89,93.65 73.89,88.54 78.43,84 78.43,80.59 80.47,78.55 80.47,74.46 82.47,72.46 82.47,71.59 84.39,69.67 84.39,68.65 84.03,68.3 84.03,67.29 81.13,64.38 81.13,58.64 84.52,55.25 84.52,51.94 85.57,50.89 85.57,43 88.42,40.15 88.42,27.21 87.77,26.57 85.5,26.57 85.08,26.99 80.31,26.99 v5(79.53,26.2)
USB3_RXP1_F1_R: length 7.4
  TOP w0.127: J133.6 81.48,15.28 81.68,15.48 81.68,15.99 81.41,16.26 79.98,16.26 79.6,16.64 79.6,17.54 79.48,17.67 D3301.4 D3301.7 79.48,18.61 79.6,18.73 79.6,19.09 79.72,19.21 79.72,19.81 79.61,19.92 CM3302.1
USB3_RXP2_F2: length 104.3
  TOP w0.089: 61.27,99.93 61.11,99.99 60.7,99.99 U1.C9
  TOP w0.102: 61.27,99.93 61.39,99.86 63.82,99.86 64.41,100.45 64.43,100.45 64.45,100.48 64.51,100.48 64.52,100.49
  TOP w0.127: RN44.3 64.82,20.79 64.76,20.85 64.54,21.07 64.54,23.31 v1(65.17,23.94) ; 64.52,100.49 64.55,100.52 65.48,100.52 65.71,100.75 65.71,100.93 v5(65.99,101.21)
  IN1 w0.127: v5(65.99,101.21) 65.86,101.08 65.86,99.26 66.63,98.49 67.99,98.49 69.65,96.84 69.65,95.96 71.63,93.98 71.63,91.46 72.16,90.92 72.16,88.25 76.73,83.69 76.73,80.53 78.59,78.68 78.59,74.16 79.45,73.29 79.45,71.35 79.14,71.04 79.14,66.42 78.31,65.58 78.31,63.64 72.91,58.24 72.91,48.75 71.58,47.41 70.84,47.41 70.24,46.82 70.24,43.26 66.66,39.68 66.66,34.67 66.14,34.15 66.14,30.22 62.24,26.32 62.24,24.39 62.84,23.79 65.02,23.79 v1(65.17,23.94)
USB3_RXP2_F2_R: length 8.5
  TOP w0.127: RN44.4 64.82,19.54 64.97,19.4 64.97,18.81 64.86,18.7 D4003.7 D4003.4 64.86,17.23 64.99,17.11 64.99,16.54 64.76,16.32 62.1,16.32 61.64,15.87 61.64,15.43 61.49,15.28 J200.6
USB3_RXP3_B1: length 70.1
  TOP w0.089: 61.31,99.63 61.1,99.75 61.06,99.8 60.99,99.8 60.97,99.81 60.71,99.81 60.63,99.73 U1.C10
  TOP w0.102: 61.31,99.63 63.96,99.63 64.57,100.24 64.77,100.24 64.78,100.26 64.84,100.26 64.86,100.27 64.87,100.27
  TOP w0.127: v1(63.18,105.69) 65.51,105.69 66.6,104.6 66.6,102.1 66.88,101.83 66.88,101.1 66.05,100.27 64.87,100.27
  IN1 w0.127: v1(63.18,105.69) 63.18,105.94 62.56,106.56 62.56,106.99 62.74,107.17 62.74,108.36 62.95,108.58 62.95,119.69 66.84,123.57 66.84,127.1 66.29,127.65 66.29,128.93 65.63,129.6 65.63,133.04 63.66,135.01 63.53,135.14 63.53,136.71 62.05,138.19 62.05,139.61 62.18,139.73 v1(62.18,140.12)
  BOTTOM w0.127: 70.07,147.02 70.07,143.47 67.77,141.17 64.8,141.17 63.96,140.32 63.96,139.28 63.5,138.83 62.46,138.83 62.18,139.11 v1(62.18,140.12) ; 70.07,147.02 RN93.1 ; 70.07,147.02 v2(70.35,147.02)
USB3_RXP3_B1_R: length 10.6
  BOTTOM w0.127: J12.15 68.45,157.13 68.32,157 68.32,156.15 68.71,155.77 69.62,155.77 70.13,155.26 70.13,152.34 70.45,152.02 70.45,151.82 70.59,151.67 D3601.2 D3601.9 70.59,150.26 69.88,149.55 69.88,149.31 70.07,149.12 RN93.2
USB3_RXP4_B2: length 69.2
  TOP w0.127: U1.J15 57.57,97.18 57.57,96.9 57.86,96.61 v1(57.96,96.61) ; 71.5,132.49 66.69,132.49 66.17,131.97 62.18,131.97 v1(60.15,129.93) ; 71.5,132.49 72.2,132.49 72.92,133.21 72.92,144.16 70.79,146.29 70.79,148.58 70.34,149.03 RN90.3 ; 71.5,132.49 v2(71.5,132.23)
  IN1 w0.127: v1(60.15,129.93) 59.88,129.93 59.45,129.5 59.45,126.86 58.97,126.37 58.97,123.64 57.63,122.3 57.63,116.64 58.06,116.21 58.06,106.92 57.41,106.27 57.41,102.21 57.17,101.97 57.17,98.61 57.72,98.07 57.72,96.85 v1(57.96,96.61)
USB3_RXP4_B2_R: length 12.4
  TOP w0.127: J12.6 68.52,160.33 68.22,160.03 68.22,159.76 69.04,158.94 69.04,158.09 68.38,157.43 68.38,156.82 68.87,156.34 70.05,156.34 70.46,155.93 70.46,154.52 70.59,154.39 D3603.9 D3603.2 70.59,152.79 70.47,152.67 70.47,152.17 70.17,151.87 70.17,151.58 70.34,151.41 RN90.4
USB3_TXN1_F1: length 2.1
  TOP w0.127: RN107.1 78.38,20.8 78.23,20.95 78.23,21.22 78.54,21.53 78.54,21.91 SC2.2
USB3_TXN1_F1_C: length 118.2
  TOP w0.127: v1(77.98,26.2) 77.75,25.98 77.75,25.85 77.87,25.72 78.32,25.72 78.6,25.44 78.6,23.47 SC2.1 ; v1(58.44,100.39) 58.44,100.13 58.69,99.89 58.9,99.89 59.05,100.04 U1.F9
  IN1 w0.127: v1(58.44,100.39) 58.79,100.39 59.18,100.77 59.18,103.44 59.75,104.02 61.94,104.02 62.56,103.39 63.09,103.39 63.39,103.7 65.41,103.7 65.86,103.24 66.55,103.24 68.29,101.5 68.8,101.5 71.91,98.39 71.91,97.37 73.95,95.33 73.95,94.69 74.66,93.97 74.66,88.93 81.61,81.98 81.61,74.47 83.25,72.83 83.25,71.91 85.34,69.82 85.34,67.5 81.9,64.06 81.9,59.09 85.29,55.7 85.29,52.26 86.34,51.21 86.34,44.3 89.19,41.46 89.19,26.8 88.03,25.63 78.24,25.63 77.98,25.89 v1(77.98,26.2)
USB3_TXN1_F1_R: length 7.7
  TOP w0.127: J133.8 76.09,15.28 75.87,15.5 75.87,15.84 76.25,16.22 77.85,16.22 78.38,16.75 78.38,17.57 78.48,17.66 D3301.2 D3301.9 78.48,18.59 78.35,18.71 78.35,19.27 78.21,19.42 78.21,19.67 78.38,19.85 RN107.2
USB3_TXN2_F2: length 1.7
  TOP w0.127: SC145.2 63.63,21.67 63.63,21.05 63.77,20.9 RN43.1
USB3_TXN2_F2_C: length 101.5
  TOP w0.127: v1(59.92,103.34) 60.37,103.34 60.41,103.31 U1.C3 ; v1(64.06,24.7) 63.73,24.37 63.73,23.54 64.03,23.23 SC145.1
  IN1 w0.127: v1(64.06,24.7) 63.83,24.93 63.83,26.74 66.88,29.78 66.88,33.14 68.97,35.24 68.97,40.92 71.42,43.37 71.42,46.12 73.66,48.36 73.66,56.72 74.04,57.1 74.04,58.31 79.04,63.31 79.04,64.58 79.88,65.42 79.88,68.09 80.36,68.57 80.36,73.57 79.35,74.59 79.35,78.96 77.57,80.74 77.57,84.12 73.35,88.33 73.35,90.97 72.52,91.81 72.52,94.13 70.38,96.26 70.38,97.14 68.3,99.23 67.1,99.23 66.65,99.68 66.65,100.83 67.08,101.26 67.08,101.94 66.29,102.73 65.65,102.73 65.22,103.17 63.58,103.17 63.22,102.81 61.31,102.81 60.78,103.34 v1(59.92,103.34)
USB3_TXN2_F2_R: length 12.8
  TOP w0.127: J200.8 56.03,15.28 55.88,15.43 55.88,15.97 56.74,16.83 63.37,16.83 63.86,17.32 D4003.2 D4003.9 63.86,18.75 63.77,18.84 RN43.2
USB3_TXN3_B1: length 19.2
  TOP w0.127: SC88.2 62.91,137.99 62.79,138.12 62.36,138.12 62.23,138.24 62.23,138.94 62.44,139.16 63.63,139.16 ; v1(65.38,139.97) 64.57,139.16 63.63,139.16 ; v2(63.63,138.88) 63.63,139.16
  BOTTOM w0.127: v1(65.38,139.97) 65,139.59 65,139.33 65.25,139.08 66.72,139.08 71.55,143.91 71.55,147.31 71.36,147.5 RN94.3
USB3_TXN3_B1_C: length 45.7
  TOP w0.127: v5(62.87,135.93) 62.56,136.24 62.56,136.5 SC88.1 ; U1.F11 59.07,99.03 v1(59.28,98.82)
  IN1 w0.127: v1(59.28,98.82) 59.13,98.82 58.66,99.29 58.2,99.29 57.99,99.51 57.99,100.55 58.3,100.87 58.3,102.69 58.13,102.87 58.13,105.97 58.9,106.75 58.9,107.36 59.03,107.48 60.65,107.48 62.42,109.25 62.42,120.5 65.9,123.98 65.9,127.26 65.12,128.04 65.12,132.3 62.55,134.88 62.55,135.6 v5(62.87,135.93)
USB3_TXN3_B1_R: length 10.6
  BOTTOM w0.127: J12.17 73.87,157.13 73.99,157 73.99,155.32 71.73,153.05 71.73,151.78 71.59,151.65 D3601.4 D3601.7 71.59,150.39 71.7,150.28 71.7,149.78 71.55,149.63 71.55,149.15 71.41,149.01 CM3602.1
USB3_TXN4_B2: length 2
  TOP w0.127: SC8.2 71.96,149.14 71.96,149.54 71.78,149.72 71.78,150.16 71.6,150.33 RN91.1
USB3_TXN4_B2_C: length 74.4
  TOP w0.102: 64.08,97.7 64.07,97.72 64.07,97.77 64.05,97.79 64.05,97.84 63.84,98.05 61.31,98.05 61.29,98.04 U1.B14
  TOP w0.127: 64.79,97.37 66.44,97.37 66.45,97.37 66.93,97.37 67.44,97.88 68.76,97.88 69.83,98.95 69.83,100.72 68.35,102.2 68.35,106.19 66.98,107.56 66.06,107.56 65.69,107.19 65.54,107.19 65.43,107.3 65.16,107.3 v1(65.05,107.19) ; 64.79,97.37 64.41,97.37 64.08,97.7 ; 64.79,97.37 v2(64.79,97.11) ; SC8.1 72.04,148.02 72.13,147.92 72.13,147.64 72.34,147.44 72.34,146.16 73.56,144.94 73.56,143.7 74.7,142.56 74.7,141.42 73.6,140.32 73.6,132.88 71.42,130.7 67.65,130.7 67.52,130.82 67.52,131.14 v1(67.66,131.28)
  IN1 w0.127: v1(65.05,107.19) 64.84,106.99 64.43,106.99 64.04,107.37 64.04,108.01 64.45,108.41 64.45,109.22 63.96,109.71 63.96,115.94 64.81,116.79 64.81,117.42 64.55,117.68 64.55,119.87 67.84,123.16 67.84,127.52 67.3,128.07 67.3,130.86 67.66,131.22 v1(67.66,131.28)
USB3_TXN4_B2_R: length 12.2
  TOP w0.127: J12.8 73.87,160.33 74.01,160.19 74.01,159.42 73.63,159.04 73.63,158.22 73.99,157.86 73.99,156.41 73.3,155.72 71.95,155.72 71.7,155.47 71.7,154.57 71.59,154.46 D3603.7 D3603.4 71.59,152.79 71.72,152.67 71.72,152.1 71.78,152.04 71.78,151.61 71.65,151.49 CM3606.4
USB3_TXP1_F1: length 2
  TOP w0.127: CM3301.2 77.83,20.82 77.98,20.97 77.98,21.33 78.28,21.63 78.28,22.03 SC1.2
USB3_TXP1_F1_C: length 118.3
  TOP w0.102: U1.F7 58.84,101.04 v1(58.75,100.95)
  TOP w0.127: SC1.1 78.34,23.47 78.34,25.34 78.22,25.47 77.77,25.47 77.49,25.74 77.49,25.92 v5(77.21,26.2)
  IN1 w0.127: v5(77.21,26.2) 77.29,26.2 78.13,25.36 88.14,25.36 89.46,26.69 89.46,41.57 86.61,44.41 86.61,51.32 85.56,52.37 85.56,55.81 82.17,59.2 82.17,63.95 85.61,67.39 85.61,69.93 83.51,72.02 83.51,72.94 81.88,74.58 81.88,82.09 74.93,89.04 74.93,94.08 74.21,94.8 74.21,95.44 72.17,97.48 72.17,98.5 68.91,101.77 68.4,101.77 66.66,103.51 65.97,103.51 65.52,103.96 63.28,103.96 62.98,103.66 62.67,103.66 62.05,104.28 59.64,104.28 58.91,103.55 58.91,101.12 v1(58.75,100.95)
USB3_TXP1_F1_R: length 7.6
  TOP w0.127: CM3301.1 77.83,19.67 77.95,19.55 77.95,19.32 78.1,19.17 78.1,18.71 77.98,18.58 D3301.10 D3301.1 77.98,17.64 78.13,17.49 78.13,16.85 77.75,16.47 76.15,16.47 75.61,15.94 75.61,15.46 75.43,15.28 J133.9
USB3_TXP2_F2: length 1.7
  TOP w0.127: SC144.2 63.37,21.82 63.37,21.02 63.17,20.82 RN43.3
USB3_TXP2_F2_C: length 101.5
  TOP w0.127: U1.D4 60.26,102.82 60.02,102.58 v1(59.84,102.58) ; SC144.1 63.5,23.29 63.5,24.37 v5(63.17,24.7)
  IN1 w0.127: v5(63.17,24.7) 63.6,25.14 63.6,26.83 66.65,29.88 66.65,33.24 68.74,35.33 68.74,41.02 71.19,43.47 71.19,46.22 73.43,48.45 73.43,56.81 73.81,57.19 73.81,58.4 78.81,63.41 78.81,64.68 79.65,65.51 79.65,68.18 80.14,68.66 80.14,73.48 79.12,74.49 79.12,78.86 77.34,80.64 77.34,84.02 73.13,88.24 73.13,90.88 72.29,91.72 72.29,94.03 70.15,96.17 70.15,97.05 68.2,99 67.01,99 66.42,99.59 66.42,100.92 66.85,101.35 66.85,101.84 66.19,102.5 65.56,102.5 65.13,102.94 63.67,102.94 63.32,102.58 61.22,102.58 60.68,103.11 60.37,103.11 v1(59.84,102.58)
USB3_TXP2_F2_R: length 12.8
  TOP w0.127: J200.9 55.47,15.28 55.62,15.43 55.62,16.07 56.64,17.08 63.27,17.08 63.36,17.18 D4003.1 D4003.10 63.36,18.78 63.52,18.93 63.52,19.48 63.17,19.82 RN43.4
USB3_TXP3_B1: length 19.2
  TOP w0.127: v1(64.74,139.97) 64.74,139.69 64.46,139.41 62.34,139.41 61.97,139.05 61.97,138.65 ; 61.97,138.65 SC89.2 ; 61.97,138.65 v2(61.7,138.65)
  BOTTOM w0.127: v1(64.74,139.97) 64.74,139.23 65.15,138.83 66.83,138.83 71.8,143.8 71.8,147.31 71.96,147.47 RN94.1
USB3_TXP3_B1_C: length 45.7
  TOP w0.127: SC89.1 62.3,136.53 62.3,136.21 v1(62.1,136.01) ; v1(58.7,98.47) 58.7,98.65 U1.G12
  IN1 w0.127: v1(58.7,98.47) 58.7,98.88 58.55,99.02 58.09,99.02 57.72,99.4 57.72,100.66 58.04,100.98 58.04,102.58 57.86,102.76 57.86,106.08 58.63,106.86 58.63,107.47 58.92,107.75 60.54,107.75 62.15,109.36 62.15,120.61 65.63,124.09 65.63,127.15 64.85,127.93 64.85,132.19 62.28,134.76 62.28,135.83 v1(62.1,136.01)
USB3_TXP3_B1_R: length 10.6
  BOTTOM w0.127: J12.18 74.37,157.13 74.25,157 74.25,155.21 71.98,152.95 71.98,151.81 72.09,151.69 D3601.5 D3601.6 72.09,150.37 71.96,150.23 71.96,149.67 71.8,149.52 71.8,149.11 71.96,148.95 RN94.2
USB3_TXP4_B2: length 2.1
  TOP w0.127: RN91.3 72.2,150.33 72.03,150.16 72.03,149.83 72.21,149.65 72.21,149.25 SC7.2
USB3_TXP4_B2_C: length 74.5
  TOP w0.102: 64.26,97.88 64.26,97.91 63.92,98.26 61.4,98.26 61.34,98.31 60.74,98.31 U1.C14
  TOP w0.127: SC7.1 72.59,146.27 73.81,145.05 73.81,143.8 74.95,142.66 74.95,141.32 73.85,140.22 73.85,132.77 71.52,130.44 67.54,130.44 v1(66.92,131.07) ; 64.26,97.88 64.51,97.63 66.44,97.63 ; 66.44,97.63 66.55,97.63 66.83,97.63 67.33,98.14 68.65,98.14 69.57,99.06 69.57,100.61 68.1,102.09 68.1,106.08 66.87,107.3 66.17,107.3 v1(65.58,106.72) ; 66.44,97.63 v2(66.44,97.91)
  IN1 w0.127: v1(66.92,131.07) 67.03,130.96 67.03,127.96 67.57,127.41 67.57,123.27 64.29,119.98 64.29,117.57 64.54,117.31 64.54,116.9 63.69,116.05 63.69,109.6 64.18,109.11 64.18,108.52 63.78,108.12 63.78,107.26 64.32,106.72 v1(65.58,106.72)
USB3_TXP4_B2_R: length 12.1
  TOP w0.127: CM3606.1 72.15,151.49 72.03,151.61 72.03,152.14 71.97,152.2 71.97,152.67 72.09,152.79 D3603.5 D3603.6 72.09,154.31 71.96,154.45 71.96,155.36 72.06,155.46 73.4,155.46 74.24,156.3 74.24,157.96 73.88,158.32 73.88,158.93 74.27,159.32 74.27,160.2 74.4,160.33 J12.9
USB_CABLE_DET1_R: length 5.2
  TOP w0.089: v1(54.82,80.71) 54.62,80.91 54.62,81.68 54.6,81.76 54.6,82.2 U1.R46
  BOTTOM w0.102: SR88.1 54.79,80.71 v1(54.82,80.71) 55.65,80.71 v2(56.06,81.12) 56.5,81.56 SR72.2
USB_EN_S4WAKE: length 168.1
  TOP w0.089: v1(54.98,79.34) 54.98,79.6 54.83,79.75 54.83,80.09 54.84,80.09 54.84,80.1 55.24,80.5 55.24,80.9 54.84,81.29 U1.R47
  TOP w0.102: SR8000.1 68.08,144.26 v2(68.08,144.9) 68.08,145.64 68.5,146.06 v1(68.5,146.47)
  IN1 w0.102: v1(16.52,121.67) 16.6,121.6 16.6,119.65 15.24,118.3 15.24,117.23 13.28,115.27 13.28,113.48 12.71,112.9 12.71,110.59 13,110.3 13,106 13.45,105.56 13.45,104.75 13.09,104.4 13.09,103.49 13.51,103.07 13.51,100.06 13.85,99.73 13.85,99 14.95,97.9 14.95,90.69 15.92,89.72 16.19,89.72 19.94,85.97 19.94,85.72 20.53,85.12 20.53,79.31 24.32,75.53 24.62,75.53 26.1,74.06 27.52,74.06 28.82,72.76 30.38,72.76 30.88,72.26 32.87,72.26 33.68,73.06 34.81,73.06 36.05,71.82 36.57,71.82 38.02,73.27 38.02,74.18 38.45,74.6 41.08,74.6 41.24,74.75 42.83,74.75 46.96,70.63 48.45,70.63 48.64,70.82 50.49,70.82 53.95,74.28 53.95,74.49 54.58,75.12 54.58,78.84 54.61,78.87 54.61,78.97 v1(54.98,79.34)
  IN2 w0.102: v1(68.5,146.47) 68.5,146.06 67.73,145.29 62.49,145.29 62.26,145.52 59.51,145.52 58.07,144.09 54.35,144.09 53.31,145.13 52.41,145.13 51.44,144.16 45.52,144.16 44.32,142.95 43.24,142.95 40,139.72 38.34,139.72 37.62,138.99 37.62,138.54 35.64,136.56 33.27,136.56 31.99,135.28 31.1,135.28 30.11,134.29 29.14,134.29 27.74,132.9 26.34,132.9 22.6,129.16 22.6,127.08 22.52,127 22.52,124.47 21.34,123.29 18.15,123.29 v1(16.52,121.67)
USB_EN_S4WAKE_R: length 64.4
  TOP w0.102: UU22.4 38.64,163.88 v1(38.95,164.19) ; v1(68.83,154.38) 68.83,152.91 69.18,152.56 69.18,147.54 68.96,147.32 68.96,146.19 68.58,145.81 68.58,144.52 68.93,144.16 69.43,144.16 69.61,143.98 SR8000.2 SR3701.2 SR8002.2 69.61,141.05 69.17,140.61 AQ20.6
  IN1 w0.127: v1(68.83,154.38) 68.42,154.38 66.36,156.43 62.55,156.43 62.3,156.68 62.3,164.68 62.79,165.17 62.79,168.62 61.85,169.56 46.94,169.56 41.6,164.23 38.99,164.23 v1(38.95,164.19)
  BOTTOM w0.102: v2(39.37,163.31) 39.37,163.77 v1(38.95,164.19)
USB_OC0_R_N: length 117.4
  TOP w0.102: v1(55.5,45.05) 54.08,43.63 v2(54.08,41.04) 54.08,40.35 59.31,35.12 v1(59.31,24.83) ; UU66.3 76.51,20.17 76.81,19.88 v1(76.81,19.42) ; v1(48.94,86.55) 48.61,86.89 U1.AH36
  IN1 w0.102: v1(59.31,24.83) 59.31,23.18 64.16,18.33 66.29,18.33 66.44,18.18 72.52,18.18 73.13,18.79 76.17,18.79 v1(76.81,19.42)
  IN2 w0.102: v1(54.25,85.49) 53.92,85.49 53.47,85.03 52.45,85.03 52.14,85.03 51.32,85.84 50.06,85.84 49.75,86.15 49.35,86.15 v1(48.94,86.55) ; v1(64.13,77.98) 64.62,77.98 65.87,76.73 65.87,72.16 66.65,71.39 66.65,70.56 66.65,70.56 66.65,70.21 67.3,69.56 67.3,67.67 66.64,67.01 66.64,64.53 64.73,62.62 64.73,57.12 63.66,56.05 61.79,56.05 60.62,54.88 60.62,53.89 59.04,52.32 59.04,47.82 58.71,47.49 57.2,47.49 55.5,45.78 v1(55.5,45.05)
  BOTTOM w0.102: v1(64.13,77.98) 63.73,77.57 63.25,77.57 63.04,77.78 63.04,78.32 62.91,78.45 61.9,78.45 61.2,79.15 SR9.2 61.59,80.14 61.59,83.99 60.46,85.12 60.46,86.93 59.68,87.71 59.17,87.71 58.86,87.4 58.07,87.4 57.47,88 56.12,88 55.68,87.57 55.12,87.57 54.93,87.38 54.93,86.47 SR7858.1 SC146.1 53.64,85.82 53.85,85.61 54.13,85.61 v1(54.25,85.49)
USB_OC1_R_N: length 199.6
  TOP w0.102: v1(47.46,85.57) 47.32,85.57 U1.AL40
  IN1 w0.102: v1(17.21,119.08) 16.32,119.08 15.45,118.21 15.45,117.15 14.12,115.82 14.12,114.03 12.91,112.82 12.91,110.67 13.21,110.38 13.21,106.09 13.65,105.64 13.65,104.67 13.3,104.31 13.3,103.57 13.71,103.16 13.71,100.15 14.05,99.82 14.05,99.09 15.16,97.97 15.16,93.72 17.47,91.4 17.47,88.72 20.74,85.46 20.74,79.4 24.4,75.73 25.61,75.73 26.83,74.51 29.3,74.51 v1(30.48,73.33) 30.48,72.95 30.87,72.56 32.79,72.56 33.49,73.27 34.9,73.27 35.44,72.72 36.37,72.72 37.79,74.15 37.79,74.23 38.36,74.81 41,74.81 41.15,74.96 43.03,74.96 47.16,70.83 48.36,70.83 49.34,71.81 50.62,71.81 54.12,75.31 54.12,78.96 53.74,79.34 53.74,80.62 52.16,82.2 v1(52.16,83.33)
  IN2 w0.102: v1(47.46,85.57) 47.95,85.08 47.95,84.5 48.23,84.21 49.06,84.21 49.69,83.58 51.91,83.58 v1(52.16,83.33) 52.49,83.01 52.49,82.88 53.41,81.96 54.89,81.96 56.41,80.43 58.27,80.43 58.89,79.8 v1(59.12,79.8) ; v1(17.21,119.08) 17.27,119.03 18.21,119.03 18.82,119.63 18.82,119.76 19.78,120.72 20.31,120.72 21.77,122.18 21.77,122.57 23.33,124.13 23.33,126.44 23.41,126.52 23.41,128.64 25.11,130.34 27.31,130.34 28.92,131.95 28.92,132.92 29.47,133.48 30.45,133.48 31.35,134.38 32.48,134.38 33.85,135.75 35.98,135.75 38.43,138.2 38.92,138.2 39.16,138.45 39.88,138.45 43.56,142.13 44.72,142.13 45.43,142.84 46.21,142.84 46.88,143.51 52.15,143.51 52.42,143.25 52.85,143.25 53.2,142.89 54.56,142.89 55.09,143.41 60.21,143.41 60.69,143.89 62.92,143.89 63.02,144 64.35,144 v1(64.68,143.67)
  BOTTOM w0.102: UU19.3 66.04,146.64 65.25,145.85 65.25,144.25 v1(64.68,143.67) ; v1(59.12,79.8) 58.6,80.32 SR23.2 ; v1(30.48,73.33) 30.48,72.83 30.61,72.71 30.61,71.27 30.45,71.11 30.45,68.32 30.14,68 30.14,65.68 26.93,62.47 v2(26.01,62.47) 25.47,61.94 25.47,60.95 25.22,60.69 24.52,60.69 23.24,59.41 21.23,59.41 20.6,58.78 20.6,58.6 SR750.1
USB_OC2_R_N: length 240.2
  TOP w0.102: U1.AJ44 47.27,83.47 47.27,83.82 v1(47.28,83.82) ; v1(63.17,74.98) 63.36,74.79 64.03,74.79 64.51,74.31 SR22.2
  IN1 w0.102: v1(11.48,73.09) 12.14,72.43 14.84,72.43 15.36,71.91 15.63,71.91 16.65,70.88 16.65,67.29 18.32,65.62 19.63,65.62 22.36,62.89 23.21,62.89 v1(24.99,61.11) 24.58,60.7 24.58,60.1 24.82,59.86 27.13,59.86 27.29,60.01 30.96,60.01 31.41,59.56 32.39,59.56 33.28,60.45 36.84,60.45 37.41,59.88 39.77,59.88 40.45,59.2 40.45,58.72 41.17,58 41.47,58 42.47,57 46.7,57 47.09,57.39 48.02,57.39 48.4,57.77 48.4,58.69 49.01,59.3 50.72,59.3 51.33,59.91 52.18,59.91 52.67,60.4 55.43,60.4 56.23,61.2 58.42,61.2 58.75,61.53 60.09,61.53 60.32,61.76 61.76,61.76 62.33,62.33 63.7,62.33 63.99,62.63 v1(63.99,63.99)
  IN2 w0.102: v1(74.27,142.28) 73.81,141.82 71.52,141.82 66.88,137.18 65.25,137.18 64.88,137.54 58.38,137.54 57.43,138.5 55.37,138.5 54.66,137.78 52.93,137.78 52.22,138.5 48.31,138.5 45.77,135.96 43.09,135.96 41.54,134.41 40.16,134.41 37.27,131.51 37.27,130.13 36.37,129.23 36.37,127.89 34.47,125.99 30.13,125.99 29.41,125.27 29.41,123.61 27.13,121.32 27.13,120.28 26.19,119.34 25.69,119.34 23.85,117.5 23.85,116.85 23.29,116.29 22.44,116.29 21.23,115.08 21.23,114.61 20.61,113.99 20.13,113.99 18.4,112.25 18.4,110.18 18.51,110.07 18.51,109.3 17.72,108.52 17.72,104.21 17.23,103.72 16.5,103.72 16.24,103.47 16.24,102.53 15.39,101.68 14.25,101.68 13.64,101.07 13.64,96.35 13.69,96.3 13.69,95.64 13.87,95.46 13.87,93.79 11.7,91.62 11.7,88.21 7.9,84.41 7.9,80.13 11.48,76.55 v1(11.48,73.09) ; v1(47.28,83.82) 47.41,83.69 47.41,83.1 48.78,81.73 49.78,81.73 50.67,80.84 51.99,80.84 52.45,81.3 52.91,81.3 53.07,81.14 53.39,81.14 53.59,80.94 53.59,79.63 54.88,78.34 55.75,78.34 56.65,77.43 57.59,77.43 57.72,77.31 58.53,77.31 60.85,74.98 v1(63.17,74.98) 63.17,74.77 64.45,73.48 64.45,72.29 64.79,71.95 64.79,70.27 64.45,69.92 64.45,67.53 64.45,67.53 64.45,65.69 64.53,65.61 64.53,64.52 v1(63.99,63.99)
  BOTTOM w0.102: v1(24.99,61.11) 24.65,61.11 23.15,59.62 21.06,59.62 20.14,58.7 19.76,58.7 SR751.1 ; v1(74.27,142.28) 74.27,143.02 v2(73.63,143.65) 73.38,143.91 73.38,146.27 75.84,148.72 UU64.3
USB_OC3_R_N: length 260.6
  TOP w0.102: UU22.3 38.64,165.16 v1(38.94,164.86) ; v1(47.33,84.51) 47.3,84.54 U1.AL41
  IN1 w0.102: v1(64.95,65.12) 64.95,63.01 64.07,62.13 62.42,62.13 61.85,61.56 60.41,61.56 60.18,61.33 58.88,61.33 58.55,61 56.31,61 55.51,60.2 52.75,60.2 52.26,59.71 51.42,59.71 51.14,59.43 51.14,59.43 50.81,59.1 49.09,59.1 48.6,58.61 48.6,57.69 48.11,57.19 47.19,57.19 46.8,56.8 42.39,56.8 41.41,57.78 41.11,57.78 39.2,59.68 37.33,59.68 36.75,60.25 33.4,60.25 32.5,59.35 31.24,59.35 30.79,59.81 27.37,59.81 27.22,59.65 24.74,59.65 23.98,60.42 23.98,60.93 23.07,61.84 v1(23.04,61.84) ; v1(56.06,146.04) 56.87,146.04 61.69,141.21 66.11,141.21 70.3,137.03 81.54,137.03 85.57,133 86.38,133 86.7,132.69 86.7,132.31 87.9,131.1 87.92,131.1 v1(88.24,130.79)
  IN2 w0.102: v1(79.88,59.27) 85.65,65.04 85.65,77.36 v1(85.29,77.71) ; v1(64.95,65.12) 64.95,65.7 64.92,65.72 64.92,70.11 65,70.18 65,73.79 v1(63.17,75.62) 62.89,75.34 60.98,75.34 58.81,77.51 57.8,77.51 57.65,77.66 56.71,77.66 55.83,78.54 54.97,78.54 53.81,79.7 53.81,81.16 53.62,81.35 53.15,81.35 53,81.5 52.54,81.5 52.54,81.5 52.37,81.5 51.91,81.04 50.75,81.04 49.86,81.93 49.69,81.93 48.87,81.93 47.83,82.97 47.83,83.86 47.33,84.36 v1(47.33,84.51)
  BOTTOM w0.102: v1(88.24,130.79) 89.14,129.89 89.47,129.89 92.21,127.14 92.21,122.82 93.51,121.52 93.51,119.48 91.85,117.82 91.85,110.63 85.37,104.15 85.37,96.27 87.51,94.12 87.51,90.53 88.39,89.66 88.39,80.17 85.94,77.71 v1(85.29,77.71) ; SR21.2 63.37,75.82 v1(63.17,75.62) ; v1(64.95,65.12) 65.05,65.23 65.61,65.23 65.84,65 68.47,65 72.75,60.72 76.23,60.72 77.68,59.27 v1(79.88,59.27) ; v1(38.94,164.86) 42.78,161.02 44.04,161.02 47.02,158.04 47.02,157.89 49.5,155.4 50.17,155.4 53.17,152.39 53.17,150.37 53.77,149.77 53.77,148.33 v1(56.06,146.04) ; v1(23.04,61.84) 23.95,61.84 v2(24.26,61.53) 24.26,61.08 23.77,60.59 22.38,60.59 21.82,60.04 20.08,60.04 SR752.1
USB_OC4_R_N: length 9
  TOP w0.089: U1.AV47 43.52,80.4 43.55,80.37 43.55,80.16 43.63,80.08 43.63,79.42
  TOP w0.102: 43.63,79.42 43.63,79.05 44.27,78.41 44.27,77.7 44.09,77.52 44.09,77.15 44.42,76.83 45.24,76.83 45.59,76.48 45.59,75.3 45.98,74.91 SR18.2
USB_OC5_R_N: length 3.6
  TOP w0.102: v1(44.04,86.99) 44.3,86.99 U1.AR35
  BOTTOM w0.102: v1(44.04,86.99) 44.5,87.45 44.5,87.8 44.22,88.08 43.74,88.08 43.55,88.27 SR17.2
USB_OC7_R_N: length 31.4
  TOP w0.102: SR20.2 64.01,70.37 63.98,70.35 63.55,70.35 63,70.91 63,71.19 63,71.19 63,71.54 63,71.54 v1(63,72) ; U1.AV43 v1(43.9,83.46)
  IN2 w0.102: v1(63,72) 63,72 63,71.32 62.75,71.07 62.41,71.07 62.4,71.08 62.28,71.08 61.34,72.01 60.46,72.01 57.58,74.89 55.46,74.89 54.36,75.99 52.97,75.99 52.39,76.58 52.39,76.95 52.14,77.19 51.01,77.19 50.03,78.17 48.55,78.17 47.34,79.38 47.34,80.36 46.74,80.95 45.86,80.95 45.29,80.38 45.01,80.38 44.3,81.09 44.3,83.06 v1(43.9,83.46)
  BOTTOM w0.102: v1(43.9,83.46) 44.39,82.97 v2(44.42,82.97)
USB_PN1_F1: length 135.4
  TOP w0.127: v1(59.16,106.37) 58.95,106.57 58.72,106.57 58.14,106 58.14,105.48 57.78,105.12 57.78,104.56 57.78,103.75 57.68,103.64 57.68,103.29 57.55,103.16 U1.J3 ; v1(69.82,20.34) 69.56,20.07 69.56,19.46 69.78,19.24 RN109.1
  IN1 w0.127: v1(59.16,106.37) 59.16,105.93 59.26,105.83 59.56,105.83 59.7,105.97 59.7,106.37 60.01,106.68 60.31,106.68 62.03,104.96 65.97,104.96 68.65,102.28 69.12,102.28 72.68,98.71 72.68,97.69 74.72,95.65 74.72,95.01 75.44,94.29 75.44,89.25 82.38,82.3 82.38,76.1 84.02,74.46 84.02,72.27 86.12,70.17 86.12,66.34 85.04,65.27 84.21,65.27 82.68,63.74 82.68,59.53 86.82,55.39 86.82,53.23 87.12,52.93 87.12,44.8 89.98,41.94 89.98,31.32 91.67,29.64 91.67,28.62 90.05,27.01 90.05,26.44 88.68,25.07 88.68,24.44 88.38,24.13 84.87,24.13 84.65,24.35 77.62,24.35 77.29,24.68 72.37,24.68 70.81,23.13 70.81,19.65 70.46,19.29 69.82,19.29 69.53,19.58 69.53,20.04 v1(69.82,20.34)
USB_PN1_F1_R: length 22.3
  TOP w0.127: v1(70.84,14.67) 71.02,14.49 71.02,13.1 70.49,12.58 70.23,12.58 70.1,12.7 70.1,14.42 69.49,15.03 69.49,16.13 D3302.1 69.49,16.46 69.49,17.31 69.78,17.59 RN109.2
  IN1 w0.127: v1(70.84,14.67) 71.21,15.04 71.32,15.04 71.38,14.98 73.15,14.98 74.7,16.53 77.9,16.53 78.35,16.08 79.31,16.08 79.54,15.86 79.54,14.73 79.27,14.47 78.46,14.47 78.23,14.7 77.93,14.7 77.8,14.57 J133.2
USB_PN2_F2: length 109.2
  TOP w0.127: U1.N13 55.62,98.03 v1(55.17,98.03) ; RN149.1 68.12,19.29 67.92,19.5 67.92,19.86 67.64,20.14 v1(67.64,20.39)
  IN1 w0.127: v1(55.17,98.03) 55.7,97.5 55.7,94.85 56.57,93.98 58.15,93.98 59.67,95.5 59.67,96.04 61.01,97.37 65.38,97.37 68.34,94.41 69.81,94.41 70.74,93.49 70.74,85.61 75,81.34 75,71.47 74.24,70.7 74.24,68.39 72.82,66.97 72.82,63.32 71.27,61.77 71.27,55.46 69.94,54.13 69.94,49.68 67.94,47.69 67.94,42.31 65.86,40.22 65.86,35.15 65.25,34.54 65.25,30.47 61.47,26.68 61.47,23.63 63.79,21.31 67.14,21.31 67.46,20.99 67.46,20.56 v1(67.64,20.39)
USB_PN2_F2_R: length 17.1
  TOP w0.127: RN149.2 68.12,17.49 68.17,17.44 68.17,15.21 67.58,14.62 67.58,13.57 D3302.4 67.59,13.23 67.59,12.94 67.34,12.69 66.66,12.69 66.03,13.32 64.23,13.32 62.94,12.03 59.18,12.03 58.55,12.66 58.55,13.03 J200.2
USB_PN3_B1: length 74.9
  TOP w0.102: U1.K4 57.29,102.89 57.29,103.22 57.06,103.45 57.06,103.9 57.06,103.9 57.06,105.3 57.56,105.8 57.56,106.22
  TOP w0.127: 57.91,109.31 57.91,106.66 57.56,106.3 57.56,106.22 ; 57.91,109.31 v2(58.18,109.31) ; 57.91,109.31 57.91,109.56 58.17,109.82 58.75,109.82 59.31,110.37 59.31,110.74 v1(59.49,110.92) ; v1(52.83,144.71) 53.41,145.3 53.41,150.9 53.97,151.45 53.97,153.51 55.14,154.68 58.72,154.68 60.37,156.32 62.02,157.97 RN95.1
  IN1 w0.127: v1(59.49,110.92) 60.09,111.53 60.09,119.7 59.19,120.6 59.19,121.67 60.97,123.45 60.97,125.3 62.48,126.81 62.48,130.47 60.5,132.45 58.95,132.45 58.53,132.87 58.53,133.98 59.19,134.64 59.19,138.96 58.35,139.8 58.35,141.33 57.11,142.58 55.56,142.58 55.18,142.96 55.17,142.96 53.7,144.43 53.1,144.43 v1(52.83,144.71)
USB_PN3_B1_R: length 27.3
  TOP w0.127: J12.11 71.3,159.45 70.84,159.45 70.28,160.01 70.28,160.57 69.21,161.64 69.21,167.58 66.57,170.22 62.3,170.22 62.01,169.93 62.01,168.48 62.62,167.87 62.62,166.41 D3602.6 62.62,166.05 62.62,165.28 62.2,164.86 62.2,162.47 62.02,162.29 RN95.2
USB_PN4_B2: length 95
  TOP w0.127: U1.M10 56.05,99.87 v1(55.8,100.12) ; v1(52.12,148.66) 52.3,148.83 52.3,149.7 52.55,149.96 52.55,151.12 52.97,151.54 52.97,154.28 54.13,155.44 58.34,155.44 60.68,157.78 60.68,160.54 60.48,160.75 RN89.1
  IN1 w0.127: v1(55.8,100.12) 55.8,100.4 55.52,100.68 55.52,101 55.76,101.24 55.76,101.88 56.22,102.34 56.22,104.06 56.31,104.15 56.31,106.94 55.46,107.79 55.46,109.04 56.22,109.8 56.22,113.1 55.99,113.32 54.18,113.32 52.22,115.28 52.22,122.54 48.78,125.99 43.57,125.99 43.07,126.49 39.76,126.49 39.18,127.07 39.18,127.89 41.25,129.95 41.25,138.05 41.49,138.29 41.49,142.25 40.99,142.74 40.99,146.08 43.33,148.41 46.74,148.41 47.36,147.8 47.36,147.04 47.58,146.81 51.35,146.81 52.16,147.62 52.16,148.62 v1(52.12,148.66)
USB_PN4_B2_R: length 26.7
  TOP w0.127: RN89.2 60.48,162.37 60.67,162.57 60.67,164.59 60.11,165.15 60.11,167.98 60.72,168.59 60.72,168.95 D3602.3 60.72,169.31 60.72,170.16 61.54,170.98 67.05,170.98 71.75,166.28 71.75,162.19 J12.2
USB_PN7_B3: length 69.3
  TOP w0.089: 55.83,104.15 55.83,104.13 56.11,103.85 56.11,103.29 56.49,102.91 U1.L4
  TOP w0.127: 55.83,104.15 55.83,105.25 56.31,105.73 56.31,107.38 56.62,107.69 56.62,111.17 57.03,111.58 57.33,111.88 58.19,111.88 v1(58.49,112.18) ; v1(43.94,146.29) 43.56,145.91 43.03,145.91 42.52,146.42 42.52,148.39 40.85,150.06 40.85,152.48 41.05,152.68 RN80.3
  IN1 w0.127: v1(43.94,146.29) 43.94,145.48 44.31,145.12 44.6,144.82 47.14,144.82 48.59,143.37 52.61,143.37 56.67,139.31 57.37,139.31 58.15,138.53 58.15,135.07 57.49,134.41 57.49,132.43 58.63,131.3 60.13,131.3 61.43,130 61.43,127.33 59.56,125.46 59.56,123.51 58.14,122.09 58.14,116.86 58.69,116.31 58.69,112.37 v1(58.49,112.18)
USB_PN7_B3_R: length 31
  TOP w0.127: J13.6 52.62,157.13 52.45,156.96 51.99,156.96 51.59,157.37 51.33,157.37 51.23,157.27 51.23,156.92 51.72,156.43 52.78,156.43 53.47,157.11 53.47,161.89 52.55,162.8 47.34,162.8 45.95,161.41 42.39,161.41 40.5,159.52 40.5,159.1 D3702.6 40.5,158.74 40.5,157.81 41.11,157.2 41.11,155.2 40.87,154.95 40.87,154.65 41.05,154.47 RN80.4
USB_PN8_B4: length 69.3
  TOP w0.102: U1.G4 58.58,102.92 58.58,103.59 58.52,103.65 58.52,103.9 58.33,104.09 58.33,104.51 58.81,105 58.85,105 58.96,105.11
  TOP w0.127: v1(45.3,147.54) 45.1,147.74 44.46,147.74 43.71,148.49 43.71,149.7 42.4,151.01 42.4,152.51 42.57,152.68 RN86.3 ; 58.96,105.11 60.35,106.5 60.35,108.68 v1(59.97,109.06)
  IN1 w0.127: v1(45.3,147.54) 45.08,147.32 45.08,147.14 46.29,145.93 47.75,145.93 48.19,145.49 53.74,145.49 55.5,143.73 57.29,143.73 59.13,141.89 59.13,140.12 59.97,139.28 59.97,136.79 60.69,136.07 60.69,133.69 62.84,131.54 63.35,131.54 64.34,130.54 64.34,127.36 65.08,126.62 65.08,124.26 61.64,120.82 61.64,120.33 61.64,120.33 61.64,111.32 59.8,109.48 59.8,109.22 v1(59.97,109.06)
USB_PN8_B4_R: length 20.1
  TOP w0.127: RN86.4 42.57,154.5 42.4,154.67 42.4,155.84 D3702.3 42.4,156.2 42.4,157.12 43.01,157.73 43.01,160.27 43.39,160.64 46.45,160.64 47.85,162.04 48.51,162.04 49.25,161.3 49.25,159.65 49.78,159.12 51.13,159.12 51.75,159.74 51.75,160.57 51.87,160.7 J13.2
USB_PN14_M.2_BT: length 120.4
  TOP w0.127: L8.1 31.32,54.56 v1(30.75,53.98) ; U1.E5 60,102.08 v1(60.15,101.94)
  IN2 w0.127: v1(60.15,101.94) 60.15,101.77 60.4,101.51 60.4,101.21 60.4,100.79 62.33,98.86 65.44,98.86 67.53,96.76 68.3,96.76 72.55,92.51 72.55,91.39 73.4,90.54 73.4,90.19 79.07,84.52 79.07,80.88 79.39,80.56 79.39,71.07 80.45,70 80.45,68.69 79.84,68.08 79.84,64.49 79.35,64 79.35,63.78 76.62,61.05 71.02,61.05 70.25,60.29 67.94,60.29 67.11,59.46 67.11,59.1 67.68,58.52 67.68,56.85 66.52,55.69 65.57,55.69 65.14,55.26 65.14,54.04 63.21,52.11 62.73,52.11 61.92,51.3 61.31,51.3 60.73,50.71 60.73,47.49 59.76,46.52 57.6,46.52 56.73,45.65 56.73,44.56 55.37,43.2 53.96,43.2 53.58,42.81 52.48,42.81 52.13,43.17 48.47,43.17 47.76,43.88 47.17,43.88 42.99,48.06 41.89,48.06 41.24,48.72 39.39,48.72 38.88,49.23 38.3,49.23 37.61,49.92 36.4,49.92 35.38,50.93 33.35,50.93 32.62,51.67 31.31,51.67 29.97,53.01 29.97,53.5 30.27,53.8 30.57,53.8 v1(30.75,53.98)
USB_PN14_M.2_BT_R: length 9.7
  TOP w0.127: J218.5 35.7,58.98 35.45,58.74 35.45,56.02 35.03,55.59 34.03,55.59 32.18,57.44 31.42,57.44 31.29,57.32 31.29,57.06 31.32,57.03 L8.2
USB_PP1_F1: length 135.4
  TOP w0.127: v1(59.66,106.95) 58.74,106.95 57.89,106.1 57.89,105.58 57.53,105.22 57.53,104.56 57.53,103.85 57.4,103.72 U1.J2 ; v1(69.06,20.36) 69.31,20.12 69.31,19.46 69.13,19.28 RN109.3
  IN1 w0.127: v1(59.66,106.95) 60.42,106.95 62.14,105.23 66.08,105.23 68.77,102.54 69.23,102.54 72.95,98.82 72.95,97.8 74.99,95.77 74.99,95.12 75.7,94.4 75.7,89.36 82.65,82.41 82.65,76.21 84.29,74.57 84.29,72.38 86.38,70.28 86.38,66.23 85.15,65 84.32,65 82.94,63.63 82.94,59.64 87.08,55.5 87.08,53.34 87.38,53.04 87.38,44.91 90.24,42.05 90.24,31.44 91.93,29.75 91.93,28.51 90.32,26.9 90.32,26.33 88.95,24.96 88.95,24.33 88.49,23.87 84.76,23.87 84.54,24.08 77.51,24.08 77.18,24.41 72.48,24.41 71.08,23.01 71.08,19.54 70.57,19.03 69.71,19.03 69.26,19.47 69.26,20.16 v1(69.06,20.36)
USB_PP1_F1_R: length 22.3
  TOP w0.127: RN109.4 69.13,17.52 69.24,17.41 69.24,14.92 69.85,14.31 69.85,13.59 D3302.6 69.85,13.21 69.85,12.6 70.12,12.32 70.6,12.32 71.27,12.99 71.27,14.87 v1(70.84,15.31)
  IN1 w0.127: J133.3 79.8,13.78 79.8,15.97 79.42,16.35 78.46,16.35 78.01,16.79 74.59,16.79 73.04,15.24 71.49,15.24 71.43,15.31 v1(70.84,15.31)
USB_PP2_F2: length 109.1
  TOP w0.127: U1.N15 55.72,97.52 55.59,97.65 55.38,97.65 55.17,97.43 v1(55.17,97.26) ; v1(66.88,20.41) 67.28,20.01 67.41,20.01 67.66,19.75 67.66,19.5 67.47,19.31 RN149.3
  IN1 w0.127: v1(55.17,97.26) 55.43,96.99 55.43,94.74 56.46,93.72 58.26,93.72 59.37,94.82 59.94,95.39 59.94,95.93 61.12,97.11 65.27,97.11 68.23,94.15 69.7,94.15 70.47,93.38 70.47,85.49 74.74,81.23 74.74,71.58 73.98,70.81 73.98,68.5 72.55,67.08 72.55,63.43 71,61.88 71,55.57 69.67,54.24 69.67,49.8 67.68,47.8 67.68,42.42 65.59,40.33 65.59,35.26 64.98,34.65 64.98,30.58 61.2,26.8 61.2,23.52 63.68,21.05 67.03,21.05 67.19,20.88 67.19,20.73 v1(66.88,20.41)
USB_PP2_F2_R: length 17.1
  TOP w0.127: J200.3 59,13.78 58.8,13.58 58.8,12.77 59.29,12.28 62.83,12.28 64.12,13.57 66.14,13.57 66.76,12.94 67.21,12.94 67.33,13.06 67.33,14.72 67.92,15.31 67.92,16.13 D3302.3 67.92,16.46 67.92,17.32 67.83,17.41 67.59,17.41 67.47,17.53 RN149.4
