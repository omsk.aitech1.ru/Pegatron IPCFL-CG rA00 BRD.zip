# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CATERR_LED_E: length 19.2
  TOP w0.102: CR4.1 167.17,31.59 168.17,31.59 168.45,31.87 168.45,34.72 168.28,34.9 168.07,34.9 167.19,35.78 167.19,36.39 168.27,37.46 Q9346.3 168.27,39.44 168,39.7 R4818.2 166.69,40.79 v1(165.82,41.66)
  BOTTOM w0.102: v1(165.82,41.66) 165.51,41.97 162.4,41.97 v2(162.05,41.62)
CBN: length 5.4
  TOP w0.203: U6.35 19.69,18.67 19.89,18.47 20.68,18.47 20.85,18.3 20.85,18.1 20.93,18.02 21.66,18.02 22.02,17.67 v1(22.04,17.67)
  TOP w0.254: AC14.2 22.69,18.34 22.04,17.69 v1(22.04,17.67)
  BOTTOM w0.254: v2(21.31,17.21) 21.77,17.67 v1(22.04,17.67)
CBP: length 4.6
  TOP w0.203: U6.37 20.89,19.64 21.13,19.4
  TOP w0.254: v1(22.02,18.63) 21.97,18.68 AC14.1 21.35,19.18 21.13,19.4
  BOTTOM w0.203: v1(22.02,18.63) 22.02,18.32 21.73,18.03 20.54,18.03 v2(20.08,18.49)
CFG_RCOMP_W8S6L200MIL: length 4.9
  TOP w0.203: HR57.1 114.2,119.58 v1(114.03,119.74) 114.03,119.77 XU1.M11
  BOTTOM w0.127: v2(114.58,118.02) 114.4,118.2 114.4,119.38 v1(114.03,119.74)
CHA_DIMM0_EVENT#: length 3.4
  TOP w0.102: v1(124.44,59.74) 124.62,59.92 DIMM2.134
  BOTTOM w0.102: v2(123.54,60.64) 123.92,60.64 123.95,60.66 D4R2.2 124.57,59.87 v1(124.44,59.74)
CHAR_EN: length 25.3
  TOP w0.102: v1(52.83,79.02) 52.49,78.68 51.6,78.68 50.98,79.3 50.98,80.74 51.2,80.97 51.57,80.97 51.74,81.13 51.74,81.19 U1.Y47
  IN2 w0.102: v1(63.47,69.85) 64.15,70.52 64.15,71.45 63.84,71.76 63.84,73.01 62.64,74.21 59.78,74.21 58.08,75.91 55.92,75.91 53.9,77.93 53.9,78.6 53.48,79.02 v1(52.83,79.02)
  BOTTOM w0.102: v1(63.47,69.85) 63.03,70.3 v2(62.76,70.3) 62.51,70.55 SR117.1
CHB_DIMM0_EVENT#: length 6
  TOP w0.102: DIMM1.134 124.63,50.44 124.46,50.61 124.46,52.34 v1(123.98,52.82)
  BOTTOM w0.102: v2(124.39,53.65) 124.39,53.23 v1(123.98,52.82) 124.29,52.5 D4R14.2
CK_14M_SIO: length 60.4
  IN1 w0.127: v1(29.11,101.36) 29.42,101.36 29.86,100.93 30.05,100.93 30.3,100.68 30.85,100.68 31.02,100.51 31.02,100.33 30.63,99.94 30.63,99.74 30.78,99.58 30.99,99.58 31.35,99.95 31.53,99.95 31.8,99.68 31.8,98.41 32.13,98.08 32.38,98.08 32.55,97.92 32.55,97.74 32.38,97.58 32.03,97.58 31.91,97.46 31.91,97.18 32.03,97.07 32.49,97.07 32.66,96.89 32.66,95.47 32.79,95.34 33.15,95.34 33.27,95.21 33.27,92.92 34.15,92.04 34.47,92.04 34.77,91.73 34.77,91.42 35.06,91.13 35.38,91.13 36.18,90.32 36.18,89.47 36.05,89.35 35,89.35 34.65,89.7 34.47,89.7 34.11,89.35 33.91,89.35 33.65,89.6 33.65,89.78 34,90.12 34,90.3 33.15,91.15 32.94,91.15 32.51,90.71 32.51,89.65 32.07,89.21 32.07,88.68 32.21,88.55 32.21,87.65 32.84,87.01 32.84,85.61 33.73,84.72 34.23,84.72 34.51,84.44 34.8,84.44 34.95,84.6 34.95,85.18 34.74,85.38 33.91,85.38 33.64,85.65 33.64,85.91 33.78,86.05 34.27,86.05 34.42,86.2 34.42,86.53 34.27,86.68 33.98,86.68 33.83,86.83 33.83,87.24 34.09,87.49 34.95,87.49 35.1,87.65 35.1,87.98 34.95,88.13 32.89,88.13 32.74,88.28 32.74,88.97 32.92,89.14 33.32,89.14 33.7,88.76 35.71,88.76 35.89,88.59 35.89,87.48 v1(36.13,87.24)
  BOTTOM w0.127: v1(29.11,101.36) 28.86,101.61 28.68,101.61 28.33,101.26 27.39,101.26 27.27,101.39 SCB68.1 26.87,101.77 26.69,101.59 26.69,101.05 26.52,100.88 26.29,100.88 26.14,101.03 26.14,101.73 25.98,101.89 v2(25.71,101.89) 25.53,101.7 25.53,100.91 25.37,100.76 U104.16 ; v1(36.13,87.24) 36.47,87.24 36.88,86.83 36.88,86.33 37.54,85.68 38.57,85.68 SC73.1 39.61,86.27 39.65,86.31 SR24.1
CK_24M_SIO: length 11.4
  BOTTOM w0.127: R637.1 32.27,87.47 32.27,87.63 SR19.1 31.62,87.59 31.41,87.59 30.87,87.06 v2(30.35,87.06) 30.35,88.03 29.67,88.71 29.44,88.71 29.08,88.36 28.81,88.36 28.38,88.79 28.38,89.08 28.53,89.24 30,89.24 30.5,88.74 31.17,88.74 ECR103.2
CK_100M_PCIE1_WLAN: length 102.3
  TOP w0.127: U1.AH10 48.19,99.56 48.19,99.31 48.32,99.18 48.62,99.18 v1(48.84,99.41) ; J218.47 46.2,59.12 46.07,58.99 46.07,58.72 46.2,58.59 v1(46.39,58.59)
  IN2 w0.127: v1(48.84,99.41) 48.84,99.12 48.64,98.92 48.37,98.92 48.17,99.12 48.17,99.55 48.41,99.79 48.41,100.5 47.69,101.22 47.69,103.08 47.45,103.33 46.19,103.33 45.41,104.1 45.23,104.1 44.71,103.59 44.71,103.41 45.11,103.02 45.11,102.61 44.69,102.2 44.69,101.1 44.18,100.59 44.18,99.95 43.72,99.5 43.72,99.31 44.47,98.56 44.47,98.02 43.8,97.35 43.36,97.35 43.08,97.63 43.08,98.14 42.85,98.37 42.62,98.37 42.02,97.77 41.61,97.77 41.3,98.07 40.88,98.07 40.55,98.4 39.57,98.4 39.1,97.93 39.1,97.54 39.28,97.36 40.79,97.36 41.3,96.86 41.3,96.03 40.7,95.43 40.7,93.86 40.01,93.16 39.54,93.16 39.01,93.69 39.01,95.98 38.85,96.15 36.74,96.15 36.48,95.89 36.48,95.18 36.93,94.73 36.93,94.05 36.48,93.6 36.48,92.39 37.15,91.73 37.15,90.53 36.83,90.21 36.83,88.56 36.56,88.29 36.56,87.87 36.74,87.7 37.43,87.7 37.71,87.41 37.71,86.95 37.43,86.67 37.12,86.67 36.92,86.47 36.92,85.81 36.74,85.63 36.58,85.47 35.85,85.47 35.8,85.42 34.75,84.37 34.75,83.42 35.75,82.42 35.75,80.28 36.37,79.66 36.37,79.16 35.53,78.32 35.53,77.02 35.11,76.6 35.11,76 35.35,75.76 36.04,75.76 36.61,75.19 36.61,74.55 36.04,73.98 35.62,73.98 35.52,73.88 35.52,72.54 36.16,71.9 37.68,71.9 38.09,71.48 38.09,69.32 38.52,68.89 38.52,66.9 38.78,66.64 38.78,64.27 40.41,62.65 42.04,62.65 42.72,63.34 43.48,63.34 44.17,62.65 44.62,62.65 45.17,63.2 45.58,63.2 46.4,62.38 46.4,61.83 46.12,61.55 44.94,61.55 44.83,61.44 44.83,61.12 44.91,61.04 46.98,61.04 47.24,60.77 47.24,60.04 46.88,59.67 46.34,59.67 46.01,60 43.82,60 43.62,59.8 43.62,59.43 43.78,59.27 44,59.27 44.21,59.49 45.68,59.49 46.09,59.08 46.09,58.72 46.22,58.59 v1(46.39,58.59)
CK_100M_PCIE1_WLAN#: length 102.4
  TOP w0.127: J218.49 46.7,58.93 46.82,58.81 46.82,58.37 v1(46.28,57.83) ; U1.AH9 48.51,100.37 v1(48.84,100.04)
  IN2 w0.127: v1(48.84,100.04) 48.68,100.21 48.68,100.61 47.96,101.33 47.96,103.19 47.56,103.59 46.3,103.59 45.52,104.37 45.12,104.37 44.45,103.7 44.45,103.3 44.84,102.91 44.84,102.73 44.42,102.31 44.42,101.21 43.92,100.7 43.92,100.07 43.46,99.61 43.46,99.2 44.21,98.45 44.21,98.13 43.69,97.61 43.47,97.61 43.34,97.74 43.34,98.25 42.96,98.63 42.51,98.63 41.91,98.03 41.72,98.03 41.41,98.34 40.99,98.34 40.66,98.67 39.46,98.67 38.83,98.04 38.83,97.43 39.17,97.09 40.68,97.09 41.03,96.74 41.03,96.14 40.44,95.54 40.44,93.97 39.89,93.43 39.65,93.43 39.28,93.8 39.28,96.09 38.96,96.41 36.63,96.41 36.22,96 36.22,95.07 36.66,94.62 36.66,94.16 36.22,93.71 36.22,92.28 36.88,91.62 36.88,90.64 36.56,90.33 36.56,88.67 36.3,88.4 36.3,87.76 36.63,87.43 37.32,87.43 37.45,87.3 37.45,87.06 37.32,86.93 37.01,86.93 36.65,86.58 36.65,85.92 36.47,85.74 35.74,85.74 35.53,85.53 35.1,85.1 35.1,85.1 34.49,84.48 34.49,83.31 35.48,82.31 35.48,80.17 36.1,79.55 36.1,79.27 35.27,78.43 35.27,77.13 34.85,76.71 34.85,75.88 35.24,75.49 35.93,75.49 36.35,75.08 36.35,74.66 35.93,74.25 35.51,74.25 35.25,73.99 35.25,72.43 36.05,71.63 37.57,71.63 37.82,71.37 37.82,69.21 38.25,68.78 38.25,66.79 38.52,66.53 38.52,64.16 40.3,62.38 42.15,62.38 42.83,63.07 43.37,63.07 44.06,62.38 44.73,62.38 45.28,62.94 45.47,62.94 46.14,62.27 46.14,61.94 46.01,61.81 44.83,61.81 44.57,61.55 44.57,61.01 44.8,60.77 46.87,60.77 46.98,60.66 46.98,60.15 46.77,59.94 46.45,59.94 46.12,60.26 43.71,60.26 43.36,59.91 43.36,59.32 43.67,59.01 44.11,59.01 44.32,59.22 45.57,59.22 45.82,58.97 45.82,58.55 46.28,58.1 v1(46.28,57.83)
CK_100M_PCIE2_LAN: length 102.2
  TOP w0.127: U1.AE15 49.7,97.57 49.82,97.7 v1(50.16,97.7)
  IN1 w0.127: v1(50.16,97.7) 50.35,97.89 50.63,97.89 50.95,98.21 50.95,98.69 51.17,98.91 51.17,101.19 50.96,101.4 50.96,102.92 49.53,104.35 49.53,105.88 49.29,106.12 49.29,107.93 47.88,109.34 47.88,112.27 48.12,112.52 48.12,117.28 48.25,117.41 48.57,117.41 48.86,117.69 48.86,118.29 48.57,118.57 48.25,118.57 48.12,118.7 48.12,119.08 48.25,119.21 48.57,119.21 48.86,119.49 48.86,120.09 48.57,120.38 48.25,120.38 48.12,120.5 48.12,121.09 48.84,121.81 48.84,122.42 48.23,123.03 40.28,123.03 39.78,123.53 38.54,123.53 36.23,125.84 36.23,129.12 37.65,130.55 37.65,132.71 37.36,133 36.5,133 36.37,133.12 36.37,133.37 36.51,133.51 37.37,133.51 37.65,133.79 37.65,134.19 37.1,134.75 37.1,135.92 37.25,136.08 37.25,136.67 36.59,137.34 36.59,138.36 37.25,139.02 37.25,140.23 36.97,140.52 36.6,140.52 36.46,140.66 36.46,140.92 36.7,141.16 37.37,141.16 37.65,141.45 37.65,142.94 38.15,143.43 38.15,145.99 37.72,146.42 36.07,146.42 33.53,143.88 31.67,143.88 30.82,143.03 29.65,143.03 28.65,144.03 26.69,144.03 26.34,143.68 26.34,142.34 26.21,142.22 24.25,142.22 23.04,141.01 22.15,141.01 21.84,140.71 21.84,139.89 21.58,139.63 21.04,139.63 20.59,140.07 19.34,140.07 19.21,140.2 19.21,141.13 18.93,141.42 17.85,141.42 17.55,141.11 17.55,140.06 16.97,139.49 15.84,139.49 15.71,139.61 15.71,140.24 15.8,140.33 15.94,140.33 v1(16.23,140.05)
  BOTTOM w0.127: U114.15 16.96,139.29 16.23,140.02 v1(16.23,140.05)
CK_100M_PCIE2_LAN#: length 102.3
  TOP w0.127: U1.AE14 50.15,98.47 v1(50.16,98.47)
  IN1 w0.127: v1(50.16,98.47) 50.16,98.29 50.29,98.16 50.52,98.16 50.68,98.32 50.68,98.8 50.9,99.02 50.9,101.08 50.7,101.29 50.7,102.81 49.26,104.24 49.26,105.77 49.02,106.01 49.02,107.82 47.61,109.23 47.61,112.39 47.85,112.63 47.85,117.39 48.14,117.67 48.46,117.67 48.59,117.8 48.59,118.18 48.46,118.31 48.14,118.31 47.85,118.59 47.85,119.19 48.14,119.48 48.46,119.48 48.59,119.6 48.59,119.98 48.46,120.11 48.14,120.11 47.85,120.39 47.85,121.2 48.58,121.92 48.58,122.31 48.12,122.76 40.17,122.76 39.67,123.26 38.43,123.26 35.96,125.73 35.96,129.23 37.39,130.66 37.39,132.59 37.25,132.73 36.39,132.73 36.1,133.01 36.1,133.48 36.4,133.77 37.26,133.77 37.39,133.9 37.39,134.08 36.83,134.64 36.83,136.03 36.98,136.19 36.98,136.56 36.32,137.23 36.32,138.47 36.98,139.13 36.98,140.12 36.86,140.25 36.49,140.25 36.19,140.55 36.19,141.03 36.59,141.43 37.26,141.43 37.39,141.56 37.39,143.05 37.88,143.54 37.88,145.88 37.61,146.15 36.18,146.15 33.64,143.61 31.78,143.61 30.93,142.76 29.54,142.76 28.54,143.77 26.8,143.77 26.6,143.57 26.6,142.23 26.32,141.95 24.36,141.95 23.15,140.74 22.26,140.74 22.11,140.6 22.11,139.78 21.69,139.36 20.93,139.36 20.48,139.8 19.23,139.8 18.94,140.09 18.94,141.02 18.82,141.15 17.97,141.15 17.81,141 17.81,139.95 17.08,139.22 15.72,139.22 15.44,139.5 15.44,140.35 15.69,140.6 16.12,140.6 v1(16.2,140.68)
  BOTTOM w0.127: U114.16 16.92,139.69 16.74,139.87 16.74,140.15 16.21,140.68 v1(16.2,140.68)
CK_100M_PCIE3_SSD: length 101.7
  TOP w0.127: U1.AE7 49.97,101.34 v1(50.26,101.34) ; v1(29.87,123.71) 29.54,124.04 29.06,124.04 28.93,123.92 28.93,123 28.64,122.71 25.09,122.71 23.2,120.83 23.2,118.1 22.93,117.82 21.79,117.82 21.51,118.1 21.51,118.73 21.77,118.99 22.06,118.99 22.19,119.12 22.19,119.48 22.06,119.61 20.98,119.61 20.7,119.89 20.7,120.35 20.98,120.63 22,120.63 22.12,120.75 22.12,122.45 22,122.58 21.74,122.58 21.62,122.45 21.62,121.66 21.13,121.18 20.12,121.18 20.01,121.07 20.01,120.89 19.74,120.61 19.27,120.61 19,120.89 19,122.68 19.48,123.15 19.48,123.49 18.9,124.07 18.9,125.73 18.55,126.08 18.22,126.08 17.98,125.83 17.98,123.61 17.52,123.15 17.52,121.68 16.91,121.07 16.91,120.82 16.69,120.59 16.69,119.39 16.78,119.3 16.78,118.24 17.19,117.82 J219.55
  IN1 w0.127: v1(50.26,101.34) 49.93,101.34 49.55,101.72 49.55,102.81 49.15,103.22 48.62,103.22 47.99,103.84 47.99,106.13 47.82,106.3 47.82,107.87 46.71,108.98 45.81,108.98 45.53,109.26 45.53,110.09 45.4,110.21 44.75,110.21 44.51,109.97 44.51,109.33 44.23,109.04 42.11,109.04 41.61,109.55 41.61,109.91 39.9,111.62 39.09,111.62 38.57,112.14 35.48,112.14 35.17,112.45 35.17,116.15 33.76,117.57 33.76,118.39 34.01,118.65 35.06,118.65 35.17,118.76 35.17,119.25 35.06,119.36 34.1,119.36 33.76,119.7 33.76,120.61 34.09,120.95 36.71,120.95 36.84,121.07 36.84,121.28 36.66,121.46 33.73,121.46 33.31,121.87 33.31,124.05 34.09,124.83 34.09,125.55 33.89,125.75 33.27,125.75 33.07,125.55 33.07,124.75 32.84,124.52 32.39,124.52 32.02,124.89 32.02,125.55 31.9,125.68 31.09,125.68 30.78,125.37 30.78,125.2 31.67,124.31 31.67,122.72 31.44,122.49 30.92,122.49 30.63,122.78 30.63,123.8 30.5,123.93 30.08,123.93 v1(29.87,123.71)
CK_100M_PCIE3_SSD#: length 102
  TOP w0.127: U1.AE6 49.87,101.99 v1(50.24,101.99) ; 17.73,124.2 17.73,123.72 17.27,123.26 17.27,121.79 16.66,121.18 16.66,120.92 16.43,120.69 16.43,119.29 16.53,119.2 16.53,118.13 16.94,117.72 16.94,116.98 16.69,116.74 J219.53 ; 17.73,124.2 v2(17.35,124.2) ; 17.73,124.2 17.73,125.94 18.12,126.33 18.66,126.33 19.15,125.84 19.15,124.17 19.73,123.59 19.73,123.05 19.25,122.57 19.25,121 19.38,120.87 19.63,120.87 19.76,121 19.76,121.18 20.01,121.43 21.02,121.43 21.36,121.77 21.36,122.56 21.64,122.83 22.1,122.83 22.38,122.56 22.38,120.65 22.1,120.37 21.08,120.37 20.95,120.25 20.95,119.99 21.08,119.87 22.16,119.87 22.44,119.59 22.44,119.01 22.16,118.73 21.87,118.73 21.77,118.63 21.77,118.2 21.89,118.07 22.82,118.07 22.95,118.2 22.95,120.94 24.98,122.97 28.54,122.97 28.68,123.11 28.68,124.02 28.95,124.3 29.69,124.3 v1(29.87,124.48)
  IN1 w0.127: v1(50.24,101.99) 49.83,102.4 49.83,102.91 49.26,103.48 48.73,103.48 48.26,103.95 48.26,106.24 48.08,106.41 48.08,107.98 46.82,109.24 45.92,109.24 45.79,109.37 45.79,110.2 45.51,110.48 44.64,110.48 44.25,110.08 44.25,109.44 44.12,109.31 42.23,109.31 41.88,109.66 41.88,110.02 40.01,111.89 39.2,111.89 38.68,112.41 35.59,112.41 35.44,112.56 35.44,116.26 34.02,117.68 34.02,118.28 34.12,118.38 35.17,118.38 35.44,118.65 35.44,119.36 35.17,119.62 34.21,119.62 34.02,119.81 34.02,120.5 34.2,120.68 36.82,120.68 37.1,120.96 37.1,121.39 36.78,121.72 33.84,121.72 33.58,121.98 33.58,123.94 34.36,124.72 34.36,125.66 34,126.02 33.16,126.02 32.8,125.66 32.8,124.86 32.73,124.79 32.5,124.79 32.29,125 32.29,125.66 32.01,125.94 30.98,125.94 30.52,125.48 30.52,125.09 31.41,124.2 31.41,122.84 31.33,122.76 31.03,122.76 30.9,122.89 30.9,123.91 30.61,124.2 30.15,124.2 v1(29.87,124.48)
CK_PCIE_N5: length 5.5
  TOP w0.102: U1.AB2 51.15,103.95 51.15,104.56 51.33,104.74 51.33,105.37 52.11,106.15 52.11,106.56 50.65,108.02 ST24.1
CK_PCIE_P5: length 1.4
  TOP w0.102: U1.AB3 51.47,102.59 v1(51.43,102.56)
  BOTTOM w0.102: v1(51.43,102.56) 51.41,102.56 51.28,102.43 ST25.1
CL_CLK: length 112.4
  TOP w0.089: U1.AR2 44.69,103.8 44.82,103.94 44.82,104.56 44.63,104.74 44.63,105.42 44.37,105.68
  TOP w0.127: APR29.1 45.92,46.9 45.92,45.42 44.48,43.98 43.55,43.98 42.9,43.33 v2(41.78,43.33) 41.48,43.64 41.48,45.53 v1(42.01,46.07) ; 44.37,105.68 44.37,105.93 v1(44.18,106.12)
  IN2 w0.127: v1(44.18,106.12) 44.18,106.75 43.04,107.89 42.77,107.89 41.82,108.83 40.8,108.83 39.39,110.24 38.55,110.24 38,110.79 33.74,110.79 32.44,109.49 32.18,109.49 30.6,107.91 29.77,107.91 27.65,105.78 26.74,105.78 26.19,105.23 26.19,105.02 26.19,105.02 26.19,104.62 25.72,104.16 24.86,104.16 24.43,103.73 24.43,101.36 23.27,100.2 23.27,98.42 22.69,97.84 22.69,94.3 20.88,92.49 20.88,89.29 20.88,89.28 20.88,88.93 20.88,88.93 20.88,86.79 21.55,86.12 21.55,78.22 20.86,77.53 20.86,74.63 21.52,73.97 21.52,72.83 21.4,72.7 21.4,63.97 22.07,63.3 22.07,60.82 21.92,60.67 21.92,59.67 22.82,58.77 23.05,58.77 25.73,56.08 25.73,53.38 29.02,50.09 32.14,50.09 32.75,49.49 34.78,49.49 36.32,47.95 38.38,47.95 38.72,47.61 40.45,47.61 42,46.07 v1(42.01,46.07)
CL_CLK_R: length 4.9
  TOP w0.127: APR29.2 45.48,48.54 v2(44.73,49.29) 44.25,49.77 44.25,50.51 44.95,51.22 J218.42
CL_DATA: length 110.8
  TOP w0.089: U1.AT5 44.28,102.62 44.43,102.77 44.43,103.85 44.63,104.05 44.63,104.48 44.42,104.68 44.42,105.26
  TOP w0.127: APR30.1 44.56,44.78 v2(44.35,44.57) 44.02,44.24 42.61,44.24 42.11,44.74 42.11,45.33 42.44,45.66 42.44,46.5 v1(42.31,46.62) ; v1(43.58,106.39) 43.58,106.1 44.42,105.26
  IN2 w0.127: v1(43.58,106.39) 43.58,106.99 42.94,107.63 42.66,107.63 41.72,108.57 40.69,108.57 39.28,109.98 38.45,109.98 37.89,110.54 34.45,110.54 32.54,108.63 31.82,108.63 30.85,107.65 29.88,107.65 27.75,105.53 26.84,105.53 26.44,105.13 26.44,104.51 25.83,103.9 24.97,103.9 24.69,103.62 24.69,101.26 23.53,100.1 23.53,98.32 22.94,97.73 22.94,94.2 21.13,92.38 21.13,89.39 21.13,89.39 21.13,88.82 21.13,88.82 21.13,86.89 21.8,86.22 21.8,77.59 21.12,76.91 21.12,75.07 21.79,74.39 21.79,72.74 21.65,72.6 21.65,64.08 22.32,63.41 22.32,63.2 22.32,60.71 22.17,60.57 22.17,59.78 22.93,59.02 24.35,59.02 25.53,57.84 25.53,56.65 25.98,56.19 25.98,53.53 29.17,50.35 32.25,50.35 32.85,49.74 34.89,49.74 36.43,48.2 38.49,48.2 38.82,47.87 40.56,47.87 41.8,46.62 v1(42.31,46.62)
CL_DATA_R: length 7.3
  TOP w0.127: J218.40 44.45,51.08 43.99,50.62 43.99,49.31 44.56,48.74 APR30.2 44.89,48.19 45.03,48.05 45.03,46.92 44.99,46.88 44.99,46.41 v2(45.41,45.99)
CL_RST#: length 103.5
  TOP w0.089: U1.AU4 44.14,102.76 44.25,102.87 44.25,103.94 44.44,104.13 44.44,104.4 44.23,104.6 44.23,104.84 43.99,105.08
  TOP w0.127: v1(43.86,105.22) 43.99,105.08 ; APR31.1 43.3,47.02 43.3,47.02 v1(42.98,46.7) 42.98,45.31 v2(42.62,44.95)
  IN2 w0.127: v1(43.86,105.22) 43.86,105.45 43.15,106.16 43.15,106.59 43.21,106.64 43.21,107 42.83,107.38 42.56,107.38 41.61,108.32 40.59,108.32 39.18,109.73 38.34,109.73 37.79,110.28 34.56,110.28 32.64,108.37 32.19,108.37 31.84,108.02 31.84,107.96 30.67,106.79 29.38,106.79 27.86,105.27 26.96,105.27 26.69,105.01 26.69,104.38 25.3,102.99 25.3,102.98 25,102.68 25,101.2 23.78,99.99 23.78,98.21 23.2,97.63 23.2,94.09 21.38,92.28 21.38,89.5 21.39,89.5 21.39,88.72 21.38,88.71 21.38,87 22.06,86.33 22.06,76.59 22.27,76.37 22.27,75.93 21.98,75.64 21.98,75.16 22.05,75.1 22.05,72.62 21.91,72.48 21.91,64.18 22.58,63.51 22.58,63.09 22.58,60.61 22.43,60.46 22.43,59.88 23.04,59.27 24.45,59.27 25.78,57.95 25.78,56.75 26.24,56.29 26.24,55.24 27.97,53.51 28.14,53.51 31.05,50.6 32.35,50.6 32.96,50 34.99,50 36.54,48.45 38.59,48.45 38.93,48.12 40.66,48.12 41.73,47.06 42.63,47.06 v1(42.98,46.7)
CL_RST#_R: length 6.5
  TOP w0.127: J218.38 43.95,50.94 43.74,50.72 43.74,49.8 43.64,49.7 APR31.2 43.95,48.19 44.12,48.02 44.12,46.85 v2(43.74,46.47)
CL_SENSE: length 19.8
  TOP w0.102: v1(64.04,80.08) 64.31,80.08 64.82,79.57 64.82,77.76 65.21,77.37 SR104.2 ; U1.T46 54.29,82.39 54.37,82.46 54.37,82.84 54.2,83 54.2,83.28 54.67,83.75 v1(55.24,83.75)
  IN2 w0.102: v1(64.04,80.08) 63.47,80.64 63.47,81.1 62.8,81.78 62.59,81.78 60.49,83.88 59.79,83.88 59.13,83.23 57.48,83.23 57.22,83.48 57.22,83.71 56.77,84.17 55.66,84.17 v1(55.24,83.75)
  BOTTOM w0.102: v2(65.84,79.01) 65.11,79.01 v1(64.04,80.08)
CLK_24M_NSSC_CPU: length 102.6
  TOP w0.102: 61.97,101.15 61.44,101.15 61.44,101.16 61.3,101.16 61.25,101.21 60.55,101.21 60.4,101.36 U1.D7
  TOP w0.127: v1(111.32,121.59) XU1.K9 ; 61.97,101.15 62.89,101.15 63.35,101.62 63.58,101.84 v1(63.73,101.84)
  IN2 w0.127: v1(111.32,121.59) 111.64,121.59 111.75,121.48 111.75,121.24 111.66,121.15 111,121.15 109.74,119.89 109.18,119.89 108.78,120.3 108.78,121.64 108.65,121.77 101.7,121.77 101.42,122.05 101.42,123.21 101.3,123.33 100.89,123.33 100.76,123.2 100.76,122.17 100.48,121.88 94.68,121.88 94.55,121.76 94.55,121.11 94.26,120.83 92.7,120.83 92.5,120.64 92.5,120.26 92.63,120.13 93.74,120.13 94.02,119.85 94.02,119.13 93.74,118.85 92.87,118.85 92.71,118.68 92.71,117.77 92.43,117.49 90.74,117.49 90.46,117.77 90.46,120.82 90.31,120.97 90.08,120.97 89.95,120.84 89.95,117.77 89.67,117.49 89.19,117.49 88.91,117.77 88.91,120.12 88.78,120.25 88.54,120.25 88.4,120.11 88.4,117.77 88.12,117.49 86.86,117.49 86.57,117.77 86.57,118.61 86.46,118.73 86.28,118.73 85.67,118.12 85.67,117.26 84.96,116.55 80.52,116.55 80.16,116.19 79.37,116.19 78.34,117.23 75.52,117.23 75.22,117.53 75.22,118.75 75.09,118.87 74.74,118.87 74.61,118.75 74.61,117.48 74.33,117.2 73.85,117.2 73.57,117.48 73.57,118.75 73.44,118.87 73.19,118.87 73.06,118.75 73.06,117.48 72.78,117.2 72.3,117.2 72.02,117.48 72.02,118.36 71.89,118.49 71.64,118.49 71.18,118.03 71.18,116.93 70.89,116.64 64.65,116.64 63.22,115.21 63.22,108.09 64.48,106.83 64.48,105.74 63.42,104.69 63.42,103.91 63.66,103.67 63.66,101.91 v1(63.73,101.84)
CLK_24M_NSSC_CPU#: length 102.7
  TOP w0.102: U1.C6 60.76,101.41 60.91,101.41 61.04,101.55 61.19,101.55 61.38,101.36 61.82,101.36 62.38,101.92 62.51,101.92 62.58,101.84 62.58,101.53
  TOP w0.127: 62.58,101.53 62.58,101.48 62.65,101.41 62.78,101.41 63.17,101.8 63.17,101.97 v1(63,102.14) ; v1(111.29,122.48) XU1.J9
  IN2 w0.127: v1(111.29,122.48) 110.88,122.07 110.88,121.42 109.62,120.16 109.29,120.16 109.04,120.41 109.04,121.75 108.76,122.04 101.81,122.04 101.69,122.16 101.69,123.32 101.41,123.6 100.78,123.6 100.49,123.31 100.49,122.28 100.37,122.15 94.56,122.15 94.28,121.87 94.28,121.22 94.15,121.1 92.59,121.1 92.24,120.75 92.24,120.15 92.52,119.87 93.63,119.87 93.76,119.74 93.76,119.24 93.63,119.12 92.76,119.12 92.44,118.79 92.44,117.88 92.31,117.76 90.85,117.76 90.73,117.88 90.73,120.93 90.42,121.24 89.97,121.24 89.69,120.95 89.69,117.88 89.56,117.76 89.3,117.76 89.18,117.88 89.18,120.23 88.89,120.51 88.43,120.51 88.14,120.22 88.14,117.88 88.01,117.76 86.97,117.76 86.84,117.88 86.84,118.72 86.57,118.99 86.17,118.99 85.41,118.23 85.41,117.37 84.85,116.82 80.41,116.82 80.05,116.46 79.48,116.46 78.45,117.5 75.63,117.5 75.49,117.64 75.49,118.86 75.2,119.14 74.63,119.14 74.34,118.86 74.34,117.59 74.22,117.46 73.96,117.46 73.84,117.59 73.84,118.86 73.55,119.14 73.08,119.14 72.79,118.86 72.79,117.59 72.67,117.46 72.41,117.46 72.29,117.59 72.29,118.47 72,118.76 71.53,118.76 70.92,118.14 70.92,117.04 70.78,116.9 64.54,116.9 62.95,115.32 62.95,107.98 64.21,106.72 64.21,105.85 63.16,104.8 63.16,103.8 63.39,103.56 63.39,102.27 63.26,102.14 v1(63,102.14)
CLK_100M_BCLK_CPU: length 102
  TOP w0.102: U1.B8 61.31,100.69 61.31,100.64 61.41,100.54 61.54,100.47 63.45,100.47 63.66,100.68 ; XU1.W5 107.73,114.19 107.26,114.19 107.09,114.35 104.12,114.35 104.03,114.26 103.35,114.26 103.33,114.29 103.3,114.29
  TOP w0.127: 103.3,114.29 99.01,114.29 98.88,114.42 98.88,116.82 99.01,116.94 100.6,116.94 100.88,117.22 100.88,117.68 100.6,117.96 98.14,117.96 97.86,117.68 97.86,114.42 97.74,114.29 97.48,114.29 97.35,114.42 97.35,117.68 97.08,117.96 96.61,117.96 96.34,117.68 96.34,114.42 96.21,114.29 95.96,114.29 95.83,114.42 95.83,117.68 95.55,117.96 95.09,117.96 94.81,117.68 94.81,114.42 94.69,114.29 94.43,114.29 94.31,114.42 94.31,117.09 94.03,117.36 93.57,117.36 93.29,117.09 93.29,109.86 91.97,108.54 91.97,102.58 92.79,101.76 92.79,96.31 90.5,94.02 86.92,94.02 v1(86.64,94.3) ; v1(64.77,102.51) 64.21,101.95 64.21,101.23 63.66,100.68 63.66,100.68
  IN2 w0.127: v1(64.77,102.51) 65.03,102.51 65.19,102.67 66.43,102.67 67.07,102.03 68.62,102.03 73.98,96.67 81.9,96.67 84.51,94.06 86.4,94.06 v1(86.64,94.3)
CLK_100M_BCLK_CPU#: length 101.9
  TOP w0.102: 63.74,100.43 63.58,100.27 61.49,100.27 61.29,100.37 61.11,100.55 60.53,100.55 60.4,100.68 60.4,100.75 U1.C8 ; XU1.W4 107.19,113.97 107.01,114.15 104.21,114.15 104.19,114.13 104.18,114.13 104.11,114.06 103.35,114.06 103.33,114.04 103.3,114.04
  TOP w0.127: 103.3,114.04 98.9,114.04 98.62,114.31 98.62,116.92 98.9,117.2 100.5,117.2 100.62,117.33 100.62,117.58 100.5,117.71 98.24,117.71 98.12,117.58 98.12,114.31 97.84,114.04 97.38,114.04 97.1,114.31 97.1,117.58 96.97,117.71 96.72,117.71 96.59,117.58 96.59,114.31 96.32,114.04 95.85,114.04 95.58,114.31 95.58,117.58 95.45,117.71 95.2,117.71 95.07,117.58 95.07,114.31 94.79,114.04 94.33,114.04 94.05,114.31 94.05,116.98 93.92,117.11 93.67,117.11 93.54,116.98 93.54,109.75 92.23,108.43 92.23,102.69 93.04,101.87 93.04,96.2 90.61,93.77 86.85,93.77 v1(86.61,93.52) ; 63.74,100.43 63.76,100.43 64.46,101.13 64.46,101.56 v1(64.64,101.74)
  IN2 w0.127: v1(64.64,101.74) 65.3,102.4 66.32,102.4 66.96,101.77 68.51,101.77 73.87,96.41 81.79,96.41 84.17,94.02 84.4,93.79 86.33,93.79 v1(86.61,93.52)
CLK_100M_ITPXDP_CPU: length 102.1
  TOP w0.089: U1.Y4 51.82,102.76 51.73,102.85 51.73,103.01 51.89,103.17 51.89,103.3 51.73,103.46 51.73,103.76 51.48,104 51.48,104.56 51.51,104.59
  TOP w0.127: 51.51,104.59 51.59,104.66 51.59,105.03 v1(52.25,105.69)
  IN2 w0.127: v1(67.31,117.74) 67.23,117.74 66.75,118.23 66.75,119.35 66.61,119.48 66.38,119.48 66.18,119.28 66.18,118.39 65.91,118.13 65.48,118.13 65.09,118.52 65.09,119.3 64.9,119.48 64.68,119.48 64.54,119.34 64.54,117.78 64.23,117.46 63.82,117.46 63.11,118.18 62.93,118.18 62.75,118 62.75,117.82 63.54,117.03 63.54,116.62 63.21,116.29 62.81,116.29 62.01,117.09 61.83,117.09 61.65,116.91 61.65,116.73 62.44,115.93 62.44,108.12 62.16,107.84 61.69,107.84 61.4,108.12 61.4,115.5 61.28,115.63 61.02,115.63 60.89,115.5 60.89,111.74 60.61,111.46 60.14,111.46 59.85,111.74 59.85,113.06 59.73,113.18 58.97,113.18 58.69,113.47 58.69,113.94 58.97,114.23 59.73,114.23 59.85,114.35 59.85,114.86 59.6,115.12 58.18,115.12 58.05,114.99 58.05,113.94 57.77,113.65 57.16,113.65 56.88,113.94 56.88,114.99 56.75,115.12 52.96,115.12 50.72,112.88 50.72,111.8 51.28,111.24 51.28,110.74 50.72,110.18 50.72,109.29 50.85,109.16 54.05,109.16 54.33,108.88 54.33,107.62 54.46,107.5 55.81,107.5 56.16,107.15 56.16,103.63 55.85,103.32 55.27,103.32 54.08,102.12 53.49,102.12 53.11,102.5 53.11,102.96 53.83,103.68 53.83,103.97 53.11,104.69 53.11,105.31 53.55,105.74 54.52,105.74 54.63,105.86 54.63,106.1 54.34,106.39 52.91,106.39 52.6,106.7 52.6,107.17 52.89,107.46 53.16,107.46 53.29,107.58 53.29,107.99 53.16,108.12 50.85,108.12 50.72,107.99 50.72,107.48 51.6,106.61 51.6,105.86 51.76,105.69 v1(52.25,105.69)
  BOTTOM w0.127: v1(67.31,117.74) 67.18,117.74 67.08,117.64 67.08,117.14 70.2,114.02 70.2,112.32 70.72,111.8 70.86,111.8 71.03,111.96 XDP1.40
CLK_100M_ITPXDP_CPU#: length 102.2
  TOP w0.089: 51.74,104.47 51.66,104.39 51.66,104.08 51.91,103.83 51.91,103.53 U1.Y3
  TOP w0.127: 51.74,104.47 51.84,104.57 51.87,104.57 v1(52.23,104.93)
  IN2 w0.127: v1(67.28,118.38) 67.02,118.65 67.02,119.46 66.72,119.75 66.27,119.75 65.91,119.4 65.91,118.5 65.8,118.39 65.59,118.39 65.35,118.63 65.35,119.41 65.02,119.75 64.57,119.75 64.28,119.45 64.28,117.89 64.11,117.73 63.94,117.73 63.22,118.45 62.82,118.45 62.48,118.11 62.48,117.71 63.27,116.92 63.27,116.74 63.1,116.56 62.92,116.56 62.12,117.35 61.72,117.35 61.38,117.02 61.38,116.62 62.18,115.82 62.18,108.23 62.05,108.1 61.8,108.1 61.67,108.23 61.67,115.61 61.39,115.89 60.91,115.89 60.63,115.61 60.63,111.85 60.5,111.72 60.25,111.72 60.12,111.85 60.12,113.17 59.84,113.45 59.08,113.45 58.95,113.58 58.95,113.83 59.08,113.96 59.84,113.96 60.12,114.24 60.12,114.97 59.71,115.38 58.07,115.38 57.78,115.1 57.78,114.05 57.66,113.92 57.27,113.92 57.15,114.05 57.15,115.1 56.86,115.38 52.85,115.38 50.46,112.99 50.46,111.69 51.01,111.13 51.01,110.85 50.46,110.29 50.46,109.18 50.74,108.89 53.94,108.89 54.06,108.77 54.06,107.51 54.35,107.23 55.7,107.23 55.89,107.03 55.89,103.74 55.74,103.58 55.16,103.58 53.96,102.39 53.6,102.39 53.38,102.61 53.38,102.85 54.1,103.57 54.1,104.08 53.38,104.8 53.38,105.2 53.66,105.48 54.63,105.48 54.9,105.75 54.9,106.21 54.45,106.66 53.02,106.66 52.87,106.81 52.87,107.06 53,107.19 53.27,107.19 53.55,107.47 53.55,108.1 53.27,108.38 50.74,108.38 50.46,108.1 50.46,107.37 51.33,106.5 51.33,105.75 51.65,105.43 51.74,105.43 v1(52.23,104.93)
  BOTTOM w0.127: XDP1.42 71.13,111.46 71.04,111.55 70.61,111.55 69.95,112.21 69.95,113.91 66.83,117.04 66.83,117.92 v1(67.28,118.38)
CLK_100M_PCIBCLK_CPU: length 101.7
  TOP w0.102: 63.29,103.15 63.02,103.15 61.92,102.05 61.69,102.05 61.59,101.95 U1.A6
  TOP w0.127: v1(88.73,92.15) 88.89,92.15 89,92.04 89,91.87 89.11,91.77 89.36,91.77 93.55,95.95 93.55,102.22 92.84,102.94 92.84,107.28 94.05,108.49 94.05,113.24 94.33,113.51 95.05,113.51 95.32,113.24 95.32,110.27 95.45,110.15 95.7,110.15 95.83,110.27 95.83,113.24 96.11,113.51 96.57,113.51 96.85,113.24 96.85,111.8 96.97,111.67 97.23,111.67 97.35,111.8 97.35,113.24 97.63,113.51 104.32,113.51 104.45,113.64 XU1.W1 ; 63.29,103.15 63.36,103.15 63.55,103.34 64.58,103.34 64.8,103.56 64.8,104.22 v1(64.63,104.39)
  IN2 w0.127: v1(64.63,104.39) 64.49,104.54 64.49,104.74 64.62,104.87 65.56,104.87 65.76,104.66 66.96,104.66 67.31,104.31 67.31,102.96 67.46,102.81 68.98,102.81 73.2,98.59 75.59,98.59 76.73,97.45 83.89,97.45 84.93,96.42 84.93,95.49 85.05,95.37 86.32,95.37 86.45,95.49 86.45,97.03 85.18,98.3 85.18,99.65 84.94,99.89 84.94,100.49 85.22,100.78 87.68,100.78 87.96,100.49 87.96,100.07 86.83,98.94 86.83,98.47 87.59,97.71 87.59,97.2 87.72,97.07 87.95,97.07 88.21,96.82 88.21,96.15 87.96,95.91 87.72,95.91 87.59,95.78 87.59,95.4 87.72,95.27 88.41,95.27 88.7,94.99 88.7,94.2 88.41,93.92 87.6,93.92 87.48,93.79 87.48,92.42 86.85,91.8 86.85,91.62 87.21,91.26 87.41,91.26 87.92,91.78 88.36,91.78 88.42,91.84 88.42,92.06 88.5,92.15 v1(88.73,92.15)
CLK_100M_PCIBCLK_CPU#: length 102
  TOP w0.102: 63.55,102.98 63.5,102.94 63.09,102.94 61.72,101.56 61.47,101.56 61.18,101.85 U1.B6
  TOP w0.127: 65.06,103.62 65.06,103.45 64.69,103.09 63.65,103.09 63.55,102.98 ; 65.06,103.62 v2(65.33,103.62) ; 65.06,103.62 65.06,104.06 v1(65.4,104.39) ; XU1.W2 105,113.81 104.46,113.26 97.74,113.26 97.61,113.13 97.61,111.69 97.33,111.42 96.87,111.42 96.59,111.69 96.59,113.13 96.47,113.26 96.21,113.26 96.08,113.13 96.08,110.17 95.81,109.89 95.34,109.89 95.07,110.17 95.07,113.13 94.94,113.26 94.43,113.26 94.31,113.13 94.31,108.39 93.09,107.17 93.09,103.04 93.8,102.33 93.8,95.85 89.47,91.51 89.04,91.51 v1(88.7,91.51)
  IN2 w0.127: v1(88.7,91.51) 88.03,91.51 87.52,91 87.09,91 86.58,91.51 86.58,91.91 87.21,92.53 87.21,93.9 87.49,94.19 88.3,94.19 88.43,94.31 88.43,94.88 88.3,95 87.61,95 87.32,95.29 87.32,95.89 87.61,96.17 87.85,96.17 87.94,96.26 87.94,96.71 87.84,96.81 87.61,96.81 87.32,97.09 87.32,97.6 86.56,98.36 86.56,99.05 87.7,100.18 87.7,100.38 87.57,100.51 85.33,100.51 85.2,100.38 85.2,100 85.44,99.76 85.44,98.41 86.71,97.14 86.71,95.38 86.43,95.1 84.94,95.1 84.66,95.38 84.66,96.3 83.78,97.18 76.62,97.18 75.47,98.33 73.09,98.33 68.87,102.54 67.35,102.54 67.04,102.85 67.04,104.2 66.85,104.39 v1(65.4,104.39)
CLKOUT_LPC1_SIO: length 26.3
  TOP w0.127: v2(26.06,104.16) 25.33,103.43 v1(25.13,103.43)
  IN1 w0.127: v1(25.13,103.43) 25.13,101.72 25.35,101.5 25.35,98.07 26.07,97.35 26.07,93.15 27.21,92 27.21,90.15 27.62,89.75 v1(28.06,89.75)
  BOTTOM w0.127: U104.7 24.67,104.36 25,104.69 26.15,104.69 26.3,104.54 SCB69.2 26.59,103.91 26.59,103.66 26.4,103.47 26.01,103.47 25.78,103.7 25.78,104.03 25.63,104.18 25.27,104.18 25.13,104.04 25.13,103.44 25.13,103.43 v1(25.13,103.43) ; ECR103.1 30.89,89.3 30.71,89.3 30.26,89.75 28.06,89.75 v1(28.06,89.75)
CNV_BRI_DT: length 8.2
  TOP w0.127: v1(43.69,102.05) 43.61,102.13 U1.AV4
  BOTTOM w0.127: v1(43.69,102.05) 43.43,101.79 43.43,100.9 43.12,100.59 SR7919.1 42.26,100.99 42.26,101.15 42.01,101.4 ; R3128.1 41.86,102.53 42.01,102.38 42.01,101.4 ; 42.01,101.4 41.54,101.4 41.4,101.26 41.4,100.74 v2(41.24,100.57) 41.03,100.57 SR7920.1
CNV_BRI_DT_R: length 93.7
  TOP w0.127: v1(42.24,50.25) 42.24,49.77 42.7,49.32 v2(42.7,48.22) 42.85,48.07 43.08,48.07 43.2,48.2 43.2,49.72 42.78,50.14 42.78,50.62 43.45,51.29 J218.36
  IN2 w0.127: v1(42.24,50.25) 42.47,50.02 42.47,49.65 42.34,49.52 42.19,49.52 41.28,50.43 40.97,50.43 39.31,52.09 37.16,52.09 36.24,53.01 35.13,53.01 34.21,53 33.02,54.19 33.02,55.22 32.82,55.42 32.82,56.15 32.69,56.28 32.03,56.28 31.77,56.53 31.77,57.51 31.64,57.65 30.43,57.65 30.3,57.77 30.3,59.1 27.51,61.9 27.51,63.17 26.53,64.15 25.74,64.15 24.74,65.14 24.74,69.43 25,69.69 25,71.61 25,73.48 25.22,73.7 25.22,74.06 25.01,74.27 25.01,74.66 24.14,75.53 24.14,77.38 23.78,77.74 23.78,81.06 24.64,81.92 24.64,82.61 24.01,83.24 24.01,85.16 24.31,85.46 24.31,88.3 24.2,88.41 24.2,90.15 24.61,90.56 24.61,92.07 24.93,92.38 24.93,96.91 25.51,97.5 25.51,99.17 26.72,100.38 26.72,101.19 28.15,102.62 28.15,103.02 28.9,103.77 29.41,103.77 30.27,104.63 31.92,104.63 33.81,106.52 33.81,106.93 34.36,107.48 36.04,107.48 36.44,107.08 v1(37.51,107.08)
  BOTTOM w0.127: v1(37.51,107.08) 37.81,107.08 40.74,104.14 R3128.2
CNV_BRI_RSP: length 93.1
  TOP w0.089: 42.54,104.87 42.54,104.09 42.49,104.04 U1.AY2
  TOP w0.102: 42.54,104.87 42.54,105.23 41.59,106.19 40.36,106.19 39.97,106.57 39.7,106.57 v1(39.27,107)
  TOP w0.127: R3125.1 38.94,48.57 38.94,49.27 v2(39.06,49.39) 39.06,50.54 39.2,50.68 v1(39.2,50.69)
  IN2 w0.127: v1(39.2,50.69) 39.2,50.93 39.01,51.13 36.9,51.13 35.88,52.14 35.49,52.14 33.85,52.14 32.15,53.84 29.41,56.58 29.41,57.85 29.28,57.98 28.01,57.98 27.3,58.69 27.3,58.89 28.17,59.76 28.17,59.98 28.01,60.14 27.81,60.14 27.41,59.73 27.15,59.73 27,59.88 27,60.11 27.46,60.57 27.46,60.73 26.46,61.72 26.46,62.2 23.87,64.79 23.87,69.79 24.14,70.05 24.14,71.73 22.91,72.96 22.91,74.73 23.28,75.1 23.28,77.02 22.92,77.38 22.92,85.29 23.45,85.82 23.45,87.84 23.13,88.17 23.13,89.91 22.92,90.11 22.37,90.11 22.25,90.24 22.25,90.68 23.75,92.18 23.75,92.43 24.06,92.74 24.06,97.27 24.65,97.85 24.65,99.53 25.86,100.74 25.86,102.32 27.39,103.85 27.66,103.85 29.3,105.49 30.95,105.49 31.97,106.52 32.55,106.52 32.89,106.86 32.89,107.24 33.24,107.59 33.24,107.75 34.35,108.85 38.75,108.85 39.47,108.13 39.47,107.2 v1(39.27,107)
CNV_BRI_RSP_R: length 9.4
  TOP w0.127: J218.22 39.95,51.32 39.75,51.12 38.78,51.12 38.63,50.97 38.63,50.73 38.37,50.46 38.37,48.73 38.28,48.64 38.28,47.93 R3125.2 38.71,47.18 38.58,47.06 SR7996.2 39.01,46.28 39.01,45.57 38.58,45.14 v2(38.58,44.77)
CNV_DET_S: length 11
  TOP w0.102: SR7993.2 69.8,52.33 D524.3 66.64,52.33 66.22,51.91 66.22,50.97 65.63,50.38 64.01,50.38 63.6,50.79 63.6,51.23 63.26,51.57 MQ26.2 63.26,53.19 v2(62.97,53.48)
CNV_RGI_DT: length 35.8
  TOP w0.102: 37.97,107.28 37.97,106.82 38.43,106.37 39.89,106.37 40.27,105.99 41.5,105.99 42.34,105.15 42.34,104.21 42.05,103.91 42.05,102.99 U1.BA4
  TOP w0.127: 37.97,107.28 38.2,107.51 v1(38.2,107.74) R3126.1
  IN2 w0.127: v1(38.2,107.74) 38.43,107.74 38.84,107.33 38.84,106.65 39.08,106.4 42.25,106.4 43.31,105.35 43.31,104.38 43.58,104.1 43.92,104.1 44.37,104.56 44.37,105.27 44.96,105.86 45.95,105.86 46.43,105.37 46.43,104.59 46.79,104.23 47.82,104.23 48.64,103.41 48.64,101.26 49.6,100.29 50.8,100.29 v1(51.66,99.43)
  BOTTOM w0.127: v2(52.78,99.33) 52.68,99.43 v1(51.66,99.43) SR7991.1 50.34,99.43 49.5,98.6 49.5,98.34 49.07,97.91 SR7921.1
CNV_RGI_DT_R: length 90.1
  TOP w0.127: R3126.2 37.77,108.77 37.77,107.86 37.43,107.52 v1(36.92,107.52) ; J218.32 42.45,51.69 41.25,50.49 v2(41.25,49.47) 41.25,49.12 40.79,48.66 40.49,48.66 40.31,48.83 v1(40.31,50.18)
  IN2 w0.127: v1(40.31,50.18) 40.31,50.46 39.11,51.66 36.98,51.66 36.06,52.57 35.31,52.57 35.31,52.57 34.03,52.57 32.59,54.01 32.59,54.63 32.49,54.73 31.88,54.73 31.47,55.13 31.47,55.36 31.72,55.62 31.72,55.87 31.55,56.05 31.37,56.05 31.19,55.87 30.81,55.87 30.68,56 30.68,56.18 31.22,56.71 31.22,56.96 31.01,57.17 30.78,57.17 30.32,56.71 30.1,56.71 29.84,56.96 29.84,58.18 29.61,58.41 28.89,58.41 28.62,58.68 28.62,60.17 28.04,60.75 26.9,61.9 26.9,63.17 26.35,63.71 25.56,63.71 24.31,64.96 24.31,69.61 24.57,69.87 24.57,71.78 24.57,71.91 23.65,72.83 23.65,73.09 24.07,73.51 24.07,74.01 23.71,74.36 23.71,77.2 23.35,77.56 23.35,85.11 23.88,85.64 23.88,88.09 23.75,88.23 23.75,90.31 24.03,90.59 24.03,90.85 23.77,91.1 23.77,91.46 24.18,91.87 24.18,92.25 24.49,92.56 24.49,97.09 25.08,97.67 25.08,99.35 26.29,100.56 26.29,101.37 27.13,102.2 27.13,102.98 27.57,103.42 27.84,103.42 28.62,104.21 29.24,104.21 29.49,104.46 29.49,104.73 29.82,105.06 31.13,105.06 32.15,106.09 32.73,106.09 33.32,106.68 33.32,107.06 33.7,107.44 33.7,107.59 34.53,108.42 35.71,108.42 36.61,107.52 v1(36.92,107.52)
CNV_RGI_RSP: length 95.6
  TOP w0.089: 42.75,104.87 42.75,103.51 42.89,103.36 43.18,103.22 43.38,103.22 U1.AV3
  TOP w0.102: v1(39.93,107) 39.93,106.97 40.51,106.39 41.67,106.39 42.75,105.32 42.75,104.87
  TOP w0.127: v2(41.45,46.52) 41.38,46.6 R3127.1 42.04,48.01 42.04,48.57 v1(42.26,48.79)
  IN2 w0.127: v1(42.26,48.79) 41.56,49.49 39.73,49.49 39.16,50.07 38.56,50.07 37.93,50.69 36.72,50.69 35.7,51.71 33.67,51.71 31.72,53.66 31.72,53.66 26.57,58.81 26.57,60.09 25.43,61.23 25.43,62.56 23.44,64.54 23.44,64.87 23.44,69.97 23.7,70.23 23.7,71.55 22.48,72.78 22.48,74.91 22.85,75.27 22.85,76.51 22.49,76.87 22.49,86.51 21.82,87.18 21.82,88.54 21.82,89.67 21.82,89.68 21.82,90.86 23.32,92.36 23.32,92.61 23.63,92.92 23.63,97.45 24.21,98.03 24.21,99.7 25.43,100.92 25.43,102.5 27.21,104.28 27.48,104.28 29.12,105.93 30.7,105.93 32.28,107.51 32.55,107.51 32.81,107.77 32.81,107.93 34.17,109.29 38.93,109.29 39.94,108.28 39.94,107.59 39.93,107.58 v1(39.93,107)
CNV_RGI_RSP_R: length 8.7
  TOP w0.127: J218.34 42.95,51.58 41.81,50.43 41.81,49.01 41.38,48.58 R3127.2 40.89,47.7 40.89,46.81 SR7997.2 41.02,46.03 41.02,45 v2(40.84,44.82)
CNV_WR_0_DN: length 73.7
  TOP w0.089: 39.65,105.41 39.67,105.4 39.67,105.38 39.7,105.34 39.7,105.11 39.72,105.08 39.72,105.07 40.03,104.76 40.04,104.76 40.06,104.75 40.73,104.75 41.12,104.36 41.12,103.86 41.03,103.77 U1.BB3
  TOP w0.127: v1(37.51,105.32) 37.51,105.6 37.64,105.72 37.82,105.72 37.89,105.65 39.41,105.65 39.65,105.41
  IN2 w0.127: v1(38.85,55.82) 39.22,56.19 39.22,56.58 38.95,56.85 37.48,56.85 36.5,57.83 36.5,58.87 35.55,59.82 35.44,59.82 35.44,59.82 33.49,59.82 30.14,63.17 30.14,65.71 28.69,67.16 28.69,70.16 28.16,70.69 28.16,79.49 29.08,80.42 29.08,83.5 28.73,83.86 28.73,86.99 28.57,87.14 28.57,90.08 29.18,90.69 29.77,90.69 30.1,91.02 30.1,91.59 29.75,91.93 29.75,93.7 29.28,94.18 29.28,94.89 27.37,96.79 27.37,98.87 28.25,99.75 28.25,100.43 28.74,100.93 29.28,100.93 29.55,101.19 29.55,101.68 30.13,102.26 30.91,102.26 31.62,102.97 32.02,102.97 32.28,102.71 33.45,102.71 33.76,103.01 33.76,104.51 34.17,104.92 35.56,104.92 36.4,105.76 37.08,105.76 v1(37.51,105.32)
  BOTTOM w0.127: v1(38.85,55.82) 38.99,55.96 38.99,56.14 R3115.2
CNV_WR_0_DP: length 73.5
  TOP w0.089: U1.BB4 41.3,103.43 41.3,104.43 40.8,104.93 40.13,104.93 40.12,104.94 40.11,104.94 39.9,105.15 39.9,105.16 39.88,105.18 39.88,105.42 39.88,105.5
  TOP w0.127: v1(36.73,105.32) 36.88,105.32 37.54,105.98 37.93,105.98 38,105.91 39.51,105.91 39.88,105.55 39.88,105.5
  IN2 w0.127: v1(39.48,55.82) 39.48,56.69 39.06,57.11 37.59,57.11 36.76,57.94 36.76,58.98 35.66,60.09 35.32,60.09 33.6,60.09 30.4,63.28 30.4,65.82 28.95,67.27 28.95,70.27 28.42,70.8 28.42,79.38 29.35,80.31 29.35,83.61 28.99,83.97 28.99,87.1 28.84,87.25 28.84,89.97 29.29,90.43 29.88,90.43 30.36,90.91 30.36,91.7 30.02,92.04 30.02,93.81 29.54,94.29 29.54,95 27.63,96.91 27.63,98.76 28.51,99.64 28.51,100.32 28.85,100.66 29.4,100.66 29.82,101.08 29.82,101.57 30.24,101.99 31.03,101.99 31.73,102.7 31.91,102.7 32.17,102.44 33.56,102.44 34.02,102.9 34.02,104.4 34.28,104.65 35.67,104.65 36.35,105.32 v1(36.73,105.32)
  BOTTOM w0.127: v1(39.48,55.82) 39.62,55.96 R3116.2
CNV_WR_1_DN: length 70.8
  TOP w0.089: U1.BA3 41.48,103.46 41.48,104.51 41.08,104.9 v1(41.08,105.36)
  IN2 w0.127: v1(37.39,58.67) 37.39,59.15 35.93,60.61 34.45,60.61 33.65,61.41 33.21,61.41 32.52,62.1 32.52,62.56 31.46,63.63 31.46,65.48 29.46,67.48 29.46,71.18 28.94,71.7 28.94,79.18 29.86,80.1 29.86,83.82 29.5,84.18 29.5,85.7 30.41,86.62 30.41,87.36 29.48,88.3 29.48,89.41 29.87,89.8 30.37,89.8 30.89,89.28 31.28,89.28 31.55,89.55 31.55,90.26 30.87,90.93 30.87,91.91 30.53,92.25 30.53,94.05 30.05,94.53 30.05,95.21 29.69,95.57 29.69,97.04 29.55,97.19 28.48,97.19 28.19,97.48 28.19,98.08 28.74,98.63 29.6,98.63 30.05,99.07 30.05,100.21 30.33,100.5 30.96,100.5 31.09,100.62 31.09,101.23 31.79,101.93 33.77,101.93 34.57,102.73 34.57,103.79 34.88,104.1 38.02,104.1 38.25,104.33 39.91,104.33 40.61,105.03 40.75,105.03 v1(41.08,105.36)
  BOTTOM w0.127: v1(37.39,58.67) 37.2,58.49 36.97,58.49 R3113.2
CNV_WR_1_DP: length 70.8
  TOP w0.089: v1(41.69,104.88) 41.62,104.8 41.62,104.62 41.66,104.58 41.66,103.86 U1.BA2
  IN2 w0.127: v1(38.01,58.53) 38.01,58.68 37.65,59.04 37.65,59.26 36.04,60.87 34.56,60.87 33.76,61.68 33.32,61.68 32.79,62.21 32.79,62.67 31.72,63.74 31.72,65.59 29.73,67.59 29.73,71.29 29.21,71.81 29.21,79.07 30.12,79.99 30.12,83.93 29.77,84.29 29.77,85.59 30.68,86.51 30.68,87.47 29.74,88.41 29.74,89.3 29.98,89.54 30.26,89.54 30.78,89.02 31.39,89.02 31.81,89.44 31.81,90.37 31.14,91.04 31.14,92.02 30.8,92.36 30.8,94.16 30.32,94.64 30.32,95.32 29.96,95.68 29.96,97.15 29.66,97.45 28.59,97.45 28.45,97.59 28.45,97.97 28.85,98.36 29.72,98.36 30.31,98.96 30.31,100.1 30.44,100.23 31.07,100.23 31.35,100.51 31.35,101.12 31.9,101.67 33.88,101.67 34.83,102.62 34.83,103.68 34.99,103.84 38.14,103.84 38.36,104.07 40.02,104.07 40.72,104.77 40.92,104.77 41.06,104.62 41.06,104.23 41.21,104.08 41.43,104.08 41.58,104.23 41.58,104.76 v1(41.69,104.88)
  BOTTOM w0.127: R3114.2 37.49,58.02 v1(38.01,58.53)
CNV_WR_CLK_DN: length 70.5
  TOP w0.127: U1.BD4 40.31,102.91 40.59,102.91 40.7,102.8 v1(40.7,102.58)
  IN2 w0.127: v1(41.04,60.26) 40.74,60.26 40.1,60.91 39.69,60.91 37.37,63.22 36.26,63.22 35.47,64.01 35.47,64.21 36.04,64.78 36.04,65.65 35.53,66.16 35.53,66.39 35.67,66.53 36.08,66.53 36.63,67.08 36.63,67.66 36.24,68.04 35.93,68.04 35.7,68.27 35.7,68.89 36.17,69.36 36.17,69.79 35.79,70.16 34.92,70.16 34.62,69.87 34.62,68.72 34.51,68.61 34.27,68.61 33.88,69 33.88,69.87 33.52,70.23 32.85,70.23 32.08,71 32.08,73.12 32.37,73.41 32.95,73.41 33.32,73.78 33.32,76.88 33.17,77.03 33.17,77.03 32.8,77.4 32.8,78.14 33.51,78.85 33.51,79.9 33.16,80.25 33.16,81.21 33.16,82.55 32.8,82.9 32.8,83.41 32.45,83.77 32.45,84.44 33.06,85.05 33.06,85.58 33.23,85.75 33.69,85.75 34.2,86.26 34.2,88.06 34.71,88.57 34.71,91.77 34.41,92.06 33.97,92.06 33.84,92.19 33.84,92.76 33.98,92.9 33.98,94.67 34.11,94.8 34.39,94.8 34.73,95.14 34.73,95.92 34.45,96.21 34.11,96.21 33.98,96.33 33.98,96.94 34.34,97.3 34.34,97.86 33.98,98.21 33.98,98.47 34.32,98.81 34.32,99.04 34.45,99.16 34.68,99.16 35.27,98.58 35.67,98.58 36.14,99.06 36.14,99.51 35.95,99.7 35.95,99.93 36.38,100.36 36.69,100.36 37.27,99.77 37.67,99.77 39.33,101.43 39.33,101.83 39.06,102.1 39.06,103.13 39.19,103.25 40.11,103.25 40.28,103.08 40.28,102.9 40.03,102.66 40.03,102.45 40.16,102.33 40.45,102.33 v1(40.7,102.58)
  BOTTOM w0.127: R3117.2 41.12,58.39 41.12,58.57 40.87,58.83 40.87,59.42 40.87,59.42 40.87,59.63 41.04,59.81 v1(41.04,60.26)
CNV_WR_CLK_DP: length 70.8
  TOP w0.127: v1(40.64,103.34) 40.61,103.31 U1.BE3
  IN2 w0.127: v1(40.64,103.34) 40.46,103.52 39.08,103.52 38.8,103.24 38.8,101.99 39.06,101.72 39.06,101.54 37.56,100.04 37.38,100.04 36.8,100.62 36.27,100.62 35.69,100.04 35.69,99.59 35.88,99.39 35.88,99.17 35.56,98.85 35.38,98.85 34.79,99.43 34.34,99.43 34.05,99.15 34.05,98.92 33.72,98.58 33.72,98.1 34.07,97.75 34.07,97.41 33.72,97.05 33.72,96.22 34,95.94 34.34,95.94 34.47,95.81 34.47,95.25 34.28,95.06 34,95.06 33.72,94.78 33.72,93.01 33.58,92.87 33.58,92.08 33.86,91.8 34.3,91.8 34.44,91.66 34.44,88.68 33.93,88.17 33.93,86.38 33.58,86.02 33.12,86.02 32.79,85.69 32.79,85.16 32.18,84.56 32.18,83.66 32.54,83.3 32.54,82.79 32.89,82.44 32.89,81.1 32.89,80.14 33.25,79.79 33.25,78.96 32.54,78.25 32.54,77.29 33.06,76.77 33.06,73.89 32.84,73.68 32.26,73.68 31.81,73.23 31.81,72.9 31.81,72.79 31.81,72.79 31.81,70.89 32.74,69.97 33.41,69.97 33.62,69.75 33.62,68.89 34.16,68.34 34.62,68.34 34.89,68.61 34.89,69.75 35.03,69.9 35.68,69.9 35.9,69.67 35.9,69.47 35.43,69 35.43,68.16 35.82,67.77 36.13,67.77 36.36,67.54 36.36,67.19 35.96,66.79 35.56,66.79 35.27,66.5 35.27,66.05 35.77,65.54 35.77,64.89 35.2,64.32 35.2,63.9 36.15,62.96 37.26,62.96 39.58,60.65 39.99,60.65 40.84,59.79 v1(41.67,59.79)
  BOTTOM w0.127: v1(41.67,59.79) 41.39,59.79 41.12,59.53 41.12,58.93 R3118.2
CNV_WR_R_0_DN: length 2.9
  TOP w0.127: J218.15 38.2,59.1 38.2,59.1 38.45,58.85 38.45,58.57 38.71,58.3 v1(38.71,57.99)
  BOTTOM w0.127: R3115.1 38.89,57.5 38.89,57.81 v1(38.71,57.99)
CNV_WR_R_0_DP: length 3.1
  TOP w0.127: J218.17 38.7,58.67 v1(39.39,57.98)
  BOTTOM w0.127: R3116.1 39.24,57.65 39.24,57.83 v1(39.39,57.98)
CNV_WR_R_1_DN: length 5.3
  TOP w0.127: v1(37.16,56.3) 37.34,56.48 37.34,56.88 36.7,57.52 J218.9
  BOTTOM w0.127: R3113.1 36.5,56.43 36.63,56.3 v1(37.16,56.3)
CNV_WR_R_1_DP: length 5.3
  TOP w0.127: J218.11 37.2,59.11 36.95,58.87 36.95,57.63 37.59,56.99 37.59,56.53 v1(37.92,56.2)
  BOTTOM w0.127: v1(37.92,56.2) 37.77,56.35 37.77,56.82 R3114.1
CNV_WR_R_CLK_DN: length 6.1
  TOP w0.127: v1(40.61,56.31) 40.84,56.54 40.84,56.99 41.12,57.27 41.12,57.69 39.7,59.11 J218.21
  BOTTOM w0.127: v1(40.61,56.31) 40.83,56.31 41.35,56.84 41.35,57.23 41.22,57.36 R3117.1
CNV_WR_R_CLK_DP: length 5.8
  TOP w0.127: J218.23 40.2,58.97 41.38,57.79 41.38,57.17 41.1,56.89 41.1,56.46 41.17,56.38 41.17,56.38 v1(41.38,56.17)
  BOTTOM w0.127: v1(41.38,56.17) 41.38,56.5 41.6,56.73 41.6,57.15 R3118.1
CNV_WT_0_DN: length 78
  TOP w0.102: 37.82,101.79 38.41,101.79 38.45,101.76 38.57,101.76 38.78,101.54 U1.BE6
  TOP w0.127: v1(37.69,101.79) 37.82,101.79
  IN2 w0.127: v1(37.69,101.79) 37.5,101.6 36.13,101.6 34.89,100.36 33.97,100.36 33.55,99.94 33.33,99.94 32.87,99.47 32.87,95.78 32.94,95.7 32.94,93.33 32.8,93.19 32.8,91.7 33.67,90.84 33.67,89.36 32.55,88.24 32.55,86.55 32.02,86.02 32.02,85.5 31.41,84.89 31.41,82.81 32.04,82.17 32.04,79.2 31.23,78.39 31.23,77.34 31.02,77.14 31.02,76.38 31.72,75.69 31.72,74.23 31.55,74.06 31.29,73.8 31.29,73.8 31.04,73.55 31.04,73.22 31.04,73.22 31.04,72.36 31.04,72.36 31.04,69.77 31.64,69.17 32.4,69.17 32.69,68.88 32.69,68.52 33.03,68.18 33.03,66.32 34.38,64.98 34.38,63.63 35.84,62.17 36.93,62.17 39.23,59.87 39.67,59.87 40.52,59.02 40.64,59.02 42,57.66 42.4,57.66 v1(42.59,57.47)
  BOTTOM w0.127: v1(42.59,57.47) 43.03,57.9 43.3,57.9 43.71,58.31 43.71,58.64 45.64,60.57 47.69,60.57 51.78,64.66 52.43,64.66 53.62,63.46 54.61,63.46 54.99,63.08 54.99,61.76 ; R3121.2 54.89,61.18 54.99,61.28 54.99,61.76 ; 54.99,61.76 v2(55.29,61.76)
CNV_WT_0_DP: length 78
  TOP w0.102: U1.BD7 40.16,101.36 40.04,101.25 39.66,101.25 39.57,101.34 38.7,101.34 38.48,101.55 38.37,101.55 v1(38.15,101.34)
  IN2 w0.127: v1(38.15,101.34) 36.24,101.34 35,100.09 34.08,100.09 33.66,99.67 33.45,99.67 33.13,99.36 33.13,95.89 33.21,95.81 33.21,93.22 33.07,93.08 33.07,91.81 33.93,90.95 33.93,89.25 32.82,88.13 32.82,86.44 32.28,85.9 32.28,85.38 31.67,84.78 31.67,82.92 32.31,82.28 32.31,79.09 31.49,78.28 31.49,77.23 31.29,77.03 31.29,76.49 31.99,75.8 31.99,74.12 31.81,73.95 31.81,73.94 31.4,73.54 31.3,73.44 31.3,73.11 31.3,69.88 31.75,69.43 32.51,69.43 32.95,68.99 32.95,68.63 33.3,68.29 33.3,66.43 34.64,65.09 34.64,63.74 35.95,62.44 37.04,62.44 39.34,60.14 39.78,60.14 40.63,59.28 40.76,59.28 42.11,57.93 42.77,57.93 v1(43.23,57.47)
  BOTTOM w0.127: v2(53.87,62.94) 53.87,63.21 ; 53.87,63.21 54.5,63.21 54.74,62.98 54.74,61.39 54.61,61.26 54.43,61.26 54.3,61.38 54.05,61.38 53.97,61.3 R3122.2 ; 53.87,63.21 53.52,63.21 52.32,64.4 51.88,64.4 47.79,60.31 45.75,60.31 43.97,58.53 43.97,58.21 v1(43.23,57.47)
CNV_WT_1_DN: length 82.9
  TOP w0.102: 37.59,102.45 37.84,102.2 37.95,102.2 38.12,102.02 38.63,102.02 38.75,101.9 38.91,101.9 U1.BG6
  TOP w0.127: 37.59,102.45 37.55,102.49 37.49,102.55 37.49,103.03 37.32,103.21 37.32,103.22 37.29,103.22 v1(37.11,103.39)
  IN2 w0.127: v1(43.46,55.87) 43.46,56.3 43.38,56.37 43.08,56.37 42.91,56.21 42.91,55.04 43.16,54.79 44.22,54.79 45.24,53.77 45.24,53.3 44.93,53 43.28,53 41.82,54.46 41.17,54.46 40.56,55.06 40.56,55.49 40.82,55.74 41.65,55.74 41.84,55.93 41.84,56.7 41.66,56.89 40.92,56.89 40.69,57.11 40.69,57.88 40.32,58.24 40.2,58.24 39.43,59.01 38.95,59.01 36.57,61.39 34.94,61.39 32.74,63.59 32.74,64.1 33.16,64.52 33.16,65.08 31.79,66.45 31.79,66.98 32.26,67.45 32.26,67.79 32.08,67.96 31.75,67.96 31.29,67.5 30.86,67.5 30.24,68.12 30.24,72.19 29.72,72.71 29.72,74.61 30.29,75.18 30.29,75.7 29.72,76.27 29.72,77.03 30.1,77.41 30.1,77.88 29.73,78.25 29.73,78.87 30.86,80.01 30.86,80.54 31.27,80.95 31.27,81.85 30.63,82.48 30.63,84.14 30.28,84.5 30.28,85.2 30.56,85.49 30.91,85.49 31.24,85.82 31.24,86.34 31.74,86.83 31.74,87.11 31.55,87.3 31.55,88.34 32.4,89.19 32.4,90.58 32,90.97 32,91.79 31.85,91.94 31.85,93.33 32.17,93.65 32.17,94.92 31.76,95.33 31.76,96.28 32.09,96.61 32.09,99.12 31.67,99.54 31.67,99.98 32.09,100.4 32.09,100.79 32.46,101.16 34.52,101.16 35.42,102.06 35.42,103.05 35.63,103.27 36.35,103.27 36.61,103 36.72,103 v1(37.11,103.39)
  BOTTOM w0.127: 43.68,56.59 v2(43.48,56.78) ; 43.68,56.59 43.97,56.88 43.97,57.08 R3119.2 ; 43.68,56.59 43.63,56.54 43.63,56.04 v1(43.46,55.87)
CNV_WT_1_DP: length 82.6
  TOP w0.102: U1.BF6 39.42,101.85 39.16,102.1 38.84,102.1 38.71,102.22 38.21,102.22 38.03,102.4 37.92,102.4 37.8,102.52 37.8,102.59 37.77,102.63
  TOP w0.127: 37.77,102.63 37.75,102.65 v1(37.75,103.39)
  IN2 w0.127: v1(37.75,103.39) 37.09,102.73 36.5,102.73 36.24,103 35.74,103 35.69,102.94 35.69,101.95 34.63,100.89 32.57,100.89 32.36,100.68 32.36,100.29 31.94,99.87 31.94,99.65 32.36,99.23 32.36,96.5 32.03,96.17 32.03,95.44 32.43,95.03 32.43,93.54 32.12,93.22 32.12,92.05 32.27,91.9 32.27,91.08 32.66,90.69 32.66,89.08 31.81,88.23 31.81,87.41 32,87.22 32,86.72 31.51,86.23 31.51,85.71 31.02,85.22 30.67,85.22 30.54,85.09 30.54,84.61 30.9,84.25 30.9,82.6 31.53,81.96 31.53,80.83 31.13,80.43 31.13,79.9 30,78.76 30,78.36 30.36,77.99 30.36,77.3 29.98,76.92 29.98,76.38 30.55,75.81 30.55,75.07 29.98,74.5 29.98,72.82 30.5,72.3 30.5,68.23 30.97,67.77 31.18,67.77 31.64,68.23 32.19,68.23 32.52,67.9 32.52,67.34 32.05,66.87 32.05,66.56 33.42,65.19 33.42,64.41 33.01,63.99 33.01,63.7 35.05,61.66 36.68,61.66 39.06,59.27 39.54,59.27 40.31,58.51 40.43,58.51 40.96,57.99 40.96,57.23 41.03,57.15 41.77,57.15 42.11,56.81 42.11,55.82 41.76,55.48 40.93,55.48 40.83,55.38 40.83,55.17 41.28,54.73 41.93,54.73 43.39,53.27 44.82,53.27 44.97,53.42 44.97,53.66 44.11,54.52 43.05,54.52 42.65,54.93 42.65,56.32 42.97,56.64 43.5,56.64 43.68,56.46 43.76,56.46 v1(44.3,55.92)
  BOTTOM w0.127: v1(44.3,55.92) 44.01,55.92 43.88,56.05 43.88,56.43 44.01,56.56 R3120.2
CNV_WT_CLK_DN: length 77.9
  TOP w0.127: v1(41.02,101.55) U1.BC5
  IN2 w0.127: v1(41.02,101.55) 40.55,101.55 37.63,98.63 36.82,98.63 35.57,97.39 35.57,92.13 36.02,91.68 36.02,89.33 35.71,89.03 35.71,88.21 34.97,87.47 34.97,85.87 33.6,84.5 33.6,83.2 34.05,82.76 34.05,82.41 34.05,82.37 34.47,81.95 34.47,77.06 34.1,76.69 34.1,75.77 34.64,75.22 34.64,73.81 33.25,72.41 33.25,71.57 33.86,70.96 36.32,70.96 36.99,70.28 36.99,68.79 37.58,68.2 37.58,65.46 37.82,65.22 37.82,63.89 39.96,61.75 41.87,61.75 42.72,60.9 42.72,59.88 v1(42.17,59.32)
  BOTTOM w0.127: R3123.2 56.26,61.99 56.39,62.12 56.89,62.12 57.02,62.25 57.02,63.01 56.51,63.52 56.51,63.87 56.06,64.33 55.68,64.33 ; 55.68,64.33 v2(55.68,64.05) ; 55.68,64.33 53.48,64.33 52.64,65.17 51.57,65.17 47.48,61.08 46.68,61.08 46.36,61.41 46.36,62.22 46.23,62.35 45.57,62.35 45.44,62.22 45.44,61.2 44.53,60.29 43.18,60.29 42.88,59.99 42.5,59.99 42.17,59.66 v1(42.17,59.32)
