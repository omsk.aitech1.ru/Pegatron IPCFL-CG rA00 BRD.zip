# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 103.82,155.23 103.82,152.39 104.47,151.74 105.25,151.74 105.52,152 111.43,152 111.5,151.93 111.5,151.32 111.96,150.87 112.36,150.87 112.59,150.64 112.59,150.21 111.26,150.21 111.26,150.36 110.96,150.67 110.32,150.67 110.18,150.53 109.31,150.53 109.24,150.47 109.24,149.34 109.19,149.28 105.68,149.28 105.57,149.17 105.57,148.08 105.43,147.94 103.95,147.94 103.86,148 103.87,148.11 104.04,148.85 103.58,149.45 103.53,149.52 103.56,149.61 103.78,150.05 103.68,150.54 103.4,151.85 102.14,151.38 102.06,151.31 101.96,151.35 101.1,151.58 100.61,150.84 100.58,150.77 100.51,150.74 98.29,150.74 98.06,150.51 96.84,150.51 96.79,150.45 96.79,149.39 93.32,149.39 92.47,148.54 92.47,147.13 92.33,146.98 91.12,146.98 90.43,147.67 90.43,147.69 89.91,148.21 89.91,151.68 89.73,151.87 89.73,152.62 92.82,152.62 93.39,152.04 99.32,152.04 101.38,154.11 101.86,154.11 102.39,154.64 102.39,154.99 102.83,155.43 103.62,155.43
GND on TOP (solid shape): outline of 168 points within 58.16,95.67 60.68,98.82
GND on TOP (solid shape): outline of 201 points within 163.45,159.32 168.76,171.06
GND on TOP (solid shape): 100.71,12.66 100.86,12.11 101.42,12.26 103.94,12.26 104.67,11.52 104.67,9.82 104.46,9.6 104.44,9.6 104.38,9.54 101.18,9.54 101.11,9.6 101.25,10.23 100.61,10.22 100.5,10.18 100.43,10.28 100.43,10.43 99.09,10.43 99.04,10.48 98.88,10.48 98.14,10.4 98.69,9.9 98.78,9.9 98.83,9.81 98.83,9.55 98.7,9.42 98.7,8.94 98.5,8.94 98.5,8.76 98.3,8.76 98.3,8.86 98.31,8.88 98.14,9.56 97.63,9.06 97.61,8.98 97.53,8.94 97.48,8.94 97.48,7.92 96.97,7.92 96.96,7.96 96.91,8.05 96.85,8.14 96.81,8.2 96.83,8.27 96.45,8.9 96.22,8.2 96.25,8.14 96.23,8.07 96.16,7.88 96.19,7.69 94.9,7.69 95.41,8.19 95.41,12.37 96.35,13.31 100.06,13.31
GND on TOP (solid shape): outline of 233 points within 161.86,128.98 169.27,136.98
GND on TOP (solid shape): outline of 234 points within 161.86,86.98 169.49,94.98
GND on TOP (solid shape): outline of 244 points within 9.46,78.74 16.44,85.72
GND on TOP (solid shape): outline of 244 points within 9.46,28.74 16.44,35.72
GND on TOP (solid shape): outline of 244 points within 40.46,22.81 47.44,29.79
GND on TOP (solid shape): outline of 252 points within 2.11,134.74 10.59,143.22
GND on TOP (solid shape): outline of 252 points within 152.7,151.24 161.18,159.73
GND on TOP (solid shape): outline of 252 points within 160.76,13.06 169.24,21.54
GND on TOP (solid shape): outline of 255 points within 75.86,128.98 83.86,136.98
GND on TOP (solid shape): outline of 289 points within 75.5,42.28 85.5,52.28
GND on TOP (solid shape): 16.55,171.79 16.66,171.68 16.81,171.64 17.15,171.64 17.15,171.16 17.14,171.16 17.14,170.22 17.15,170.21 17.15,169.49 17.14,169.48 17.14,169 17.04,168.9 16.48,168.9 16.48,169.48 15.52,169.48 15.52,168.9 9.75,168.9 9.29,169.36 2.79,169.36 2.18,168.75 2.18,164.4 1.01,163.23 1.01,151.78 2.14,150.66 2.14,143.06 1.01,141.93 1.01,16.15 0.76,15.93 0.66,15.6 0.66,15.4 0.75,15.09 0.98,14.86 0.98,14.86 1.36,14.48 4.46,14.48 4.57,14.37 4.59,14.26 4.51,14.2 3.82,12.84 5.33,12.77 5.41,12.82 5.49,12.79 6.34,11.94 7.05,12.57 7.97,12.81 10.23,12.81 18.2,12.81 19.04,12.63 19.72,12.12 19.72,11.56 19.64,11.46 19.53,11.51 18.97,12.09 18.2,12.31 8,12.31 6.95,11.89 6.49,10.86 6.49,10.81 1,10.81 0.65,10.95 0.51,11.3 0.51,12.68 0.58,12.78 0.69,12.74 2.3,13.3 0.69,13.86 0.58,13.82 0.51,13.92 0.51,171.3 0.65,171.65 1,171.79
GND on TOP (solid shape): outline of 316 points within 57.3,80.56 60.04,85.41
GND on TOP (solid shape): outline of 390 points within 67.8,8 87.93,14.85
GND on TOP (solid shape): outline of 382 points within 25.4,17.75 69.52,62.82
GND on TOP (solid shape): outline of 126 points within 93.1,70.35 119.38,73.73
GND on TOP (solid shape): outline of 536 points within 122.3,70.4 158.06,74.13
GND on TOP (solid shape): outline of 137 points within 134.11,58.28 158.62,59.98
GND on TOP (solid shape): outline of 581 points within 35.07,4.81 169.49,171.79
GND on TOP (solid shape): outline of 156 points within 93.22,58.36 114.26,59.96
GND on TOP (solid shape): outline of 300 points within 92.96,62.19 120.37,68.19
GND on TOP (solid shape): outline of 361 points within 92.57,50.16 117.51,56.23
GND on TOP (solid shape): outline of 326 points within 121.79,62.19 158.29,68.19
GND on TOP (solid shape): outline of 590 points within 113.05,46.17 158.32,56.2
GND on TOP (solid shape): outline of 4003 points within 39.75,82.64 60.7,103.09
GND on TOP (solid shape): outline of 9886 points within 102.46,90.24 145.41,119.02
GND on BOTTOM (solid shape): 160.31,121.36 157.46,121.36 157.46,122.2 160.31,122.2
GND on BOTTOM (solid shape): 63.11,51.73 63.11,51.08 62.93,50.89 62.03,50.89 62,50.92 62,51.83 63.01,51.83
GND on BOTTOM (solid shape): 86.17,27.63 86.17,26.8 79.52,26.8 79.18,27.14 79.18,27.78 79.48,28.07 85.73,28.07
GND on BOTTOM (solid shape): 64.9,149.16 64.9,148.43 64.84,148.38 64.29,148.38 64.06,148.61 64.06,149.55 64.1,149.58 64.48,149.58
GND on BOTTOM (solid shape): 71.68,92.57 71.68,92.12 71.5,91.94 69.37,91.94 68.96,92.34 68.96,92.75 69.09,92.88 71.37,92.88
GND on BOTTOM (solid shape): 76.15,74.01 76.15,70.58 75.99,70.41 74.92,70.41 74.83,70.5 74.83,74.01 75.06,74.23 75.92,74.23
GND on BOTTOM (solid shape): 84.83,152.44 84.83,151.75 84.61,151.53 83.29,151.53 83.13,151.68 83.13,153.1 83.18,153.15 84.12,153.15
GND on BOTTOM (solid shape): 92.19,38.94 92.19,37.87 92.1,37.79 90.37,37.79 89.93,38.23 89.93,38.99 89.98,39.04 92.08,39.04
GND on BOTTOM (solid shape): 121.99,60.42 121.99,59.3 121.94,59.25 120.27,59.25 120.22,59.3 120.22,60.49 120.37,60.65 121.77,60.65
GND on BOTTOM (solid shape): 150.21,56.38 150.21,54.4 150.04,54.22 149.33,54.22 149.12,54.42 149.12,56.4 149.15,56.43 150.16,56.43
GND on BOTTOM (solid shape): 154.62,47.4 154.62,46.8 154.52,46.7 153.01,46.7 152.8,46.9 152.8,47.34 152.98,47.51 154.51,47.51
GND on BOTTOM (solid shape): 164.84,49.82 164.84,49.17 164.69,49.02 162.98,49.02 162.63,49.37 162.63,50.03 162.99,50.38 164.28,50.38
GND on BOTTOM (solid shape): 168.73,50.21 168.73,49.29 168.53,49.09 167.13,49.09 167.03,49.19 167.03,50.21 167.17,50.35 168.59,50.35
GND on BOTTOM (solid shape): 14.65,13.05 12.14,13.05 12.01,13.17 12.01,13.68 12.37,14.04 14.65,14.04
GND on BOTTOM (solid shape): 134.68,28.32 134.68,27.91 134.6,27.84 133.92,27.84 133.16,28.59 133.16,28.85 133.29,28.98 134.02,28.98
GND on BOTTOM (solid shape): 158.07,109.78 158.07,108.58 157.84,108.35 156.11,108.35 155.76,108.7 155.76,109.78 156.14,110.16 157.69,110.16
GND on BOTTOM (solid shape): 13.41,63.82 13.41,62.32 13.31,62.22 12.34,62.22 12.14,62.42 12.14,63.41 12.6,63.87 13.36,63.87
GND on BOTTOM (solid shape): 16.25,72.99 16.25,70.98 16.08,70.81 15.75,70.81 15.62,70.93 15.62,73.12 15.7,73.19 16.05,73.19
GND on BOTTOM (solid shape): 20.65,69.43 20.65,69.18 20.52,69.05 20.06,69.05 19.86,69.26 19.1,69.26 19.05,69.31 19.05,70.22 19.21,70.39 19.7,70.39
GND on BOTTOM (solid shape): 29.65,26.31 29.65,25.51 29.6,25.46 28.63,25.46 28.42,25.67 28.42,26.36 28.49,26.43 29.53,26.43
GND on BOTTOM (solid shape): 35.43,19.85 35.43,19.04 35.32,18.93 34.22,18.93 34.16,18.99 34.16,19.9 34.26,20.01 35.28,20.01
GND on BOTTOM (solid shape): 57.09,23.19 57.09,20.87 56.98,20.76 55.53,20.76 55.48,20.8 55.48,22.19 55.47,22.2 55.47,23.56 55.6,23.69 56.59,23.69
GND on BOTTOM (solid shape): 90.5,24.5 90.5,23.71 90.37,23.59 89.11,23.59 88.91,23.79 88.91,24.72 89.13,24.93 90.07,24.93
GND on BOTTOM (solid shape): 92.52,59 92.52,57.58 92.34,57.39 91.41,57.39 91.37,57.44 91.37,58.83 91.72,59.18 92.35,59.18
GND on BOTTOM (solid shape): 94.32,43.17 94.32,42.31 94.24,42.24 92.47,42.24 92.16,42.54 91.68,42.54 91.6,42.62 91.6,43.44 91.84,43.68 93.81,43.68
GND on BOTTOM (solid shape): 97.69,151.83 97.69,150.43 96.45,149.19 91.44,149.19 91.14,148.9 90.23,148.9 90.23,151.24 90.94,151.95 97.56,151.95
GND on BOTTOM (solid shape): 97.71,24.96 97.71,23.97 97.48,23.74 96.24,23.74 95.63,24.35 95.63,25.11 95.83,25.31 97.36,25.31
GND on BOTTOM (solid shape): 101.9,150.95 101.9,148.6 101.78,148.48 101.14,148.48 101.09,148.53 101.09,150.96 101.26,151.12 101.72,151.12
GND on BOTTOM (solid shape): 143.95,29.56 143.95,27.51 143.44,27 142.78,27 142.43,27.35 142.43,29.59 142.73,29.89 143.62,29.89
GND on BOTTOM (solid shape): 146.77,30.1 146.77,22.02 146.39,21.64 144.84,21.64 144.28,22.2 144.28,29.69 144.93,30.34 146.53,30.34
GND on BOTTOM (solid shape): 148.5,87.18 148.5,86.71 147.51,85.71 147.17,85.71 147.04,85.84 147.04,86.4 147.88,87.24 148.44,87.24
GND on BOTTOM (solid shape): 9.09,63.16 9.09,62.78 8.93,62.62 8.9,62.6 8.86,62.58 6.34,62.58 6.3,62.63 6.3,63.21 6.37,63.29 8.96,63.29
GND on BOTTOM (solid shape): 18.46,63.73 18.46,62.69 18.32,62.56 16.85,62.56 16.79,62.62 16.79,63.57 16.98,63.75 16.98,63.75 17.06,63.83 18.36,63.83
GND on BOTTOM (solid shape): 39.39,20.16 39.39,19.12 39.36,19.08 36.58,19.08 36.41,19.25 36.41,20.48 36.52,20.59 38.96,20.59
GND on BOTTOM (solid shape): 128.55,70.58 128.55,69.59 128.47,69.51 127.99,69.51 127.94,69.56 127.94,70.25 127.58,70.6 127.58,71.06 127.71,71.19 127.94,71.19
GND on BOTTOM (solid shape): 54.97,94.43 54.97,94.02 54.23,93.28 53.9,93.28 53.41,93.77 53.41,94.38 53.51,94.47 54.93,94.47
GND on BOTTOM (solid shape): 61.31,151.78 61.31,151.07 61.06,150.82 61.06,150 60.91,149.85 60.17,149.85 59.84,150.18 59.84,151.81 59.94,151.91 61.19,151.91
GND on BOTTOM (solid shape): 99.72,50.61 99.72,50.1 99.95,49.88 99.95,48.91 99.9,48.86 99.26,48.86 99.19,48.94 99.19,50.56 99.29,50.66 99.67,50.66
GND on BOTTOM (solid shape): 102.06,41.7 102.06,41.11 101.9,40.96 100.46,40.96 100.38,41.04 100.38,41.29 100.53,41.44 100.66,41.44 101.07,41.85 101.9,41.85
GND on BOTTOM (solid shape): 127.46,59.48 127.46,59.17 127.33,59.04 127.07,59.04 126.95,59.17 126.95,59.39 126.73,59.6 126.29,59.6 126.26,59.63 126.26,60.09 126.31,60.14 126.8,60.14
GND on BOTTOM (solid shape): 139.2,19 139.2,15.53 138.34,14.67 137.36,14.67 136.88,15.15 136.88,19.4 137.22,19.74 138.45,19.74
GND on BOTTOM (solid shape): 143.66,60.87 143.66,59.1 143.51,58.94 143.36,58.94 143.23,58.94 142.95,59.22 142.95,60.85 143.03,60.92 143.61,60.92
GND on BOTTOM (solid shape): 62.29,62.41 62.55,62.41 62.7,62.26 62.7,60.25 62.56,60.11 61.48,60.11 61.05,60.54 61.05,62.46 61.21,62.63 62.08,62.63
GND on BOTTOM (solid shape): 83.16,149.14 82.73,148.71 79.55,148.71 79.4,148.55 79.07,148.55 78.92,148.71 78.92,149.8 79.09,149.98 83.16,149.98
GND on BOTTOM (solid shape): 114.12,32.6 114.12,32.27 113.95,32.1 113.52,32.1 113.37,31.95 112.51,31.95 112.48,31.98 112.48,32.72 112.6,32.83 113.89,32.83
GND on BOTTOM (solid shape): 49.55,96.69 49.55,95.6 49.5,95.54 49.22,95.54 49.11,95.56 48.99,95.54 48.66,95.54 48.61,95.6 48.61,96.71 48.74,96.84 49.4,96.84
GND on BOTTOM (solid shape): 150.7,67.55 150.7,66.97 150.62,66.89 148.74,66.89 148.61,67.02 148.61,67.5 148.69,67.58 148.89,67.58 149.01,67.59 149.12,67.63 150.62,67.63
GND on BOTTOM (solid shape): 61.03,139.93 61.03,139 60.96,138.93 60.3,138.93 59.79,139.44 59.79,139.88 59.76,139.91 59.76,140.06 59.61,140.06 59.49,140.17 59.49,140.17 59.33,140.33 59.33,140.6 59.41,140.68 60.28,140.68
GND on BOTTOM (solid shape): 126.88,19.92 126.88,16.75 127.1,16.54 127.1,15.23 126.97,15.1 125.8,15.1 125.34,15.56 125.34,17.59 125.17,17.76 124.56,17.76 124.47,17.85 124.47,19.91 124.94,20.38 126.42,20.38
GND on BOTTOM (solid shape): 138.85,58.87 138.94,58.79 139.04,58.74 139.34,58.44 139.34,57.44 139.32,57.42 138.76,57.42 138.73,57.44 138.73,58.28 138.53,58.49 138.53,58.71 138.68,58.87
GND on BOTTOM (solid shape): 134.9,50.76 134.9,49.57 134.88,49.55 134.4,49.55 134.38,49.58 134.38,49.99 134.55,50.17 134.55,50.56 134.27,50.84 134.03,50.84 133.91,50.97 133.91,51.27 134.01,51.37 134.29,51.37
GND on BOTTOM (solid shape): 136.67,108.86 136.67,106.91 136.45,106.69 135.03,106.69 134.72,106.39 132.44,106.39 132.26,106.57 132.26,108.68 132.38,108.8 133.73,108.8 134.38,109.45 136.08,109.45
GND on BOTTOM (solid shape): 155.9,60.85 155.9,60.62 156.36,60.16 156.36,59.48 156.26,59.38 155.98,59.38 155.89,59.46 155.89,59.88 155.51,60.26 154.84,60.26 154.79,60.31 154.79,60.9 154.84,60.95 155.8,60.95
GND on BOTTOM (solid shape): 52.04,98.33 52.04,97.28 52.02,97.26 50.63,97.26 50.57,97.32 50.57,98.12 50.65,98.24 50.69,98.38 50.82,98.52 51.85,98.52
GND on BOTTOM (solid shape): 96.87,14.01 96.87,13.07 97.04,12.91 97.04,9.27 96.7,8.93 96.49,8.93 96.34,9.08 96.34,13.26 95.82,13.78 95.47,13.78 95.35,13.9 95.35,14.29 95.58,14.52 96.37,14.52
GND on BOTTOM (solid shape): 109.17,152.03 110.12,152.03 110.14,152.01 110.14,149.66 109.74,149.26 106.44,149.26 105.77,148.59 105.25,148.59 105.02,148.83 105.02,151.63 105.4,152.02 106.84,152.02 107.68,152.86 108.34,152.86
GND on BOTTOM (solid shape): 165.2,110.73 165.2,108.07 165.07,107.94 163.55,107.94 162.91,107.3 162.91,101.84 162.28,101.21 162.28,99.02 161.54,98.29 161.54,97.55 161.39,97.4 160.5,97.4 159.99,97.91 159.99,106.89 164.09,110.99 164.95,110.99
GND on BOTTOM (solid shape): 20.19,23.93 20.19,21.24 19.89,20.94 19.89,20.07 20.19,19.77 20.19,19.58 20.04,19.43 19.26,19.43 19.01,19.68 16.63,19.68 16.62,19.68 15.86,19.68 15.73,19.81 15.73,24.03 15.86,24.15 19.97,24.15
GND on BOTTOM (solid shape): 87.31,37.98 87.31,35.3 87.23,35.22 85.07,35.22 84.48,34.64 84.48,34.02 82.71,34.02 82.36,34.37 82.36,36.44 83.08,37.17 83.08,38.7 83.55,39.16 84.49,39.16 84.49,39.93 84.56,40.01 85.29,40.01
GND on BOTTOM (solid shape): 115.72,62.65 116.74,62.65 117.27,62.12 117.27,61.25 117.22,61.2 116.61,61.2 116.58,61.23 116.58,61.84 116.43,61.99 115.82,61.99 115.66,61.83 115.56,61.83 115.39,61.66 114.91,61.66 114.88,61.69 114.88,62.8 114.91,62.83 115.54,62.83
GND on BOTTOM (solid shape): 51.69,135.55 51.69,134.3 51.55,134.04 51.56,133.75 51.56,133.74 51.56,133.49 51.43,133.37 51.13,133.37 50.98,133.52 50.98,135.5 51.15,135.68 51.56,135.68
GND on BOTTOM (solid shape): 117.51,150.17 117.51,149.74 117.68,149.57 117.68,148.48 117.6,148.4 117.6,148.07 117.61,148.04 117.63,147.97 117.61,147.9 117.61,147.9 117.48,147.76 116.82,147.76 116.82,147.77 116.82,151.37 116.93,151.48 117.51,151.48
GND on BOTTOM (solid shape): 159.94,125.75 159.94,125.19 159.79,125.03 159.54,125.03 159.41,125.16 159.41,125.66 159.01,126.06 158.95,126.18 158.98,126.31 159.03,126.39 159.03,126.41 159.28,126.41
GND on BOTTOM (solid shape): 62.13,106.9 62.3,106.9 62.43,106.77 62.69,106.77 62.76,106.7 62.76,105.81 62.63,105.68 62.48,105.68 62.3,105.86 59.95,105.86 59.79,106.02 59.79,106.47 59.97,106.64 61.44,106.64 61.77,106.97 62.05,106.97
GND on BOTTOM (solid shape): 48.11,50.94 48.11,50.66 48.65,50.12 51.81,50.12 51.86,50.07 51.89,50.04 51.99,49.94 51.99,46.78 51.87,46.65 48.46,46.65 48.41,46.7 48.41,49.52 47.5,50.43 47.5,50.89 47.62,51.02 48.03,51.02
GND on BOTTOM (solid shape): 133.17,112.84 133.18,112.79 133.2,112.75 133.2,112.41 133.14,112.21 133.2,112.01 133.2,111.83 133.27,111.75 133.27,110.68 133.17,110.58 129.49,110.58 129.28,110.78 129.28,112.79 129.59,113.1 132.92,113.1
GND on BOTTOM (solid shape): 20.21,10.92 20.21,10.86 20.21,10.8 20.21,6.81 22.59,6.81 22.59,6.31 20.2,6.31 19.85,6.45 19.71,6.8 19.71,10.8 19.71,10.86 19.7,10.92
GND on BOTTOM (solid shape): 128.42,56.63 128.42,55.62 127.84,55.03 127.3,55.03 127.15,55.18 127.15,55.51 127.2,55.57 127.66,55.57 127.86,55.77 127.86,55.81 127.89,55.9 127.9,56 127.9,56.34 127.79,56.45 127.1,56.45 127.05,56.5 127.05,56.94 127.13,57.01 128.04,57.01
GND on BOTTOM (solid shape): 117.37,57.52 117.37,55.82 116.61,55.06 116,55.06 115.87,55.18 115.87,55.51 115.95,55.59 116.05,55.59 116.4,55.63 116.59,55.93 116.74,56.07 116.74,57.52 116.81,57.6 117.3,57.6
GND on BOTTOM (solid shape): 116,13.78 117.3,13.78 121.86,9.22 125.54,9.22 125.54,9.21 126.33,9.21 126.52,9.03 126.53,9.03 126.65,8.9 127.45,8.9 127.75,9.2 127.75,9.7 129.25,9.7 129.88,9.07 129.88,7.63 129.84,7.58 112.07,7.58 110.01,9.64 101.95,9.64 101.95,11.29 102.72,12.05 104.15,12.05 105.09,12.99 106.98,14.88 106.98,15.2 107.14,15.36 114.43,15.36
GND on BOTTOM (solid shape): 42.42,98.54 42.42,97.82 42.33,97.74 41.92,97.74 41.73,97.55 41.53,97.47 41.4,97.3 41.15,97.3 40.98,97.47 40.98,98 41.32,98.34 41.51,98.34 41.62,98.45 41.66,98.48 41.7,98.52 41.72,98.56 41.81,98.64 42.31,98.64
GND on BOTTOM (solid shape): 99.95,61.2 99.95,59.73 99.08,58.87 98.7,58.87 98.6,58.97 98.6,59.25 98.73,59.38 98.84,59.38 99.28,59.48 99.35,59.93 99.34,59.97 99.34,60.09 99.31,60.11 99.31,61.18 99.36,61.23 99.92,61.23
GND on BOTTOM (solid shape): 131.62,151.44 131.62,150.59 131.6,150.56 130.35,150.56 129.94,150.15 129.94,148.72 129.87,148.65 129.42,148.65 129.26,148.8 123.72,148.8 123.47,148.56 122.1,148.56 121.3,149.35 121.3,151.11 121.41,151.21 122.72,151.21 122.79,151.15 124.15,151.15 124.21,151.21 126.29,151.21 126.89,151.81 127.4,151.81 127.55,151.66 129.94,151.66 129.95,151.67 130.37,151.67 130.62,151.92 131.14,151.92
GND on BOTTOM (solid shape): 56.21,90.11 56.21,89.7 56.21,89.62 56.21,88.38 55.6,87.77 54.96,87.77 54.81,87.62 52.12,87.62 52.05,87.66 51.96,87.68 51.08,88.56 50.27,88.56 50.19,88.64 50.19,88.97 50.32,89.09 51.36,89.09 51.76,88.69 53.95,88.69 54.05,88.79 55.42,88.79 55.5,88.86 55.5,88.98 55.51,89 55.51,90.12 55.6,90.21 56.11,90.21
GND on BOTTOM (solid shape): 30.17,116.12 30.17,115.56 30.3,115.43 31.95,115.43 32.15,115.23 32.15,114.51 31.49,113.85 30.96,113.85 30.79,113.9 30.62,113.9 30.41,113.9 30.23,113.82 30.1,113.76 29.99,113.68 29.01,113.68 28.24,114.44 28.24,115.05 28.24,115.33 28.73,115.33 29.59,116.19 30.1,116.19
GND on BOTTOM (solid shape): 116.15,75.96 116.15,72.79 115.85,72.48 115.64,72.48 115.36,72.61 115.08,72.51 113.38,72.51 113.36,72.5 113.12,72.5 113.09,72.54 113.09,72.73 113.19,72.83 113.19,73.05 113.17,73.08 113.09,73.16 113.09,73.34 113.18,73.44 113.42,73.44 113.71,73.44 113.82,73.55 113.82,76.04 113.89,76.11 116,76.11
GND on BOTTOM (solid shape): 93.47,50.84 93.47,50.68 93.37,50.4 93.48,50.13 93.48,49.86 93.72,49.62 93.72,48.58 93.98,48.33 93.98,47.16 93.63,46.81 93.6,46.79 92.38,46.79 92.38,47.17 92.79,47.58 92.79,47.96 92.87,48.04 92.87,48.86 92.79,48.95 92.79,50.4 92.91,50.53 92.91,50.92 93.01,51.02 93.29,51.02
GND on BOTTOM (solid shape): 135.24,24.88 135.37,24.88 135.4,24.85 135.4,24.07 135.91,23.56 136.06,23.56 136.06,23.56 137.44,23.56 137.64,23.36 137.64,22.75 137.51,22.62 137.07,22.62 137.02,22.57 136.76,22.57 136.5,22.65 136.24,22.57 133.94,22.57 132.69,23.82 132.69,24.23 132.71,24.37 132.69,24.51 132.9,24.71 133.87,24.71 134.04,24.88 135.24,24.88
GND on BOTTOM (solid shape): 110.18,56.48 110.18,55.54 109.75,55.11 109.22,55.11 109.1,55.22 109.1,55.48 109.23,55.61 109.29,55.61 109.38,55.6 109.48,55.61 109.49,55.62 109.78,56.12 109.27,56.4 109.12,56.55 109.12,57 109.21,57.09 109.57,57.09
GND on BOTTOM (solid shape): 69.03,49.81 69.03,48.32 69.03,48.32 69.03,47.63 68.39,46.99 68.39,45.76 68.47,45.68 69.15,45.68 69.17,45.67 69.17,45.48 69.16,45.47 68.48,45.47 68.39,45.38 68.39,44.2 68.58,44.01 68.96,44.01 69.52,43.45 69.67,43.22 70.23,43.22 70.31,43.14 70.31,42.66 70.07,42.43 68.59,42.43 68.55,42.47 68.55,43.5 68.41,43.64 68.29,43.64 67.64,44.28 67.64,47.42 67.33,47.73 67.33,50.1 67.38,50.15 68.68,50.15
GND on BOTTOM (solid shape): 132.13,50.46 132.13,49.29 132.89,48.53 132.89,47.56 132.71,47.39 131.62,47.39 131.55,47.46 131.55,47.51 131.53,47.52 131.54,47.55 130.95,47.98 130.95,47.25 130.95,46.4 128.57,46.4 128.45,46.52 128.45,49.9 128.5,49.95 131.14,49.95 131.44,50.26 131.44,50.41 131.7,50.66 131.93,50.66
GND on BOTTOM (solid shape): 16.55,171.79 16.66,171.68 16.81,171.64 17.15,171.64 17.15,168.82 9.78,168.82 9.27,169.34 2.78,169.34 2.23,168.79 2.23,160.27 3.02,159.48 3.02,158.03 2.34,157.35 2.25,157.35 2.2,157.3 2.2,153.84 3.02,153.02 3.02,151.25 2.68,150.91 2.68,150.37 2.56,150.26 2.56,149.47 2.31,149.21 1.26,149.21 1.01,148.97 1.01,141.17 0.84,140.68 0.71,140.18 0.6,140.1 0.51,140.2 0.51,171.3 0.65,171.65 1,171.79
GND on BOTTOM (solid shape): 94.13,71.79 94.11,71.78 94.11,70.96 94.06,70.9 93.68,70.89 93.47,70.58 93.67,70.18 94.11,70.21 94.18,70.23 94.24,70.2 94.39,70.1 94.55,70.05 94.62,70.02 94.65,69.95 94.65,68.83 94.62,68.81 93.06,68.81 92.91,68.95 92.91,71.9 93.19,72.18 93.74,72.18
GND on BOTTOM (solid shape): 68.06,5.31 68.15,5.14 68.27,4.98 68.3,4.87 68.2,4.81 66.3,4.81 65.28,4.41 64.8,3.44 64.79,3.43 64.79,1 64.65,0.65 64.3,0.51 62.93,0.51 46.86,0.51 46.86,1.01 51.88,1.01 51.88,3.86 53.07,5.05 62.24,5.05 62.25,5.05 65.31,5.05 65.79,5.25 66.3,5.31
GND on BOTTOM (solid shape): 43.31,46.19 43.31,45.35 43.23,45.28 43.08,45.28 43.07,45.28 42.87,45.28 42.87,45.28 42.49,45.28 42.42,45.21 42.39,45.21 42.19,45.01 42.19,44.98 42.16,44.96 42.16,41.89 42.34,41.71 42.34,39.63 42.19,39.48 40.65,39.48 40.5,39.63 40.5,40.49 40.46,40.53 40.46,41.19 41.03,41.76 41.28,41.76 41.42,41.91 41.42,43.15 41.29,43.28 40.66,43.28 40.66,43.47 41.26,43.47 41.42,43.64 41.42,44.87 41.25,45.05 41.25,45.05 41.12,45.18 41.12,45.94 41.43,46.24 41.51,46.24 41.58,46.21 41.61,46.13 42.03,45.66 42.4,46.17 42.41,46.21 42.44,46.24 42.48,46.25 43.25,46.25
GND on BOTTOM (solid shape): 114.11,118.41 114.11,118.21 114.1,118.21 114.08,118.06 114.1,117.92 114.11,117.91 114.11,117.81 114.3,117.62 114.32,117.62 114.33,117.61 114.55,117.54 114.77,117.58 114.8,117.59 115.23,117.17 115.23,110.51 116.11,109.63 117.9,109.63 117.91,109.62 118.86,109.62 119.21,109.28 119.21,108.18 119.15,108.05 119.13,107.91 119.15,107.77 119.21,107.63 119.21,106.67 118.72,106.18 112.43,106.18 112.28,106.33 112.28,106.66 112.97,106.66 112.97,107.58 112.28,107.58 112.28,107.76 112.29,107.78 112.37,108.05 112.28,108.32 112.28,112.85 113.13,113.7 113.13,115.69 113.39,115.95 113.39,118.04 113.4,118.05 113.42,118.18 113.4,118.32 113.39,118.33 113.39,118.59 113.42,118.61 113.9,118.61
GND on BOTTOM (solid shape): outline of 91 points within 93.6,28.09 98.58,30.72
GND on BOTTOM (solid shape): outline of 88 points within 43.43,46.51 46.89,50.84
GND on BOTTOM (solid shape): outline of 92 points within 59.13,146.53 61.42,149.65
GND on BOTTOM (solid shape): outline of 101 points within 130.38,142.03 135.05,146.9
GND on BOTTOM (solid shape): outline of 224 points within 161.86,128.98 168.76,136.98
GND on BOTTOM (solid shape): outline of 234 points within 161.86,86.98 169.49,94.98
GND on BOTTOM (solid shape): outline of 244 points within 9.46,78.74 16.44,85.72
GND on BOTTOM (solid shape): outline of 244 points within 9.46,28.74 16.44,35.72
GND on BOTTOM (solid shape): outline of 244 points within 40.46,22.81 47.44,29.79
GND on BOTTOM (solid shape): outline of 252 points within 2.11,134.74 10.59,143.22
GND on BOTTOM (solid shape): outline of 252 points within 152.7,151.24 161.18,159.73
GND on BOTTOM (solid shape): outline of 252 points within 160.76,13.06 169.24,21.54
GND on BOTTOM (solid shape): outline of 255 points within 75.86,128.98 83.86,136.98
GND on BOTTOM (solid shape): outline of 266 points within 0.51,10.81 19.63,137.86
GND on BOTTOM (solid shape): outline of 289 points within 75.5,42.28 85.5,52.28
GND on BOTTOM (solid shape): outline of 340 points within 124.25,106.21 126.98,117.92
GND on BOTTOM (solid shape): outline of 873 points within 35.07,4.81 169.49,171.79
GND on GND (solid shape): outline of 4146 points within 0.51,0.51 169.49,171.79
GND on IN1 (solid shape): 169,171.79 169.35,171.65 169.49,171.3 169.49,92.69 169.26,93.11 168.99,93.5 168.99,127.8 168.98,127.8 168.98,131.31 168.43,131.87 168.43,133.92 168.99,134.48 168.99,171.29 35.57,171.29 35.57,168.98 35.07,168.98 35.07,171.64 35.41,171.64 35.56,171.68 35.67,171.79
GND on IN1 (solid shape): 68.06,5.31 68.15,5.14 68.27,4.98 68.3,4.87 68.2,4.81 66.3,4.81 65.28,4.41 64.8,3.44 64.79,3.41 64.79,1.57 64.79,1.56 64.79,1 64.78,0.88 64.73,0.76 64.72,0.75 64.54,0.57 64.3,0.51 46.86,0.51 46.86,1.01 51.88,1.01 51.88,3.88 53.04,5.05 65.31,5.05 65.79,5.25 66.3,5.31
GND on IN1 (solid shape): 169.49,13.3 169.35,12.95 169,12.81 160,12.81 158.93,12.37 158.49,11.3 158.49,9.3 158.35,8.95 158,8.81 142.76,8.81 141.72,8.71 140.72,8.41 137.51,7.13 136.69,6.89 135.84,6.81 110.01,6.81 110.01,7.8 109.71,8.51 109,8.81 101,8.81 100.29,8.51 99.99,7.8 99.99,6.81 74.8,6.81 74.09,6.51 73.79,5.8 73.79,4.81 69.4,4.81 69.3,4.87 69.33,4.98 69.45,5.14 69.54,5.31 73.29,5.31 73.29,5.8 73.73,6.87 74.8,7.31 99.49,7.31 99.49,7.8 99.93,8.87 101,9.31 109,9.31 110.07,8.87 110.51,7.8 110.51,7.31 135.84,7.31 136.59,7.39 137.32,7.6 140.53,8.88 141.63,9.2 142.76,9.31 157.99,9.31 157.99,11.51 158,11.52 158.66,12.8 160,13.31 168.99,13.31 168.99,61.75 169.18,62.3 168.99,62.84 168.99,72.57 169.37,73.3 168.99,74.03 168.99,88.46 169.26,88.85 169.49,89.27
GND on IN1 (solid shape): outline of 544 points within 0.51,6.31 22.59,171.79
GND on IN2 (solid shape): 169,171.79 169.35,171.65 169.49,171.3 169.49,92.69 169.26,93.11 168.99,93.5 168.99,127.95 168.98,127.96 168.98,131.31 168.43,131.87 168.43,133.92 168.99,134.48 168.99,171.29 35.57,171.29 35.57,168.98 35.07,168.98 35.07,171.64 35.41,171.64 35.56,171.68 35.67,171.79
GND on IN2 (solid shape): 68.06,5.31 68.15,5.14 68.27,4.98 68.3,4.87 68.2,4.81 66.3,4.81 65.35,4.47 64.82,3.61 64.81,3.52 64.79,3.3 64.79,1.57 64.79,1.56 64.79,1 64.78,0.9 64.75,0.81 64.75,0.8 64.57,0.59 64.3,0.51 46.86,0.51 46.86,1.01 51.9,1.01 51.9,3.88 52.54,4.52 52.54,4.54 52.56,4.54 53.07,5.05 65.31,5.05 65.79,5.25 66.3,5.31
GND on IN2 (solid shape): 169.42,88.96 169.49,88.87 169.49,13.3 169.35,12.95 169,12.81 160,12.81 158.93,12.37 158.49,11.3 158.49,11.11 158.49,10.11 158.49,9.3 158.35,8.95 158,8.81 142.76,8.81 141.72,8.71 140.72,8.41 137.51,7.13 136.69,6.89 135.84,6.81 110.01,6.81 110.01,7.8 109.71,8.51 109,8.81 101,8.81 100.29,8.51 99.99,7.8 99.99,6.81 74.8,6.81 74.09,6.51 73.79,5.8 73.79,4.81 69.4,4.81 69.3,4.87 69.33,4.98 69.45,5.14 69.54,5.31 73.29,5.31 73.29,5.8 73.73,6.87 74.8,7.31 99.49,7.31 99.49,7.8 99.93,8.87 101,9.31 109,9.31 110.07,8.87 110.51,7.8 110.51,7.31 135.84,7.31 136.59,7.39 137.32,7.6 140.53,8.88 141.63,9.2 142.76,9.31 157.99,9.31 157.99,11.53 158,11.55 158.67,12.81 160,13.31 168.99,13.31 168.99,61.75 169.18,62.3 168.99,62.84 168.99,72.57 169.37,73.3 168.99,74.03 168.99,88.46 169.15,88.69 169.3,88.92
GND on IN2 (solid shape): outline of 530 points within 0.51,6.31 22.59,171.79
GND on VCC (solid shape): outline of 4244 points within 0.51,0.51 169.49,171.79
GND_AUDIO on TOP (solid shape): 46.12,9.26 46.12,8.37 46.05,8.3 45.08,8.3 45.01,8.37 45.01,9.29 45.11,9.39 46,9.39
GND_AUDIO on TOP (solid shape): 46.15,10.3 46.15,9.67 46.07,9.59 45.08,9.59 45.01,9.67 45.01,10.61 45.11,10.71 45.74,10.71
GND_AUDIO on TOP (solid shape): 31.53,18.17 31.53,17.45 31.47,17.39 31.22,17.39 30.82,17.79 30.26,17.79 30.19,17.86 30.19,18.11 30.48,18.4 31.31,18.4
GND_AUDIO on TOP (solid shape): 17.8,15.81 17.8,14.96 17.45,14.6 14.55,14.6 14.32,14.82 14.32,15.61 14.43,15.72 15.41,15.72 15.54,15.85 17.77,15.85
GND_AUDIO on TOP (solid shape): 45.16,17.13 45.16,16.22 45.19,16.2 45.41,16.2 45.52,16.09 45.52,15.82 45.46,15.77 44.52,15.77 44.43,15.85 44.43,17.03 44.59,17.19 45.11,17.19
GND_AUDIO on TOP (solid shape): 30.81,15.69 30.81,14.98 30.73,14.9 29.77,14.9 29.6,14.73 29.6,13.69 29.59,13.68 28.85,13.68 28.79,13.74 28.79,15.25 29.28,15.74 30.76,15.74
GND_AUDIO on TOP (solid shape): 15.38,19.14 15.38,18.94 14.7,18.26 14.7,17.6 14.66,17.57 14.25,17.57 14.23,17.59 14.23,18.54 14.96,19.27 15.26,19.27
GND_AUDIO on TOP (solid shape): outline of 285 points within 23.1,0.51 33.68,12.81
GND_AUDIO on TOP (solid shape): outline of 437 points within 33.86,0.51 46.34,12.57
GND_AUDIO on BOTTOM (solid shape): 14.73,14.6 11.45,14.6 11.38,14.67 11.38,15.1 12.25,15.1 12.25,15.1 14.02,15.1 14.13,15.21 14.73,15.21
GND_AUDIO on BOTTOM (solid shape): 17.47,18.09 17.31,17.92 17.29,17.91 16.87,17.91 16.81,17.96 16.81,18.51 16.54,18.78 15.15,18.78 14.96,18.98 14.96,19.21 15.09,19.34 17.47,19.34
GND_AUDIO on BOTTOM (solid shape): 39.34,18 39.34,17.57 39.6,17.31 39.6,17.21 39.42,17.03 39.21,17.03 39.18,17.06 38.7,17.06 38.69,17.06 38.53,17.08 38.37,17.04 38.36,17.03 38.25,17.03 38.17,17.11 37.9,17.11 37.36,17.64 36.75,17.64 36.7,17.69 36.7,18.23 36.75,18.28 39.06,18.28
GND_AUDIO on BOTTOM (solid shape): 21.89,20.34 21.89,20.23 21.87,20.09 21.89,19.94 21.89,19.73 21.86,19.68 21.83,19.62 21.41,19.62 20.98,20.06 20.96,20.06 20.95,20.06 20.75,20.13 20.54,20.11 20.51,20.09 20.45,20.16 20.45,20.67 20.56,20.78 21.45,20.78
GND_AUDIO on BOTTOM (solid shape): 11.71,24.17 11.71,23.55 11.66,23.5 11.4,23.5 11.32,23.58 10.96,23.75 10.57,23.64 10.01,23.69 9.68,23.23 8.58,22.12 8.56,22.12 8.24,21.84 8.34,21.43 8.39,21.38 8.39,19.97 8.39,19.97 8.38,19.68 8.5,19.41 8.5,16.75 8.41,16.65 8.02,16.65 7.9,16.78 7.9,23.93 8.2,24.24 11.64,24.24
GND_AUDIO on BOTTOM (solid shape): outline of 1630 points within 23.1,0.51 46.34,18.46
GND_AUDIO on GND (solid shape): outline of 519 points within 7.59,0.51 46.35,24.89
GND_AUDIO on IN1 (solid shape): outline of 1347 points within 23.1,0.51 46.34,15.86
GND_AUDIO on IN2 (solid shape): outline of 462 points within 7.86,14.63 13.06,24.89
GND_AUDIO on IN2 (solid shape): outline of 1378 points within 23.1,0.51 46.3,14.39
GND_AUDIO on VCC (solid shape): outline of 519 points within 7.59,0.51 46.35,24.89
PVDD on TOP (solid shape): 23.67,26.71 23.67,25.94 23.12,25.4 23.12,22.8 22.96,22.64 22.96,21.1 22.86,21 22.55,21 22.51,20.99 22.44,20.99 22.37,20.99 22.3,20.98 21.6,20.98 21.45,21.13 20.45,21.13 20.45,21.31 20.47,21.33 21.41,21.33 21.41,21.33 21.5,21.33 21.54,21.3 21.57,21.26 21.73,21.22 21.89,21.23 22.32,21.6 22.18,22.15 22.15,22.23 22.19,22.3 22.36,22.94 21.77,23.26 21.75,23.26 21.52,23.24 21.32,23.12 21.25,23.1 21.18,23.13 21.17,23.13 20.45,23.13 20.44,23.15 20.44,23.34 20.44,23.35 21.37,23.35 21.62,23.6 21.62,24.05 22.12,24.55 22.12,25.56 22.21,25.65 22.21,26.54 22.21,26.54 22.21,26.67 22.38,26.84 23.54,26.84
+0P95V_CPUIO on TOP (solid shape): 127.86,103.04 127.86,102.86 127.74,102.73 127.46,102.73 126.52,103.67 126.52,103.83 126.69,104 126.9,104
+0P95V_CPUIO on TOP (solid shape): outline of 86 points within 74.22,97.81 84.89,106.52
+0P95V_CPUIO on TOP (solid shape): 110.97,120.43 111.02,120.38 111.87,119.53 113.01,119.53 113.52,119.02 113.52,117.29 114.31,116.51 114.31,115.25 114.31,115.24 114.27,115.08 114.31,114.92 114.31,114.91 114.31,114.14 114.13,113.97 112.3,113.97 111.92,113.59 110.77,113.59 110.61,113.75 110.61,113.91 110.68,113.96 110.75,114.03 110.83,114.08 110.91,114.03 111.56,114 111.43,114.63 111.43,114.63 111.19,114.87 111.18,114.88 111.11,114.98 111.01,115.06 111,115.06 110.82,115.24 110.81,115.25 110.77,115.34 110.71,115.41 110.67,115.45 110.63,115.48 110.63,115.74 110.79,116.07 110.63,116.4 110.63,116.66 110.63,116.67 110.63,116.85 110.67,116.94 110.77,116.95 110.92,117.1 110.94,117.11 111.48,117.11 111.68,117.06 111.88,117.11 111.92,117.14 111.96,117.17 112.02,117.7 111.5,117.83 111.47,117.81 110.99,117.81 110.94,117.82 110.85,117.84 110.76,117.82 110.67,117.84 110.63,117.92 110.63,118.54 111.24,119.14 111.24,119.45 110.79,119.9 110.78,119.93 110.74,119.99 110.7,120.05 110.68,120.06 110.68,120.07 110.63,120.12 110.63,120.3 110.75,120.43
+0P95V_CPUIO on BOTTOM (solid shape): 81.33,101.92 81.33,100.19 81.76,99.76 84.58,99.76 84.86,99.48 84.86,97.7 84.22,97.07 79.32,97.07 78.08,98.31 78.08,102.22 78.59,102.73 80.52,102.73
+0P95V_CPUIO on BOTTOM (solid shape): 113.13,118.38 113.14,118.38 113.14,116.51 112.86,116.23 112.38,116.23 112.21,116.06 111.98,116.06 111.83,115.92 111.62,115.92 111.54,115.99 111.54,116.84 111.77,117.07 112.07,117.6 111.51,117.83 111.49,117.83 111.12,118.2 111.12,118.61 111.85,118.61 111.85,118.63 112.88,118.63
+0P95V_CPUIO on IN1 (solid shape): outline of 2594 points within 81.13,98.19 128.27,119
+1P2V_DUAL on TOP (solid shape): 136.16,25.34 136.49,25.34 136.63,25.2 136.63,24.13 136.4,23.9 135.59,23.9 134.44,25.05 134.44,25.68 135.03,26.27 135.23,26.27
+1P2V_DUAL on TOP (solid shape): outline of 141 points within 75.72,96 91.41,110.99
+1P2V_DUAL on TOP (solid shape): outline of 137 points within 140.45,13.91 154.48,22.91
+1P2V_DUAL on BOTTOM (solid shape): 122.58,42.11 122.58,40.75 122.34,40.51 121.5,40.51 121.29,40.72 121.29,41.93 121.3,41.94 121.3,42.17 121.46,42.33 122.35,42.33
+1P2V_DUAL on BOTTOM (solid shape): 137.98,26.97 137.98,25.89 137.68,25.58 137.68,25.58 137.65,25.55 137.65,24 137.45,23.8 136.05,23.8 135.74,24.12 135.74,25.01 136.04,25.31 136.37,25.31 136.75,25.69 136.75,26.05 136.89,26.19 137.68,26.19 137.75,26.26 137.75,26.32 137.76,26.32 137.78,26.34 137.78,26.97 137.8,27 137.96,27
+1P2V_DUAL on BOTTOM (solid shape): outline of 28582 points within 90.65,13.66 161.06,106.64
+1P2V_DUAL on IN2 (solid shape): outline of 279 points within 96.21,56.46 110.83,60.11
+1P2V_DUAL on IN2 (solid shape): outline of 7161 points within 110.38,41.14 161.36,63.74
+1P2V_DUAL_A_CS on BOTTOM (solid shape): 142.02,28.29 142.02,27.66 141.88,27.52 140.76,27.52 140.32,27.96 139.38,27.96 139.35,27.99 139.35,28.11 139.4,28.17 140.65,28.17 140.83,28.34 141.97,28.34
+1P2V_DUAL_A_V5IN on BOTTOM (solid shape): 142.85,32.25 142.85,31.44 142.6,31.19 142.6,30.35 141.94,29.69 141.94,28.95 141.54,28.55 140.73,28.55 140.55,28.37 139.4,28.37 139.35,28.42 139.35,28.52 139.4,28.57 140.22,28.57 141.28,29.64 141.28,29.94 141.6,30.26 141.6,30.77 141.6,30.78 141.6,31.14 141.62,31.16 141.62,31.59 141.76,31.72 142.52,31.72 142.52,32.48 142.62,32.48
+1P2V_DUAL_BST on BOTTOM (solid shape): 138.39,26.9 138.39,25.3 138.8,24.88 139.55,24.88 139.67,24.75 139.67,23.82 139.55,23.69 138.44,23.69 137.88,24.24 137.88,25.45 138.19,25.75 138.19,26.92 138.21,26.95 138.34,26.95
+1P2V_DUAL_BST_RC on BOTTOM (solid shape): 141.11,22.85 141.11,22.29 140.4,21.58 138.53,21.58 138.4,21.71 138.4,22.74 138.59,22.93 141.03,22.93
+1P2V_DUAL_HG on BOTTOM (solid shape): 138.79,26.95 138.79,26.03 139.28,25.55 139.28,25.35 139.15,25.22 138.97,25.22 138.59,25.6 138.59,26.97 138.62,27 138.74,27
+1P2V_DUAL_HG_IN on TOP (solid shape): 136.16,11.65 135.89,11.38 134.96,11.38 134.86,11.48 134.86,11.88 135.36,12.37 136.16,12.37
+1P2V_DUAL_HG_IN on BOTTOM (solid shape): 136.07,13.63 136.07,11.95 135.77,11.66 134.68,11.66 133.88,12.46 132.79,12.46 132.74,12.51 132.74,13.25 132.86,13.37 135.37,13.37 135.66,13.66 136.04,13.66
+1P2V_DUAL_LG on BOTTOM (solid shape): 140.75,26.82 140.75,26.39 140.65,26.29 140.22,26.29 139.35,27.15 139.35,27.3 139.4,27.35 140.22,27.35
+1P2V_DUAL_LG_R_D on TOP (solid shape): 135.95,18.11 135.95,16.56 136.13,16.38 136.13,14.87 136.03,14.78 135.66,14.78 135.24,15.2 135.24,16.59 135.38,16.73 135.38,18.25 135.81,18.25
+1P2V_DUAL_LG_R_D on BOTTOM (solid shape): 136.53,17.85 136.53,15.55 136.03,15.05 135.38,15.05 135.13,15.31 135.13,17.77 135.38,18.02 136.36,18.02
+1P2V_DUAL_PHASE on TOP (solid shape): 143.69,14.43 143.69,11.36 139.04,11.36 138.83,11.57 138.83,12.99 138.28,13.53 135.68,13.53 135.61,13.6 135.61,14.56 138.66,14.56 139.54,15.44 142.68,15.44
+1P2V_DUAL_PHASE on BOTTOM (solid shape): 143.15,14.97 143.15,12.21 142.41,11.47 139.86,11.47 139.18,12.16 136.47,12.16 136.47,13.66 137.08,14.26 138.4,14.26 139.37,15.23 142.89,15.23
+1P2V_DUAL_PHASE on BOTTOM (solid shape): 139.25,26.92 139.25,26.64 141.2,24.7 141.2,23.48 140.18,23.48 140.05,23.61 140.05,24.94 139.61,25.39 139.61,25.73 139.52,25.81 139.43,25.95 139.29,26.04 139,26.34 139,26.97 139.02,27 139.18,27
+1P2V_DUAL_SUR on BOTTOM (solid shape): 141.79,17.92 141.79,16.6 141.2,16.01 139.65,16.01 139.62,16.04 139.62,18.05 139.69,18.12 141.59,18.12
+1P2V_DUAL_VIN on TOP (solid shape): 135.92,13.16 138.15,13.16 138.48,12.83 138.48,11.11 138.88,10.71 139.49,10.71 139.49,9.7 139.15,9.35 133.95,9.35 133.55,9.76 133.55,11.95 133.55,11.96 134.65,11.96 134.65,11.39 134.87,11.17 135.97,11.17 136.36,11.57 136.36,12.58 135.27,12.58 134.65,11.96 133.55,11.96 132.82,12.69 132.82,12.87 133.13,13.18 135.9,13.18
+1P5V on BOTTOM (solid shape): 31.35,24.94 30.44,24.03 28.33,24.03 28.28,24.07 28.28,24.91 28.62,25.24 29.82,25.24 30.3,25.72 31.35,25.72
+1P05VSB on TOP (solid shape): 73.1,95.37 73.1,94.76 72.82,94.48 71.17,94.48 70.76,94.07 70.76,92.83 71.04,92.55 71.86,92.55 72.13,92.27 72.13,92.12 72.05,92.04 72.05,87.49 72.34,87.21 72.34,79.12 71.96,78.74 67.55,78.74 67.14,79.14 67.14,80.32 66.62,80.84 65.53,80.84 65.49,80.88 65.49,81.35 65.54,81.4 66.47,81.4 66.5,81.42 66.5,81.63 66.62,81.76 67.95,81.76 68.31,82.12 68.31,83.68 68.45,83.83 68.45,85.51 68.31,85.65 68.31,90.74 68.36,90.79 68.72,90.79 68.88,90.96 68.88,91.01 69.02,91.15 69.02,91.76 69.03,91.77 69.03,91.88 69.4,92.25 69.53,92.34 69.61,92.47 69.7,92.55 69.7,95.39 70.2,95.9 72.57,95.9
+1P05VSB on BOTTOM (solid shape): 72.95,95.67 72.95,94.43 72.21,93.69 70.51,93.69 70.33,93.87 70.33,94.5 70.43,94.6 70.43,95.47 70.18,95.72 70.18,96.21 70.28,96.31 72.31,96.31
+1P05VSB_PHASE on TOP (solid shape): 72.74,75.81 72.74,72.42 72.83,72.33 72.83,71.67 72.88,71.62 72.88,70.61 73.01,70.48 75.42,70.48 75.55,70.35 75.55,69.72 75.42,69.59 72.25,69.59 72.12,69.72 72.12,70.23 71.99,70.35 71.46,70.35 71.37,70.44 71.36,70.47 71.33,70.52 71.3,70.57 71.25,70.61 71.21,70.64 71.16,70.67 71.1,70.69 71.04,70.7 70.98,70.7 70.93,70.7 70.87,70.69 70.81,70.66 70.76,70.63 70.72,70.6 70.68,70.56 70.64,70.51 70.63,70.48 69.4,70.48 69.28,70.61 69.28,70.78 72.64,70.78 72.64,71.31 72.39,71.31 72.39,70.78 69.28,70.78 69.28,71.09 68.76,71.61 68.76,72.15 68.4,72.5 67.86,72.5 67.55,72.82 67.55,75.69 67.93,76.07 72.48,76.07
+1P05VSB_PHASE on BOTTOM (solid shape): 71.75,72.02 71.75,70.98 71.5,70.73 70.72,70.73 70.39,70.4 69.39,70.4 67.97,71.82 67.97,72.02 68.12,72.18 71.6,72.18
+1P05VSB_SUR on BOTTOM (solid shape): 74.42,72.13 74.42,70.38 74.17,70.12 72.55,70.12 72.32,70.35 72.32,71.88 72.85,72.41 74.14,72.41
+1P05VSB_VBST on TOP (solid shape): 70.59,70.21 70.7,70.01 70.91,69.9 71.24,69.57 71.84,69.57 71.89,69.52 71.89,69.39 71.87,69.36 71.42,69.36 70.7,68.65 69.47,68.65 69.43,68.69 69.43,70.18 69.48,70.23 70.58,70.23
+1P05VSB_VBST_RC on TOP (solid shape): 68.98,71.03 68.98,70.3 69.19,70.09 69.19,68.77 69.11,68.7 67.89,68.7 67.83,68.76 67.83,71.4 67.93,71.5 68.51,71.5
+1P05VSB_VIN on TOP (solid shape): 79.21,69.32 79.22,69.33 79.32,69.33 79.32,69.27 79.32,69.26 79.48,68.79 79.97,68.82 80.87,68.82 81,68.7 81,67.68 80.73,67.41 79.18,67.41 79.07,67.3 78.33,67.3 77.77,67.86 75.56,67.86 75.55,67.84 72.22,67.84 72.13,67.93 72.13,69.09 72.23,69.19 75.17,69.19 75.32,69.34 79.19,69.34
+1P8VSB on BOTTOM (solid shape): 67.41,62.32 67.41,61.92 67.21,61.71 66.8,61.71 66.36,62.16 65.72,62.16 65.66,62.09 64.24,62.09 64.13,61.99 64.13,60.24 64.16,60.21 64.72,60.21 64.72,60.11 64.36,59.76 64.36,58.44 64.05,58.13 64.01,58.12 63.96,58.11 63.32,58.11 63.32,59.72 63.51,60.01 63.4,60.34 63.38,60.38 63.4,60.41 63.51,60.74 63.33,61.04 63.33,62.72 63.76,63.16 66.57,63.16
+1P8VSB on BOTTOM (solid shape): 47.14,92.06 47.39,91.69 47.83,91.77 48.12,91.52 48.5,91.57 48.72,91.35 48.75,91.13 48.89,90.96 49.22,90.63 49.22,89.73 49.23,89.71 49.97,88.97 49.98,88.97 49.98,88.55 50.18,88.36 50.93,88.36 51.61,87.67 51.61,87.55 51.5,87.27 51.61,87 51.61,86.81 51.51,86.71 51.51,86.63 51.5,86.52 51.51,86.41 51.51,86.38 51.37,86.24 50.86,86.24 50.8,86.3 50.8,87.63 50.58,87.85 49.59,87.85 48.68,88.75 48.7,88.79 48.6,89.27 48.11,89.3 48.07,89.28 47.93,89.42 47.93,89.57 47.93,89.58 47.96,89.73 47.93,89.88 47.93,89.89 47.93,90.33 47.93,90.34 47.91,90.73 47.57,90.92 47.53,90.92 46.89,90.92 46.23,91.58 46.23,92.02 46.27,92.07 46.42,92.07 46.55,92.12 47.14,92.12
+1P8VSB on IN2 (solid shape): outline of 111 points within 66.29,61.64 70.05,65.74
+1P8VSB on IN2 (solid shape): outline of 1102 points within 50.98,81.14 67.31,88.03
+2P5VPP on TOP (solid shape): 89.42,71.47 91.91,71.47 92,71.39 92,68.54 91.73,68.54 91.73,70.46 91.67,70.53 91.01,70.53 90.96,70.47 90.96,70.17 91.01,70.12 91.49,70.12 91.49,68.54 88.85,68.54 88.8,68.49 88.42,68.49 87.64,69.27 87.64,71.52 88.32,72.21 88.68,72.21
+2P5VPP on BOTTOM (solid shape): 91.4,70.96 91.4,68.93 91.12,68.65 88.38,68.65 88.29,68.75 88.29,71.08 88.63,71.42 90.94,71.42
+2P5VPP on BOTTOM (solid shape): 92.09,57.09 92.09,55.66 91.78,55.35 90.07,55.35 89.42,56 89.42,56.45 89.48,56.66 89.42,56.88 89.42,57.1 89.5,57.17 92.01,57.17
+2P5VPP on BOTTOM (solid shape): 90.13,42.54 90.13,41.5 90.43,41.2 92.01,41.2 92.55,40.65 94.18,40.65 94.29,40.54 94.29,39.62 94.19,39.52 88.88,39.52 88.63,39.77 88.63,42.44 88.81,42.62 90.05,42.62
+2P5VPP_VREF_A on BOTTOM (solid shape): 91.27,44.05 91.27,42.41 91.4,42.29 91.98,42.29 92.67,41.6 94.22,41.6 94.29,41.53 94.29,41.04 94.22,40.97 92.54,40.97 92.03,41.48 90.76,41.48 90.51,41.73 90.51,44.01 90.76,44.26 91.06,44.26
+3P3V on TOP (solid shape): 7.48,24.6 7.48,24.37 7.42,24.32 7.42,22.37 7.42,22.37 7.42,22.32 7.39,22.29 6.98,22.29 6.93,22.34 6.93,24.66 6.94,24.67 7.41,24.67
+3P3V on TOP (solid shape): 53.88,139.75 54.98,139.75 55,139.73 55,139.5 53.83,139.5 53.81,139.47 53.81,139.27 53.83,139.25 55,139.25 55,138.99 53.83,138.99 53.78,138.94 53.78,138.76 53.81,138.74 55,138.74 55,138.53 54.98,138.51 53.5,138.51 53.3,138.71 53.3,138.89 52.98,139.2 52.98,139.7 52.92,139.77 52.54,139.77 52.44,139.87 52.44,140.16 52.53,140.25 53.39,140.25
+3P3V on TOP (solid shape): outline of 206 points within 14.3,50.64 17.84,61.56
+3P3V on BOTTOM (solid shape): 130.73,29.05 130.73,27.78 130.63,27.68 129.59,27.68 129.49,27.78 129.49,29.1 129.61,29.23 130.55,29.23
+3P3V on BOTTOM (solid shape): 113.59,48.64 113.59,47.77 112.8,46.98 112.37,46.98 112.29,47.06 112.29,47.28 112.8,47.79 112.8,48.65 112.91,48.76 113.46,48.76
+3P3V on BOTTOM (solid shape): 41.2,42.5 41.18,42.48 40.64,42.48 40.64,42.31 41.2,42.31 41.2,42.09 41.19,42.08 40.94,42.08 40.09,41.22 40.09,40.5 40.26,40.33 40.26,38.93 40.03,38.7 38.89,38.7 38.62,38.96 38.62,39.71 38.67,39.76 38.67,39.93 39.09,40.35 39.09,40.94 39.31,41.16 39.31,41.56 39.99,42.24 40.41,42.66 40.58,42.66 40.61,42.7 41.2,42.7
+3P3V on BOTTOM (solid shape): 20.52,85.48 20.52,85.46 20.56,85.14 20.8,84.91 20.8,79.36 18.64,77.21 16.99,77.21 16.6,77.6 16.6,78.11 16.61,78.12 17.38,78.96 17.95,79.94 17.96,79.95 18.01,80 18.01,80.06 18.01,80.07 18.31,80.99 18.44,81.95 16.77,86.19 12.48,87.71 12.46,87.71 12.42,87.75 12.42,88.2 12.55,88.33 17.68,88.33
+3P3V on BOTTOM (solid shape): outline of 253 points within 31.48,121.83 44.98,130.09
+3P3V on IN1 (solid shape): 53.54,140.12 53.54,139.21 53.47,139.13 52.3,139.13 52.3,140.2 52.42,140.32 53.34,140.32
+3P3V on IN1 (solid shape): 45.95,130.37 45.95,129.35 43.3,129.35 43.26,129.4 43.26,130.12 43.26,130.22 43.26,130.32 43.26,130.65 45.67,130.65
+3P3V on IN1 (solid shape): outline of 208 points within 12.65,41.37 35.61,52.64
+3P3V on IN2 (solid shape): 42.25,129.89 42.43,129.81 42.62,129.83 42.68,129.85 42.73,129.89 45.13,129.89 45.36,129.66 45.36,128.64 45.16,128.44 42.42,128.44 42.01,128.03 42.01,127.22 41.35,126.56 40.36,126.56 39.66,127.26 39.66,128.12 41.43,129.89
+3P3V on IN2 (solid shape): 36.88,41.85 38.71,41.85 40.31,40.25 40.31,37.75 40.04,37.48 37.62,37.48 36.55,38.55 33.73,38.55 32.87,39.41 32.87,40 37.51,40 37.52,39.94 37.53,39.88 37.55,39.83 37.58,39.78 37.61,39.73 37.65,39.69 37.69,39.66 37.74,39.63 37.8,39.61 37.85,39.59 37.91,39.59 37.96,39.59 38.02,39.6 38.07,39.62 38.13,39.64 38.17,39.67 38.21,39.71 38.25,39.76 38.28,39.8 38.3,39.86 38.32,39.91 38.33,39.97 38.33,40.02 38.32,40.08 38.3,40.14 38.28,40.19 38.25,40.24 38.21,40.28 38.17,40.32 38.13,40.35 38.07,40.37 38.02,40.39 37.96,40.4 37.91,40.4 37.85,40.4 37.8,40.38 37.74,40.36 37.69,40.33 37.65,40.3 37.61,40.26 37.58,40.21 37.55,40.16 37.53,40.11 37.52,40.05 37.51,40 32.87,40 32.87,42.28 32.87,42.28 33.41,42.82 35.91,42.82
+3P3V on IN2 (solid shape): 73.35,48.32 73.35,47.2 72.38,46.24 72.35,46.24 72.28,46.24 72.21,46.24 72.15,46.23 72.09,46.21 72.03,46.18 71.97,46.14 71.92,46.1 71.87,46.05 71.83,45.99 71.8,45.94 71.78,45.87 71.76,45.81 71.75,45.74 71.75,45.71 71.74,45.71 71.74,45.3 71.59,45.15 69.72,45.15 69.56,45.31 69.56,46.79 70.7,46.79 70.7,46.73 70.71,46.68 70.73,46.62 70.76,46.57 70.79,46.53 70.83,46.49 70.88,46.45 70.93,46.42 70.98,46.4 71.03,46.39 71.09,46.38 71.15,46.38 71.2,46.39 71.26,46.41 71.31,46.44 71.36,46.47 71.4,46.51 71.44,46.55 71.47,46.6 71.49,46.65 71.5,46.7 71.51,46.76 71.51,46.82 71.5,46.87 71.49,46.93 71.47,46.98 71.44,47.03 71.4,47.07 71.36,47.11 71.31,47.14 71.26,47.17 71.2,47.18 71.15,47.19 71.09,47.2 71.03,47.19 70.98,47.18 70.93,47.16 70.88,47.13 70.83,47.09 70.79,47.05 70.76,47.01 70.73,46.96 70.71,46.9 70.7,46.85 70.7,46.79 69.56,46.79 69.56,47.39 69.85,47.68 70.98,47.68 71.18,47.68 71.94,48.44 73.23,48.44
+3P3V on IN2 (solid shape): outline of 108 points within 46.71,36.06 53.94,38.92
+3P3V on IN2 (solid shape): outline of 2289 points within 12.19,59.93 33.6,123.48
+3P3V_DEBUG on TOP (solid shape): 3.88,126.62 3.88,125.47 3.73,125.31 1.47,125.31 1.45,125.34 1.45,125.82 1.52,125.9 3.1,125.9 3.2,126 3.2,126.18 3.05,126.33 1.47,126.33 1.42,126.38 1.42,126.81 1.48,126.88 3.63,126.88
+3P3V_DPC on TOP (solid shape): 110.82,164.02 111.17,164.02 111.45,163.74 112.16,163.74 112.47,164.05 112.83,164.05 113.03,163.85 113.03,163.41 112.06,162.45 111.3,162.45 110.49,163.26 109.78,163.26 109.52,163.52 109.52,163.72 109.37,163.87 108.38,163.87 108.18,164.07 108.18,165.09 108.33,165.24 109.6,165.24
+3P3V_HDD on BOTTOM (solid shape): outline of 90 points within 37.4,122.14 43.3,126.94
+3P3V_L on TOP (solid shape): 23.71,139.08 23.85,139.05 23.98,139.08 23.99,139.08 24.23,139.08 24.38,138.93 24.38,138.39 25.37,137.4 25.37,136.87 26.14,136.11 26.14,135.45 25.98,135.3 25.6,135.3 25.53,135.37 25.53,135.78 25.04,136.26 24.27,136.26 23.66,136.21 23.8,135.61 23.8,134.84 23.28,134.33 23.28,133.91 23.17,133.91 23.16,133.91 22.94,133.91 22.92,133.93 22.92,134.59 23.06,134.7 23.13,134.86 23.16,134.9 23.16,134.9 23.12,135.19 22.89,135.37 22.86,135.38 22.86,138.95 22.99,139.08 23.71,139.08
+3P3V_LDOOUT on BOTTOM (solid shape): 103.51,29.04 107.33,29.04 107.38,28.99 107.38,28.91 107.32,28.85 106.52,28.85 106.21,28.54 102.77,28.54 102.75,28.57 102.75,29.32 102.8,29.37 103.18,29.37
+3P3V_MSATA on TOP (solid shape): 25.32,115.61 25.32,112.25 25.37,112.2 25.46,112.11 25.46,107.63 23.99,106.16 23.19,106.16 23.06,106.29 22.63,106.29 22.5,106.16 21.74,106.16 21.64,106.06 21.08,106.06 21.03,106.11 21.03,107 21.31,107.28 21.31,107.33 21.59,107.33 21.61,107.3 21.74,107.3 21.79,107.36 21.79,109.01 21.59,109.01 21.59,107.33 21.31,107.33 21.31,107.4 21.32,107.41 21.32,109.18 21.71,109.58 22.39,109.58 22.43,109.56 22.51,109.52 22.59,109.48 22.68,109.46 22.77,109.44 22.86,109.43 22.95,109.42 23.04,109.43 23.13,109.44 23.22,109.46 23.31,109.49 23.39,109.52 23.47,109.56 23.55,109.61 23.62,109.67 23.69,109.73 23.75,109.8 23.81,109.87 23.86,109.95 23.9,110.03 23.93,110.11 23.96,110.2 23.98,110.29 23.99,110.38 24,110.47 24,110.56 23.99,110.65 23.97,110.74 23.94,110.83 23.91,110.91 23.87,110.99 23.82,111.07 23.76,111.14 23.7,111.21 23.67,111.24 23.67,111.29 23.39,111.57 23.39,112.97 23.77,113.35 23.95,113.35 24.08,113.48 24.08,115.46 24.31,115.69 25.25,115.69
+3P3V_MSATA on TOP (solid shape): 3.66,95.82 3.66,55.38 4.04,55 4.04,54.3 3.65,53.96 3.57,53.45 3.73,53.1 4.04,52.87 4.04,51.91 3.74,51.5 3.91,51.03 3.94,50.96 3.91,50.89 3.73,50.49 3.9,50.09 3.93,50.02 3.89,49.95 3.73,49.57 3.93,49.11 3.89,49.04 3.73,48.65 3.91,48.26 3.94,48.19 3.91,48.11 3.73,47.73 3.88,47.34 3.91,47.27 3.88,47.2 3.73,46.88 3.82,46.54 3.83,46.45 3.77,46.39 3.53,45.93 3.93,45.61 4.01,45.58 4.04,45.51 4.04,42.38 3.66,42 1.45,42 1.22,42.23 1.22,95.98 1.27,96.03 3.45,96.03
+3P3V_MSATA on TOP (solid shape): outline of 244 points within 1.22,102.61 9.09,112.64
+3P3V_MSATA on BOTTOM (solid shape): 5.69,43.6 5.96,43.6 6.63,42.93 7.58,42.93 7.97,42.53 7.97,41.19 7.35,40.57 4.38,40.57 3.2,41.75 3.2,45.3 3.5,45.61 3.68,45.61
+3P3V_MSATA on BOTTOM (solid shape): outline of 428 points within 21.92,36.46 41.17,46.14
+3P3V_WLAN on TOP (solid shape): 34.39,51.25 35.79,51.25 35.89,51.15 35.89,50.05 35.69,49.85 32.76,49.85 32.69,49.78 32.69,49.53 32.82,49.39 34.05,49.39 35.06,48.38 35.06,47.93 35.03,47.89 34.09,47.89 33.91,48.07 32.97,48.07 32.69,48.35 32.05,48.35 31.7,48.71 30.07,48.71 29.87,48.91 29.87,50.33 30.88,51.35 34.29,51.35
+3P3V_WLAN on TOP (solid shape): outline of 81 points within 52.3,50.28 56.77,53.89
+3P3V_WLAN on BOTTOM (solid shape): 67.16,51.63 67.16,50.76 66.93,50.54 64.74,50.54 64.46,50.82 64.46,51.82 64.59,51.95 66.84,51.95
+3P3V_WLAN on BOTTOM (solid shape): 70.9,49.03 70.9,47.58 69.59,46.27 68.66,46.27 68.63,46.29 68.63,46.48 68.65,46.5 69.19,46.5 69.21,46.52 69.21,46.65 69.19,46.68 68.66,46.68 68.63,46.7 68.63,46.89 68.64,46.89 69.11,47.36 69.31,47.36 69.35,47.4 69.35,48.92 69.34,48.93 69.44,49.04 70.89,49.04
+3P3V_WLAN on IN1 (solid shape): 36.85,46.65 36.85,45.28 36.65,45.07 35.91,45.07 35.03,45.96 35.03,46.32 35.13,46.32 35.13,46.26 35.14,46.21 35.16,46.15 35.19,46.1 35.22,46.06 35.26,46.02 35.31,45.98 35.35,45.95 35.41,45.93 35.46,45.92 35.52,45.91 35.58,45.91 35.63,45.92 35.69,45.94 35.74,45.97 35.78,46 35.83,46.04 35.86,46.08 35.89,46.13 35.92,46.18 35.93,46.23 35.94,46.29 35.94,46.35 35.93,46.4 35.92,46.46 35.89,46.51 35.86,46.56 35.83,46.6 35.78,46.64 35.74,46.67 35.69,46.7 35.63,46.71 35.58,46.72 35.52,46.73 35.46,46.72 35.41,46.71 35.35,46.69 35.31,46.66 35.26,46.62 35.22,46.58 35.19,46.54 35.16,46.49 35.14,46.43 35.13,46.38 35.13,46.32 35.03,46.32 35.03,47.03 34.47,47.59 34.47,47.95 34.33,48.08 34.33,48.31 34.47,48.45 35.05,48.45
+3P3V_WLAN on IN1 (solid shape): outline of 324 points within 55.35,45.97 66.98,52.45
+3P3VA on TOP (solid shape): 105.23,38.12 105.23,36.69 105.05,36.52 102.74,36.52 102.4,36.86 102.4,38.12 102.79,38.52 104.82,38.52
+3P3VA on TOP (solid shape): 119.24,28.47 119.24,24.97 119.17,24.9 117.6,24.9 117.36,25.14 117.36,28.6 117.41,28.65 119.06,28.65
+3P3VA on TOP (solid shape): 72.11,44.8 72.11,44.53 73.02,43.62 73.09,43.14 73.58,43.07 74.57,42.07 74.57,33.7 74.02,33.14 69.92,33.14 68.82,34.24 65.28,34.24 65.23,34.3 65.23,36.16 64.61,36.77 64.5,36.96 64.32,37.07 64.14,37.25 64.14,41.21 64.89,41.97 66.19,41.97 67.64,43.42 67.64,44.39 68.48,45.23 71.68,45.23
