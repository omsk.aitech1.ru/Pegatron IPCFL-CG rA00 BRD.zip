# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Text on the board (continued)
User.45: 0@@list("" "INDEXB_CROSS" list(12869.380000 792.350000) nil "0.10") | 0@@list("" "INDEXB_CROSS" list(6884.380000 1645.350000) nil "0.10") | 0@@list("" "INDEXB_CROSS" list(7309.380000 6786.350000) nil "0.10") | 0@@list("" "INDEXB_CROSS" list(9350.380000 5730.350000) nil "0.10") | 0@@list("AC1" "MX_C0402_SMALL_T01" list(7515.810000 1388.630000) nil "0.10") | 0@@list("AC100" "MX_C0805_SMALL_T02" list(7223.810000 1133.630000) nil "0.10") | 0@@list("AC12" "MX_C0603_SMALL_T01" list(7368.980000 964.350000) nil "0.10") | 0@@list("AC13" "MX_C0402_SMALL_T01" list(7371.380000 1029.350000) nil "0.10") | 0@@list("AC14" "MX_C0603_SMALL_T01" list(7652.380000 1064.350000) nil "0.10") | 0@@list("AC20" "MX_C0402_SMALL_T01" list(7796.380000 4658.350000) nil "0.10") | 0@@list("AC202" "MX_C1206_H75" list(7254.880000 1046.130000) nil "0.10") | 0@@list("AC203" "MX_C1206_H75" list(7254.810000 948.630000) nil "0.10") | 0@@list("AC204" "MX_C0402_SMALL_T01" list(7058.810000 1316.630000) nil "0.10") | 0@@list("AC205" "MX_C0402_SMALL_T01" list(7163.310000 1321.630000) nil "0.10") | 0@@list("AC206" "MX_C0402_SMALL_T01" list(6971.810000 1418.630000) nil "0.10") | 0@@list("AC207" "TX_C0805_T02_H57" list(11134.460000 6738.510000) nil "0.10") | 0@@list("AC24" "MX_C0603_SMALL_T01" list(7652.810000 1007.470000) nil "0.10") | 0@@list("AC25" "MX_C0402_SMALL_T01" list(7796.380000 4621.530000) nil "0.10") | 0@@list("AC3" "MX_C0603_SMALL_T01" list(7599.810000 1385.630000) nil "0.10") | 0@@list("AC4" "TX_C0201" list(7597.380000 1344.350000) nil "0.10") | 0@@list("AC70" "MX_C0402_SMALL_T01" list(8451.380000 4680.350000) nil "0.10") | 0@@list("AC84" "MX_C0402_SMALL_T01" list(7086.810000 1390.130000) nil "0.10") | 0@@list("AC85" "MX_C0603_SMALL_T01" list(7234.810000 1198.630000) nil "0.10") | 0@@list("AC86" "MX_C0603_SMALL_T01" list(7419.810000 967.630000) nil "0.10") | 0@@list("AC87" "MX_C0603_SMALL_T01" list(7469.810000 968.630000) nil "0.10") | 0@@list("AC90" "MX_C0603_SMALL_T01" list(7760.380000 1093.350000) nil "0.10") | 0@@list("AC92" "MX_C0603_SMALL_T01" list(7735.160000 1507.920000) nil "0.10") | 0@@list("AC93" "MX_C0402_SMALL_T01" list(7696.380000 1172.350000) nil "0.10") | 0@@list("AC94" "MX_C0402_SMALL_T01" list(7741.310000 1401.130000) nil "0.10") | 0@@list("AC95" "MX_C0603_SMALL_T01" list(7699.810000 1313.630000) nil "0.10") | 0@@list("AC96" "MX_C0402_SMALL_T01" list(7697.380000 1238.350000) nil "0.10") | 0@@list("AC97" "MX_C0402_SMALL_T01" list(7279.810000 1247.630000) nil "0.10") | 0@@list("AC98" "MX_C0402_SMALL_T01" list(7278.810000 1283.630000) nil "0.10") | 0@@list("AC99" "MX_C0805_SMALL_T02" list(7141.380000 1037.350000) nil "0.10") | 0@@list("APD1" "TX_SOD323_79X55_H45" list(9102.730000 2207.650000) nil "0.10") | 0@@list("APD2" "TX_SOD323_79X55_H45" list(9095.950000 2380.630000) nil "0.10") | 0@@list("APR115" "MX_R0402_SMALL_T01" list(9090.380000 2080.350000) nil "0.10") | 0@@list("APR119" "MX_R0402_SMALL_T01" list(7507.110000 4472.780000) nil "0.10") | 0@@list("APR120" "MX_R0402_SMALL_T01" list(9100.380000 2589.350000) nil "0.10") | 0@@list("APR124" "MX_R0402_SMALL_T01" list(9022.380000 2161.350000) nil "0.10") | 0@@list("APR125" "MX_R0402_SMALL_T01" list(7409.380000 4441.350000) nil "0.10") | 0@@list("APR126" "MX_R0402_SMALL_T01" list(7413.100000 4478.070000) nil "0.10") | 0@@list("APR132" "MX_R0402_SMALL_T01" list(8772.880000 2292.550000) nil "0.10") | 0@@list("APR133" "MX_R0402_SMALL_T01" list(8772.880000 2248.550000) nil "0.10") | 0@@list("APR136" "MX_R0402_SMALL_T01" list(9022.880000 2331.350000) nil "0.10") | 0@@list("APR137" "MX_R0402_SMALL_T01" list(9033.950000 2272.630000) nil "0.10") | 0@@list("APR142" "MX_R0402_SMALL_T01" list(7335.880000 4361.200000) nil "0.10") | 0@@list("APR143" "MX_R0402_SMALL_T01" list(7347.880000 4400.200000) nil "0.10") | 0@@list("APR144" "MX_R0402_SMALL_T01" list(7346.580000 4473.350000) nil "0.10") | 0@@list("APR46" "MX_R0402_SMALL_T01" list(7033.810000 1121.630000) nil "0.10") | 0@@list("APR5" "MX_R0402_SMALL_T01" list(8154.380000 2181.150000) nil "0.10") | 0@@list("AQ18" "TX_SOIC_6P_26_87X53_COLY" list(11079.380000 6978.350000) nil "0.10") | 0@@list("AQ19" "TX_SOIC_6P_26_87X53_COLY" list(11176.810000 6597.630000) nil "0.10") | 0@@list("AQ2" "TX_SOT23_2D4_T01_H43" list(8030.380000 964.350000) nil "0.10") | 0@@list("AQ20" "TX_SOIC_6P_26_87X53_COLY" list(9534.380000 5783.350000) nil "0.10") | 0@@list("AQ3" "TX_SOT23_2D4_T01_H43" list(7860.100000 964.780000) nil "0.10") | 0@@list("AR14" "MX_R0402_SMALL_T01" list(8331.810000 919.890000) nil "0.10") | 0@@list("AR15" "MX_R0402_SMALL_T01" list(8487.380000 981.350000) nil "0.10") | 0@@list("AR17" "MX_R0402_SMALL_T01" list(8051.380000 1065.350000) nil "0.10") | 0@@list("AR22" "MX_R0402_SMALL_T01" list(7712.810000 922.630000) nil "0.10") | 0@@list("AR23" "MX_R0402_SMALL_T01" list(7732.810000 972.620000) nil "0.10") | 0@@list("AR40" "MX_R0603_SMALL_T01" list(7687.810000 1510.630000) nil "0.10") | 0@@list("AR43" "MX_R0402_SMALL_T01" list(9775.380000 4948.350000) nil "0.10") | 0@@list("C1" "MX_C0402_SMALL_T01" list(7708.160000 4499.780000) nil "0.10") | 0@@list("C10" "MX_C0402_SMALL_T01" list(7112.380000 4519.350000) nil "0.10") | 0@@list("C11" "MX_C0603_SMALL_T01" list(7798.100000 4773.350000) nil "0.10") | 0@@list("C12" "MX_C0402_SMALL_T01" list(7413.100000 4514.920000) nil "0.10") | 0@@list("C2" "MX_C0402_SMALL_T01" list(7657.860000 4499.780000) nil "0.10") | 0@@list("C201" "MX_C0402_SMALL_T01" list(9696.380000 1041.350000) nil "0.10") | 0@@list("C204" "MX_C0402_SMALL_T01" list(11187.380000 6715.350000) nil "0.10") | 0@@list("C205" "MX_C0402_SMALL_T01" list(11620.380000 5886.350000) nil "0.10") | 0@@list("C206" "MX_C0402_SMALL_T01" list(11582.380000 5886.350000) nil "0.10") | 0@@list("C207" "MX_C0402_SMALL_T01" list(11239.380000 5923.350000) nil "0.10") | 0@@list("C248" "MX_C0402_SMALL_T01" list(7334.380000 852.350000) nil "0.10") | 0@@list("C249" "MX_C0402_SMALL_T01" list(7422.380000 861.350000) nil "0.10") | 0@@list("C2715" "TX_C0201_T009_H14" list(8036.030000 3177.450000) nil "0.10") | 0@@list("C2726" "MX_C0402_SMALL_T01" list(8059.380000 3123.350000) nil "0.10") | 0@@list("C3" "MX_C0402_SMALL_T01" list(7796.950000 4730.630000) nil "0.10") | 0@@list("C3101" "MX_C0402_SMALL_T01" list(8212.110000 6969.790000) nil "0.10") | 0@@list("C3102" "MX_C0402_SMALL_T01" list(7415.460000 6967.790000) nil "0.10") | 0@@list("C316" "MX_C0402_SMALL_T01" list(7978.380000 2238.350000) nil "0.10") | 0@@list("C3907" "MX_C0402_SMALL_T01" list(8449.380000 7028.350000) nil "0.10") | 0@@list("C4" "MX_C0603_SMALL_T01" list(7798.100000 4821.350000) nil "0.10") | 0@@list("C4000" "TX_C0201_T009_H14" list(7473.380000 5999.350000) nil "0.10") | 0@@list("C4001" "MX_C0402_SMALL_T01" list(7456.360000 5733.130000) nil "0.10") | 0@@list("C4002" "MX_C0402_SMALL_T01" list(7624.380000 5748.350000) nil "0.10") | 0@@list("C4003" "MX_C0402_SMALL_T015" list(7475.380000 5966.350000) nil "0.10") | 0@@list("C4006" "MX_C0402_SMALL_T01" list(7571.380000 5686.350000) nil "0.10") | 0@@list("C4007" "MX_C0402_SMALL_T01" list(7509.380000 5857.350000) nil "0.10") | 0@@list("C4008" "MX_C0402_SMALL_T01" list(7472.380000 5857.350000) nil "0.10") | 0@@list("C4009" "MX_C0402_SMALL_T01" list(7535.380000 5683.350000) nil "0.10") | 0@@list("C4010" "MX_C0402_SMALL_T01" list(7624.380000 5788.350000) nil "0.10") | 0@@list("C4011" "MX_C0402_SMALL_T01" list(7608.380000 5686.350000) nil "0.10") | 0@@list("C4012" "TX_C0201_T009_H14" list(7706.380000 5607.350000) nil "0.10") | 0@@list("C4013" "MX_C0603_SMALL_T02_H37" list(7478.880000 5777.350000) nil "0.10") | 0@@list("C4014" "MX_C0402_SMALL_T01" list(7545.380000 5857.350000) nil "0.10") | 0@@list("C4015" "MX_C0402_SMALL_T01" list(7499.380000 5683.350000) nil "0.10") | 0@@list("C4016" "MX_C0402_SMALL_T015" list(7658.380000 5841.350000) nil "0.10") | 0@@list("C4017" "MX_C0402_SMALL_T01" list(7620.880000 5841.350000) nil "0.10") | 0@@list("C4301" "MX_C0402_SMALL_T01" list(8532.380000 893.350000) nil "0.10") | 0@@list("C4302" "MX_C0402_SMALL_T01" list(8418.380000 857.350000) nil "0.10") | 0@@list("C4303" "MX_C0402_SMALL_T01" list(8007.380000 822.350000) nil "0.10") | 0@@list("C4304" "MX_C0402_SMALL_T01" list(8256.810000 892.630000) nil "0.10") | 0@@list("C4305" "MX_C0402_SMALL_T01" list(7794.950000 886.070000) nil "0.10") | 0@@list("C4306" "MX_C0402_SMALL_T01" list(8118.380000 863.350000) nil "0.10") | 0@@list("C4307" "MX_C0402_SMALL_T01" list(8552.380000 930.350000) nil "0.10") | 0@@list("C4308" "MX_C0402_SMALL_T01" list(8353.380000 975.350000) nil "0.10") | 0@@list("C4309" "MX_C0402_SMALL_T01" list(8088.380000 1020.850000) nil "0.10") | 0@@list("C4310" "MX_C0402_SMALL_T01" list(8242.880000 1001.350000) nil "0.10") | 0@@list("C49" "MX_C0603_SMALL_T01" list(7581.380000 6234.350000) nil "0.10") | 0@@list("C5" "MX_C0402_SMALL_T01" list(7796.380000 4694.350000) nil "0.10") | 0@@list("C6" "MX_C0402_SMALL_T01" list(7796.380000 4585.350000) nil "0.10") | 0@@list("C7" "MX_C0603_SMALL_T01" list(7798.100000 4869.350000) nil "0.10") | 0@@list("C8" "MX_C0402_SMALL_T01" list(6952.380000 4519.350000) nil "0.10") | 0@@list("C8308" "MX_C0402_SMALL_T01" list(9750.380000 1420.350000) nil "0.10") | 0@@list("C9" "MX_C0402_SMALL_T01" list(7022.380000 4519.350000) nil "0.10") | 0@@list("C941488" "MX_C0402_SMALL_T01" list(7956.380000 1633.350000) nil "0.10") | 0@@list("C941489" "MX_C0402_SMALL_T01" list(7926.380000 1577.350000) nil "0.10") | 0@@list("C941492" "MX_C0402_SMALL_T01" list(7085.380000 1132.350000) nil "0.10") | 0@@list("C941623" "MX_C0603_SMALL_T02" list(12971.880000 6958.350000) nil "0.10") | 0@@list("C941625" "MX_C0402_SMALL_T01" list(12019.380000 6883.350000) nil "0.10") | 0@@list("C941629" "MX_C0603_SMALL_T01" list(12961.380000 7048.350000) nil "0.10") | 0@@list("C941633" "MX_C0603_SMALL_T02" list(11299.810000 4888.630000) nil "0.10") | 0@@list("C941634" "MX_C0603_SMALL_T02" list(11299.810000 4833.630000) nil "0.10") | 0@@list("C941636" "MX_C0402_SMALL_T01" list(9394.380000 2225.350000) nil "0.10") | 0@@list("C941645" "MX_C0603_SMALL_T02" list(10905.380000 6899.350000) nil "0.10") | 0@@list("C941646" "MX_C0402_SMALL_T01" list(9617.380000 1001.850000) nil "0.10") | 0@@list("C941647" "MX_C0402_SMALL_T01" list(8744.380000 998.350000) nil "0.10") | 0@@list("C941648" "TX_C0603_T015_H37" list(7997.380000 1834.350000) nil "0.10") | 0@@list("C941649" "TX_C0603_T015_H37" list(7930.380000 1267.350000) nil "0.10") | 0@@list("C97" "MX_C0603_SMALL_T01" list(7494.380000 6188.350000) nil "0.10") | 0@@list("C98" "MX_C0603_SMALL_T01" list(7494.380000 6138.350000) nil "0.10") | 0@@list("CB171" "MX_C0805_SMALL_T02" list(13135.380000 3198.350000) nil "0.10") | 0@@list("CB4133" "MX_C0402_SMALL_T01" list(8679.380000 3175.550000) nil "0.10") | 0@@list("CB4134" "MX_C0402_SMALL_T01" list(8679.380000 3211.850000) nil "0.10") | 0@@list("CB4152" "MX_C0402_SMALL_T01" list(6897.380000 5499.350000) nil "0.10") | 0@@list("CM3101" "MX_CHOKE_4P_79X47_FUK_COLAY" list(7095.810000 5304.630000) nil "0.10") | 0@@list("CM3102" "MX_CHOKE_4P_79X47_FUK_COLAY" list(7183.810000 5328.630000) nil "0.10") | 0@@list("CM3103" "MX_CHOKE_4P_79X47_FUK_COLAY" list(7271.810000 5328.630000) nil "0.10") | 0@@list("CM3104" "MX_CHOKE_4P_79X47_FUK_COLAY" list(7360.810000 5328.630000) nil "0.10") | 0@@list("CM3303" "MX_CHOKE_4P_55X47_CHI" list(9519.810000 1058.630000) nil "0.10") | 0@@list("CM3603" "MX_CHOKE_4P_55X47_CHI" list(9240.380000 6689.350000) nil "0.10") | 0@@list("CM3604" "MX_CHOKE_4P_55X47_CHI" list(9179.550000 6688.960000) nil "0.10") | 0@@list("CM3703" "MX_CHOKE_4P_55X47_CHI" list(8388.660000 6380.920000) nil "0.10") | 0@@list("CM3704" "MX_CHOKE_4P_55X47_CHI" list(8448.660000 6380.920000) nil "0.10") | 0@@list("CM4003" "MX_CHOKE_4P_55X47_CHI" list(9454.660000 1058.920000) nil "0.10") | 0@@list("CR1" "MX_LED_2P_63X31_H16" list(13365.810000 1242.630000) nil "0.10") | 0@@list("CR2" "MX_LED_2P_63X31_H16" list(13365.810000 1302.630000) nil "0.10") | 0@@list("CR22" "MX_LED_2P_63X31_H16" list(13365.810000 1362.630000) nil "0.10") | 0@@list("CR23" "MX_LED_2P_63X31_H16" list(13364.810000 1678.630000) nil "0.10") | 0@@list("CR4" "MX_LED_2P_63X31_EVER" list(13365.810000 1541.630000) nil "0.10") | 0@@list("CR5" "MX_LED_2P_63X31_H16" list(13365.810000 1481.630000) nil "0.10") | 0@@list("CR6" "MX_LED_2P_63X31_H16" list(13365.810000 1421.630000) nil "0.10") | 0@@list("CR7" "MX_LED_2P_63X31_H16" list(13365.810000 1601.630000) nil "0.10") | 0@@list("D3" "MX_SOT323" list(7728.130000 6178.600000) nil "0.10") | 0@@list("D3101" "MX_DFN_10P_118X79_3PAD" list(7323.810000 5497.200000) nil "0.10") | 0@@list("D3102" "MX_DFN_10P_118X79_3PAD" list(7161.810000 5497.200000) nil "0.10") | 0@@list("D3103" "MX_S0402_AMAZ_COLAY_T01" list(8176.740000 6493.760000) nil "0.10") | 0@@list("D3104" "MX_S0402_AMAZ_COLAY_T01" list(8236.380000 6784.350000) nil "0.10") | 0@@list("D3106" "MX_S0402_AMAZ_COLAY_T01" list(7512.380000 6256.350000) nil "0.10") | 0@@list("D3301" "MX_ESD_10P_20_98X39_NXP" list(9894.810000 1043.630000) nil "0.10") | 0@@list("D3302" "MX_SOT23_S6" list(9490.380000 913.350000) nil "0.10") | 0@@list("D3602" "MX_SOT23_S6" list(9206.380000 6930.350000) nil "0.10") | 0@@list("D3603" "MX_ESD_10P_20_98X39_NXP" list(9584.380000 6373.350000) nil "0.10") | 0@@list("D3702" "MX_SOT23_S6" list(8424.380000 6528.350000) nil "0.10") | 0@@list("D4003" "MX_ESD_10P_20_98X39_NXP" list(9319.380000 1040.350000) nil "0.10") | 0@@list("D4301" "MX_S0402_AMAZ_COLAY" list(8542.380000 850.350000) nil "0.10") | 0@@list("D4302" "MX_S0402_AMAZ_COLAY" list(8357.380000 850.350000) nil "0.10") | 0@@list("D4303" "MX_S0402_AMAZ_COLAY" list(8179.380000 864.350000) nil "0.10") | 0@@list("D4304" "MX_S0402_AMAZ_COLAY" list(7937.660000 862.920000) nil "0.10") | 0@@list("D4305" "MX_S0402_AMAZ_COLAY" list(8254.810000 851.630000) nil "0.10") | 0@@list("D4306" "MX_S0402_AMAZ_COLAY" list(7790.450000 843.630000) nil "0.10") | 0@@list("D4307" "MX_S0402_AMAZ_COLAY" list(8075.380000 854.350000) nil "0.10") | 0@@list("D4308" "MX_S0402_AMAZ_COLAY" list(7872.380000 843.850000) nil "0.10") | 0@@list("D4310" "MX_S0402_AMAZ_COLAY_T01" list(12709.380000 6532.350000) nil "0.10") | 0@@list("D4C1" "MX_C0402_SMALL_T01" list(10138.810000 2979.630000) nil "0.10") | 0@@list("D4C2" "TX_C0201_T009_H14" list(10138.810000 2941.630000) nil "0.10") | 0@@list("D4C29" "MX_C0402_SMALL_T01" list(8486.380000 7028.350000) nil "0.10") | 0@@list("D4C3" "TX_C0201_T009_H14" list(10138.810000 2890.130000) nil "0.10") | 0@@list("D4C31" "MX_C0402_SMALL_T01" list(11471.380000 3185.350000) nil "0.10") | 0@@list("D4C4" "TX_C0201_T009_H14" list(10268.810000 3175.630000) nil "0.10") | 0@@list("D4C6" "MX_C0603_SMALL_T01" list(10330.930000 3209.630000) nil "0.10") | 0@@list("D4C7" "MX_C0402_SMALL_T01" list(10429.810000 3163.630000) nil "0.10") | 0@@list("D4C8" "MX_C0402_SMALL_T01" list(10340.810000 3163.630000) nil "0.10") | 0@@list("D4CB1" "MX_C0201" list(11419.380000 3168.350000) nil "0.10") | 0@@list("D4CB2" "MX_C0201" list(11825.310000 3172.130000) nil "0.10") | 0@@list("D4CB3" "MX_C0201" list(11636.310000 3175.130000) nil "0.10") | 0@@list("D4CB4" "MX_C0201" list(11918.310000 3171.630000) nil "0.10") | 0@@list("D4R5" "MX_R0402_SMALL_T01" list(10138.880000 3104.130000) nil "0.10") | 0@@list("D4R6" "MX_R0402_SMALL_T01" list(10138.810000 3067.630000) nil "0.10") | 0@@list("D4T1" "MX_TPC26T_S4_68" list(11285.380000 3155.350000) nil "0.10") | 0@@list("D519" "MX_S0402_AMAZ_COLAY_T01" list(7073.380000 903.350000) nil "0.10") | 0@@list("D524" "MX_SOT323" list(9464.630000 2427.100000) nil "0.10") | 0@@list("D525" "MX_SOT323" list(7746.130000 6294.100000) nil "0.10") | 0@@list("E61" "MX_SOCKET_16P_50_LOTE" list(9007.380000 3116.350000) nil "0.10") | 0@@list("ECR106" "MX_R0402_SMALL_T01" list(7845.380000 3869.350000) nil "0.10") | 0@@list("ECR135" "MX_R0402_SMALL_T01" list(7649.380000 3203.350000) nil "0.10") | 0@@list("ECR141" "MX_R0402_SMALL_T01" list(7490.810000 4995.110000) nil "0.10") | 0@@list("ECR146" "MX_R0402_SMALL_T01" list(7494.380000 4333.350000) nil "0.10") | 0@@list("ECR156" "MX_R0402_SMALL_T01" list(10639.380000 649.050000) nil "0.10") | 0@@list("ECR157" "MX_R0402_SMALL_T01" list(10707.880000 723.350000) nil "0.10") | 0@@list("F1" "TX_POLYSWITCH_2P_87X59_H49" list(12833.380000 6833.350000) nil "0.10") | 0@@list("F3R1" "MX_R0402_SMALL_T01" list(9327.380000 3027.350000) nil "0.10") | 0@@list("F3R10" "MX_R0402_SMALL_T01" list(9354.380000 3178.350000) nil "0.10") | 0@@list("F3R11" "MX_R0402_SMALL_T01" list(9333.380000 3138.350000) nil "0.10") | 0@@list("F3R12" "MX_R0402_SMALL_T01" list(8657.380000 3105.350000) nil "0.10") | 0@@list("F3R2" "MX_R0402_SMALL_T01" list(8605.380000 3109.350000) nil "0.10") | 0@@list("F3R22" "MX_R0402_SMALL_T01" list(9327.380000 2990.350000) nil "0.10") | 0@@list("F3R23" "MX_R0402_SMALL_T01" list(9369.380000 3218.350000) nil "0.10") | 0@@list("F3R6" "MX_R0402_SMALL_T01" list(8544.380000 2894.350000) nil "0.10") | 0@@list("F3R7" "MX_R0402_SMALL_T01" list(8674.380000 2963.350000) nil "0.10") | 0@@list("F3R71" "MX_R0402_SMALL_T01" list(9409.880000 2879.350000) nil "0.10") | 0@@list("F3R8" "MX_R0402_SMALL_T01" list(8683.380000 2925.350000) nil "0.10") | 0@@list("F3R9" "MX_R0402_SMALL_T01" list(9326.380000 2950.350000) nil "0.10") | 0@@list("FCB1" "MX_C0402_SMALL_T01" list(13364.730000 3317.350000) nil "0.10") | 0@@list("FR1" "MX_R0402_SMALL_T01" list(13362.730000 3403.350000) nil "0.10") | 0@@list("FR10" "MX_R0402_SMALL_T01" list(7057.970000 4259.270000) nil "0.10") | 0@@list("FR12" "MX_R0402_SMALL_T01" list(11734.380000 6558.350000) nil "0.10") | 0@@list("FR2" "MX_R0603_SMALL_T01" list(13363.730000 3360.350000) nil "0.10") | 0@@list("H1" "HOLE_C315D181N_M2_P2_V8" list(9929.530000 5564.180000) nil "0.10") | 0@@list("H11" "HOLE_C315D169N_M2_P2_V8" list(13315.360000 3910.640000) nil "0.10") | 0@@list("H3" "HOLE_C334D157N_M2_P2_V8" list(12964.180000 6450.230000) nil "0.10") | 0@@list("H5" "HOLE_C315D181N_M2_P2_V8" list(13315.360000 5564.180000) nil "0.10") | 0@@list("H6" "HOLE_C334D157N_M2_P2_V8" list(7035.380000 5800.350000) nil "0.10") | 0@@list("H8" "HOLE_C334D157N_M2_P2_V8" list(13281.500000 1009.850000) nil "0.10") | 0@@list("H9" "HOLE_C394D157N_M2_P2_V8_SPE" list(9954.740000 2190.160000) nil "0.10") | 0@@list("HC1" "MX_C0402_SMALL_T01" list(12697.810000 3528.630000) nil "0.10") | 0@@list("HC15" "TX_C0201_T009_H14" list(8113.380000 3333.350000) nil "0.10") | 0@@list("HC2" "MX_C0402_SMALL_T01" list(12699.810000 3428.630000) nil "0.10") | 0@@list("HC3" "MX_C0402_SMALL_T01" list(10219.100000 5657.780000) nil "0.10") | 0@@list("HC4" "MX_C0603_SMALL_T02" list(10157.810000 5183.630000) nil "0.10") | 0@@list("HC5" "MX_C0402_SMALL_T01" list(10205.810000 5205.630000) nil "0.10") | 0@@list("HCB3" "MX_C0402_SMALL_T01" list(9631.810000 4654.070000) nil "0.10") | 0@@list("HCB6" "MX_C0402_SMALL_T01" list(9874.380000 4755.350000) nil "0.10") | 0@@list("HQ1" "TX_SOT23_2D4_122X55_H44" list(12806.660000 3303.920000) nil "0.10") | 0@@list("HQ2" "TX_SOT23_2D4_122X55_H44" list(12879.810000 3493.630000) nil "0.10") | 0@@list("HR1" "MX_R0402_SMALL_T01" list(12931.100000 3282.780000) nil "0.10") | 0@@list("HR2" "MX_R0402_SMALL_T01" list(12978.950000 3458.070000) nil "0.10") | 0@@list("HR25" "MX_R0402_SMALL_T01" list(10206.380000 5443.350000) nil "0.10") | 0@@list("HR30" "MX_R0402_SMALL_T01" list(10191.810000 5723.630000) nil "0.10") | 0@@list("HR32" "MX_R0402_SMALL_T01" list(10208.810000 5505.930000) nil "0.10") | 0@@list("HR34" "MX_R0402_SMALL_T01" list(10207.810000 5607.630000) nil "0.10") | 0@@list("HR343" "MX_R0402_SMALL_T01" list(10182.100000 5657.780000) nil "0.10") | 0@@list("HR364" "MX_R0402_SMALL_T01" list(9879.380000 4921.850000) nil "0.10") | 0@@list("HR365" "MX_R0402_SMALL_T01" list(9879.480000 4884.850000) nil "0.10") | 0@@list("HR366" "MX_R0402_SMALL_T01" list(8362.380000 4709.350000) nil "0.10") | 0@@list("HR371" "MX_R0402_SMALL_T01" list(9936.380000 5082.350000) nil "0.10") | 0@@list("HR373" "MX_R0402_SMALL_T01" list(8568.880000 4606.230000) nil "0.10") | 0@@list("HR379" "MX_R0402_SMALL_T01" list(9875.380000 4831.350000) nil "0.10") | 0@@list("HR380" "MX_R0402_SMALL_T01" list(9631.810000 4581.070000) nil "0.10") | 0@@list("HR384" "MX_R0402_SMALL_T01" list(9990.380000 5063.350000) nil "0.10") | 0@@list("HR399" "MX_R0402_SMALL_T01" list(9631.810000 4617.070000) nil "0.10") | 0@@list("HR4" "MX_R0402_SMALL_T01" list(12844.810000 3408.630000) nil "0.10") | 0@@list("HR426" "MX_R0402_SMALL_T01" list(9993.980000 4832.680000) nil "0.10") | 0@@list("HR427" "MX_R0402_SMALL_T01" list(9993.780000 4869.020000) nil "0.10") | 0@@list("HR44" "MX_R0402_SMALL_T01" list(9663.380000 5005.350000) nil "0.10") | 0@@list("HR45" "MX_R0402_SMALL_T01" list(9663.660000 4967.720000) nil "0.10") | 0@@list("HR46" "MX_R0402_SMALL_T01" list(9663.660000 4931.220000) nil "0.10") | 0@@list("HR47" "MX_R0402_SMALL_T01" list(9663.660000 4895.220000) nil "0.10") | 0@@list("HR48" "MX_R0402_SMALL_T01" list(9600.280000 4771.920000) nil "0.10") | 0@@list("HR49" "MX_R0402_SMALL_T01" list(9600.280000 4808.420000) nil "0.10") | 0@@list("HR5" "MX_R0603_SMALL_T01" list(12622.930000 3476.630000) nil "0.10") | 0@@list("HR54" "MX_R0402_SMALL_T01" list(9600.280000 4735.980000) nil "0.10") | 0@@list("HR55" "MX_R0402_SMALL_T01" list(9600.280000 4699.780000) nil "0.10") | 0@@list("HR57" "MX_R0402_SMALL_T01" list(11297.810000 4954.630000) nil "0.10") | 0@@list("HR58" "MX_R0402_SMALL_T01" list(10136.380000 5108.350000) nil "0.10") | 0@@list("HR6" "MX_R0603_SMALL_T01" list(12624.810000 3428.630000) nil "0.10") | 0@@list("HR69" "MX_R0402_SMALL_T01" list(7560.810000 957.630000) nil "0.10") | 0@@list("HR7" "MX_R0402_SMALL_T01" list(12632.810000 3518.630000) nil "0.10") | 0@@list("HR8" "MX_R0402_SMALL_T01" list(12699.810000 3389.630000) nil "0.10") | 0@@list("HR81" "MX_R0402_SMALL_T01" list(10082.380000 5230.350000) nil "0.10") | 0@@list("HR82" "MX_R0402_SMALL_T01" list(9663.660000 4858.920000) nil "0.10") | 0@@list("HR83" "MX_R0402_SMALL_T01" list(9662.380000 5043.350000) nil "0.10") | 0@@list("HR84" "MX_R0402_SMALL_T01" list(9663.780000 4821.720000) nil "0.10") | 0@@list("HR85" "MX_R0402_SMALL_T01" list(9591.380000 4849.350000) nil "0.10") | 0@@list("HR96" "MX_R0402_SMALL_T01" list(9874.380000 4792.350000) nil "0.10") | 0@@list("HT45" "MX_TPC26T_S4_68" list(13232.440000 6612.790000) nil "0.10") | 0@@list("HT51" "MX_TPC26T_S4_68" list(9352.440000 6337.290000) nil "0.10") | 0@@list("HT52" "MX_TPC26T_S4_68" list(9214.440000 6263.290000) nil "0.10") | 0@@list("HT53" "MX_TPC26T_S4_68" list(9274.440000 6314.290000) nil "0.10") | 0@@list("HT54" "MX_TPC26T_S4_68" list(9218.440000 6190.290000) nil "0.10") | 0@@list("HT55" "MX_TPC26T_S4_68" list(9276.440000 6391.290000) nil "0.10") | 0@@list("HT79" "MX_TPC26T_S4_68" list(9830.380000 3241.350000) nil "0.10") | 0@@list("HT80" "MX_TPC26T_S4_68" list(12082.380000 3185.350000) nil "0.10") | 0@@list("HT81" "MX_TPC26T_S4_68" list(12194.380000 3185.350000) nil "0.10") | 0@@list("HT83" "MX_TPC26T_S4_68" list(9770.380000 3327.350000) nil "0.10") | 0@@list("J218" "MX_MIN_PCI_67P_20_4H" list(8515.760000 2476.380000) nil "0.10") | 0@@list("J219" "MX_MINI_PCI_67P_20_4H_LOTE1" list(7295.080000 4678.250000) nil "0.10") | 0@@list("J68" "MX_WTOB_24P_39_2HD_ACES" list(9942.580000 6102.350000) nil "0.10") | 0@@list("J69" "MX_WTOB_30P_20_6HD_STARCONN" list(9012.970000 5973.350000) nil "0.10") | 0@@list("L117" "MX_L0603" list(7688.810000 1393.630000) nil "0.10") | 0@@list("L120" "MX_L0402" list(7639.810000 1487.630000) nil "0.10") | 0@@list("L122" "MX_L0603_SMALL_T02" list(8467.380000 869.350000) nil "0.10") | 0@@list("L123" "MX_L0603_SMALL_T02" list(8412.380000 946.350000) nil "0.10") | 0@@list("L129" "MX_L0402_SMALL_T01" list(7084.590000 959.150000) nil "0.10") | 0@@list("L16" "MX_L0402_SMALL_T01" list(7761.190000 1178.630000) nil "0.10") | 0@@list("L21" "MX_L0603_SMALL_T02" list(8006.380000 868.350000) nil "0.10") | 0@@list("L22" "MX_L0603_SMALL_T02" list(8245.810000 937.630000) nil "0.10") | 0@@list("L4000" "MX_CHOKE_2P_158X177" list(7636.880000 5979.350000) nil "0.10") | 0@@list("L8" "MX_CHOKE_4P_79X47" list(8002.950000 2524.070000) nil "0.10") | 0@@list("LC5" "MX_C0402_SMALL_T01" list(7458.380000 6255.350000) nil "0.10") | 0@@list("LC7" "MX_C0402_SMALL_T01" list(7842.380000 6264.350000) nil "0.10") | 0@@list("LC8" "MX_C0402_SMALL_T01" list(8221.380000 6493.350000) nil "0.10") | 0@@list("LR10" "MX_R0402_SMALL_T01" list(8258.380000 6493.350000) nil "0.10") | 0@@list("LR11" "MX_R0402_SMALL_T01" list(8300.380000 6538.350000) nil "0.10") | 0@@list("LU3" "MX_TRANS_24P_39_595X394_DEL" list(7128.440000 6275.350000) nil "0.10") | 0@@list("M1C100" "MX_C0402_SMALL_T01" list(11187.950000 6779.070000) nil "0.10") | 0@@list("M1C102" "MX_C0402_SMALL_T01" list(11167.380000 6963.350000) nil "0.10") | 0@@list("M1C103" "MX_C0402_SMALL_T01" list(11360.380000 6523.850000) nil "0.10") | 0@@list("M1C104" "MX_C0402_SMALL_T01" list(11396.380000 6523.850000) nil "0.10") | 0@@list("M1C105" "MX_C0402_SMALL_T01" list(11318.380000 6523.850000) nil "0.10") | 0@@list("M1C106" "MX_C0402_SMALL_T01" list(11282.380000 6523.850000) nil "0.10") | 0@@list("M1C107" "MX_C0402_SMALL_T01" list(11448.380000 6523.850000) nil "0.10") | 0@@list("M1C108" "MX_C0402_SMALL_T01" list(11484.380000 6523.850000) nil "0.10") | 0@@list("M1C109" "MX_C0402_SMALL_T01" list(11565.380000 6523.850000) nil "0.10") | 0@@list("M1C110" "MX_C0402_SMALL_T01" list(11529.380000 6523.850000) nil "0.10") | 0@@list("M1C112" "MX_C0402_SMALL_T01" list(11158.660000 6664.920000) nil "0.10") | 0@@list("M1C113" "MX_C0402_SMALL_T01" list(11679.380000 6586.350000) nil "0.10") | 0@@list("M1C114" "MX_C0402_SMALL_T01" list(11221.380000 6529.350000) nil "0.10") | 0@@list("M1C115" "MX_C0402_SMALL_T01" list(9696.380000 1004.350000) nil "0.10") | 0@@list("M1C116" "MX_C0402_SMALL_T01" list(9750.380000 1384.350000) nil "0.10") | 0@@list("M1C117" "MX_C0402_SMALL_T01" list(12266.380000 6508.350000) nil "0.10") | 0@@list("M1C118" "MX_C0402_SMALL_T01" list(12302.380000 6508.350000) nil "0.10") | 0@@list("M1C119" "MX_C0402_SMALL_T01" list(12122.380000 6536.350000) nil "0.10") | 0@@list("M1C120" "MX_C0402_SMALL_T01" list(12086.380000 6536.350000) nil "0.10") | 0@@list("M1C121" "MX_C0402_SMALL_T01" list(12342.880000 6508.350000) nil "0.10") | 0@@list("M1C122" "MX_C0402_SMALL_T01" list(12378.880000 6508.350000) nil "0.10") | 0@@list("M1C123" "MX_C0402_SMALL_T01" list(12006.380000 6536.350000) nil "0.10") | 0@@list("M1C124" "MX_C0402_SMALL_T01" list(11970.380000 6536.350000) nil "0.10") | 0@@list("M1C49" "MX_C0402_SMALL_T01" list(8018.380000 2358.350000) nil "0.10") | 0@@list("M1C50" "MX_C0402_SMALL_T01" list(8019.380000 2238.350000) nil "0.10") | 0@@list("M1C51" "MX_C0402_SMALL_T01" list(9022.880000 2403.350000) nil "0.10") | 0@@list("M1C52" "MX_C0402_SMALL_T01" list(9023.160000 2439.920000) nil "0.10") | 0@@list("M1C73" "MX_C0402_SMALL_T01" list(12816.380000 6723.350000) nil "0.10") | 0@@list("M1C82" "MX_C0402_SMALL_T01" list(8350.380000 6691.350000) nil "0.10") | 0@@list("M1C83" "MX_C0402_SMALL_T01" list(8412.380000 7028.350000) nil "0.10") | 0@@list("M1F2" "MX_POLYSWITCH_2P_0805_H30" list(11024.380000 6808.350000) nil "0.10") | 0@@list("M1Q7" "MX_SOT23_2D4_122X55_H44" list(12736.620000 6620.950000) nil "0.10") | 0@@list("M1Q8" "MX_SOT23_2D4_122X55_H44" list(11844.810000 6558.630000) nil "0.10") | 0@@list("M1Q9" "TX_SOT23_2D4_T01_H43" list(12181.320000 6598.250000) nil "0.10") | 0@@list("M1R14" "MX_R0402_SMALL_T01" list(12826.380000 6665.350000) nil "0.10") | 0@@list("M1R19" "MX_R0402_SMALL_T01" list(11913.380000 6480.350000) nil "0.10") | 0@@list("M1R20" "MX_R0402_SMALL_T01" list(11764.380000 6608.350000) nil "0.10") | 0@@list("M1R21" "MX_R0402_SMALL_T01" list(11172.810000 6829.630000) nil "0.10") | 0@@list("M1R22" "MX_R0402_SMALL_T01" list(11171.810000 6875.630000) nil "0.10") | 0@@list("M1R23" "MX_R0402_SMALL_T01" list(12605.940000 6530.840000) nil "0.10") | 0@@list("M1R24" "MX_R0402_SMALL_T01" list(12541.820000 6530.860000) nil "0.10") | 0@@list("M1R25" "MX_R0402_SMALL_T01" list(12603.940000 6668.840000) nil "0.10") | 0@@list("M1R26" "MX_R0402_SMALL_T01" list(12537.940000 6668.840000) nil "0.10") | 0@@list("M1U3" "MX_ESD_10P_20_98X39_NXP" list(11335.750000 6592.530000) nil "0.10") | 0@@list("M1U4" "MX_ESD_10P_20_98X39_NXP" list(11539.810000 6598.630000) nil "0.10") | 0@@list("M2R1" "MX_R0402_SMALL_T01" list(12713.380000 6494.350000) nil "0.10") | 0@@list("MC5402" "MX_C0402_SMALL_T01" list(8008.380000 1065.350000) nil "0.10") | 0@@list("MC8303" "MX_C0402_SMALL_T01" list(8613.380000 687.850000) nil "0.10") | 0@@list("MC8304" "MX_C0402_SMALL_T01" list(8613.380000 723.850000) nil "0.10") | 0@@list("MQ26" "TX_SOT23_2D4_T01_H43" list(9313.420000 2332.250000) nil "0.10") | 0@@list("O2C2" "MX_C0402_SMALL_T01" list(12854.380000 896.350000) nil "0.10") | 0@@list("O2C6" "MX_C0402_SMALL_T01" list(7744.150000 3621.850000) nil "0.10") | 0@@list("O2C8" "MX_C0402_SMALL_T01" list(7418.380000 3822.350000) nil "0.10") | 0@@list("O2CB19" "MX_C0402_SMALL_T01" list(7418.380000 3891.350000) nil "0.10") | 0@@list("O2CB7" "TX_C0201_T009_H14" list(7731.380000 4249.350000) nil "0.10") | 0@@list("O2R22" "MX_R0402_SMALL_T01" list(7447.380000 3978.350000) nil "0.10") | 0@@list("O2R24" "MX_R0402_SMALL_T01" list(7483.380000 3978.350000) nil "0.10") | 0@@list("O2R9" "MX_R0402_SMALL_T01" list(7235.600000 4434.920000) nil "0.10") | 0@@list("OR109" "MX_R0402_SMALL_T01" list(7154.500000 4406.790000) nil "0.10") | 0@@list("OR111" "MX_R0402_SMALL_T01" list(7154.500000 4444.270000) nil "0.10") | 0@@list("OR112" "MX_R0402_SMALL_T01" list(7154.500000 4481.470000) nil "0.10") | 0@@list("OR118" "MX_R0402_SMALL_T01" list(7292.380000 4002.350000) nil "0.10") | 0@@list("OR119" "MX_R0402_SMALL_T01" list(7154.380000 4370.350000) nil "0.10") | 0@@list("OR126" "MX_R0402_SMALL_T01" list(7119.380000 4013.350000) nil "0.10") | 0@@list("OR127" "MX_R0402_SMALL_T01" list(7044.380000 3958.350000) nil "0.10") | 0@@list("OR128" "MX_R0402_SMALL_T01" list(7090.380000 4392.350000) nil "0.10") | 0@@list("OR129" "MX_R0402_SMALL_T01" list(7011.380000 4342.850000) nil "0.10") | 0@@list("OR130" "MX_R0402_SMALL_T01" list(7011.380000 4305.850000) nil "0.10") | 0@@list("OR141" "MX_R0402_SMALL_T01" list(7208.950000 4115.630000) nil "0.10") | 0@@list("OR143" "MX_R0402_SMALL_T01" list(7208.810000 4196.070000) nil "0.10") | 0@@list("OR146" "MX_R0402_SMALL_T01" list(7494.880000 4296.350000) nil "0.10") | 0@@list("OR147" "MX_R0402_SMALL_T01" list(7494.880000 4259.350000) nil "0.10") | 0@@list("OR148" "MX_R0402_SMALL_T01" list(7417.380000 4071.350000) nil "0.10") | 0@@list("OR149" "MX_R0402_SMALL_T01" list(7417.380000 4110.350000) nil "0.10") | 0@@list("OR150" "MX_R0402_SMALL_T01" list(7417.380000 4146.350000) nil "0.10") | 0@@list("OR151" "MX_R0402_SMALL_T01" list(7417.380000 4187.350000) nil "0.10") | 0@@list("OR153" "MX_R0402_SMALL_T01" list(7228.380000 3980.350000) nil "0.10") | 0@@list("OR59" "MX_R0402_SMALL_T01" list(7328.380000 4216.350000) nil "0.10") | 0@@list("OR72" "MX_R0402_SMALL_T01" list(7235.660000 4398.780000) nil "0.10") | 0@@list("P305" "MX_SW_4P_2HOLD_RA_DIPT" list(9494.100000 606.300000) nil "0.10") | 0@@list("PC1" "TX_C0603" list(13234.380000 6373.350000) nil "0.10") | 0@@list("PC104" "MX_C0402_SMALL_T01" list(9724.850000 2908.610000) nil "0.10") | 0@@list("PC105" "MX_C0402_SMALL_T01" list(9812.830000 2900.620000) nil "0.10") | 0@@list("PC121" "MX_C0805_SMALL_T02" list(12143.380000 706.350000) nil "0.10") | 0@@list("PC122" "MX_C0805_SMALL_T02" list(12073.380000 706.350000) nil "0.10") | 0@@list("PC129" "MX_C0402_SMALL_T01" list(12139.380000 1000.350000) nil "0.10") | 0@@list("PC17" "MX_C0603_SMALL_T01" list(8651.380000 5711.350000) nil "0.10") | 0@@list("PC19" "MX_C0805_SMALL_T02" list(7946.980000 4931.450000) nil "0.10") | 0@@list("PC20" "MX_C0805_SMALL_T02" list(7876.980000 4931.450000) nil "0.10") | 0@@list("PC21" "MX_C0402_SMALL_T01" list(8774.380000 5797.350000) nil "0.10") | 0@@list("PC24" "MX_C0402_SMALL_T01" list(8811.380000 5797.350000) nil "0.10") | 0@@list("PC25" "MX_C0603_SMALL_T01" list(9989.380000 4678.350000) nil "0.10") | 0@@list("PC26" "MX_C0402_SMALL_T01" list(8129.780000 4973.550000) nil "0.10") | 0@@list("PC27" "MX_C0603_SMALL_T02" list(8585.380000 5043.350000) nil "0.10") | 0@@list("PC28" "MX_C0402_SMALL_T01" list(9991.380000 4415.350000) nil "0.10") | 0@@list("PC30" "MX_C0402_SMALL_T01" list(9990.380000 4506.350000) nil "0.10") | 0@@list("PC31" "MX_C0603_SMALL_T02" list(9989.380000 4182.350000) nil "0.10") | 0@@list("PC33" "MX_C0603_SMALL_T02" list(9690.380000 4503.350000) nil "0.10") | 0@@list("PC34" "MX_C0402_SMALL_T01" list(8068.580000 4805.950000) nil "0.10") | 0@@list("PC35" "MX_C0402_SMALL_T01" list(8712.380000 5540.350000) nil "0.10") | 0@@list("PC36" "MX_C0603_SMALL_T01" list(8654.380000 5827.350000) nil "0.10") | 0@@list("PC37" "MX_C0402_SMALL_T01" list(8633.380000 5642.350000) nil "0.10") | 0@@list("PC38" "MX_C0603_SMALL_T02" list(11299.810000 4778.350000) nil "0.10") | 0@@list("PC44" "MX_C0603_SMALL_T02" list(11299.810000 4723.350000) nil "0.10") | 0@@list("PC47" "MX_C0805_SMALL_T02" list(11775.380000 1096.350000) nil "0.10") | 0@@list("PC49" "MX_C0402_SMALL_T01" list(12389.380000 739.350000) nil "0.10") | 0@@list("PC5" "MX_C0402_SMALL_T01" list(13328.380000 5860.350000) nil "0.10") | 0@@list("PC52" "MX_C0402_SMALL_T01" list(11987.950000 916.630000) nil "0.10") | 0@@list("PC55" "MX_C0603_SMALL_T01" list(10686.380000 1084.350000) nil "0.10") | 0@@list("PC56" "MX_C0603_SMALL_T01" list(10736.380000 1084.350000) nil "0.10") | 0@@list("PC57" "MX_C0402_SMALL_T01" list(11929.380000 672.350000) nil "0.10") | 0@@list("PC58" "MX_C0402_SMALL_T01" list(11385.380000 1075.350000) nil "0.10") | 0@@list("PC69" "MX_C0603_SMALL_T01" list(9294.380000 1860.350000) nil "0.10") | 0@@list("PC70" "MX_C0603_SMALL_T01" list(9294.380000 1812.350000) nil "0.10") | 0@@list("PC71" "MX_C0402_SMALL_T01" list(9726.380000 1938.350000) nil "0.10") | 0@@list("PC7310" "MX_C0402_SMALL_T01" list(9829.380000 2992.350000) nil "0.10") | 0@@list("PC7899" "MX_C0402_SMALL_T01" list(8179.380000 1288.350000) nil "0.10") | 0@@list("PC802" "MX_C0805_SMALL_T02" list(9640.380000 3818.350000) nil "0.10") | 0@@list("PC803" "MX_C0805_SMALL_T02" list(9458.790000 3590.750000) nil "0.10") | 0@@list("PC808" "MX_C0402_SMALL_T01" list(9566.810000 2916.620000) nil "0.10") | 0@@list("PC812" "MX_C0805_SMALL_T02" list(9637.990000 3743.620000) nil "0.10") | 0@@list("PC813" "MX_C0603_SMALL_T02" list(9623.800000 3949.590000) nil "0.10") | 0@@list("PC814" "MX_C0603_SMALL_T02" list(9624.380000 3893.350000) nil "0.10") | 0@@list("PC815" "MX_C0805_SMALL_T02" list(9637.380000 3593.350000) nil "0.10") | 0@@list("PC816" "MX_C0805_SMALL_T02" list(9637.380000 3668.350000) nil "0.10") | 0@@list("PC89001" "MX_C0402_SMALL_T01" list(10192.380000 7040.350000) nil "0.10") | 0@@list("PC89002" "MX_C0402_SMALL_T01" list(10292.380000 6569.350000) nil "0.10") | 0@@list("PC89006" "MX_C0603_SMALL_T01" list(10677.380000 6952.350000) nil "0.10") | 0@@list("PC89008" "MX_C0402_SMALL_T01" list(10261.380000 6533.350000) nil "0.10") | 0@@list("PC89014" "MX_C0402_SMALL_T01" list(10175.380000 6606.350000) nil "0.10") | 0@@list("PC89016" "MX_C0402_SMALL_T01" list(10152.370000 6862.360000) nil "0.10") | 0@@list("PC89017" "MX_C0402_SMALL_T01" list(10203.380000 6839.350000) nil "0.10") | 0@@list("PC89018" "MX_C0402_SMALL_T01" list(10169.380000 6703.350000) nil "0.10") | 0@@list("PC89019" "MX_C0402_SMALL_T01" list(10169.380000 6913.350000) nil "0.10") | 0@@list("PC89020" "MX_C0402_SMALL_T01" list(10129.380000 6703.350000) nil "0.10") | 0@@list("PC89021" "MX_C0402_SMALL_T01" list(10324.380000 6856.350000) nil "0.10") | 0@@list("PC89023" "MX_C0402_SMALL_T01" list(10644.380000 6833.350000) nil "0.10") | 0@@list("PC89032" "MX_C0402_SMALL_T01" list(10491.380000 6720.350000) nil "0.10") | 0@@list("PC89033" "MX_C0402_SMALL_T01" list(10544.380000 6843.350000) nil "0.10") | 0@@list("PC89034" "MX_C0402_SMALL_T01" list(10455.380000 6720.350000) nil "0.10") | 0@@list("PC89035" "MX_C0402_SMALL_T01" list(10594.380000 6671.350000) nil "0.10") | 0@@list("PC90006" "MX_C0402_SMALL_T01" list(11799.380000 6448.350000) nil "0.10") | 0@@list("PC90008" "MX_C0402_SMALL_T01" list(11624.380000 6122.350000) nil "0.10") | 0@@list("PC90010" "MX_C0402_SMALL_T01" list(11910.380000 6268.350000) nil "0.10") | 0@@list("PC90012" "MX_C0805_SMALL_T02" list(10868.380000 6349.350000) nil "0.10") | 0@@list("PC90013" "TX_C0805_T02_H57" list(10868.380000 6421.350000) nil "0.10") | 0@@list("PC90017" "MX_C0402_SMALL_T01" list(11092.380000 6453.350000) nil "0.10") | 0@@list("PC90018" "MX_C0402_SMALL_T01" list(10921.380000 6144.350000) nil "0.10") | 0@@list("PC9002" "MX_C0402_SMALL_T01" list(11165.380000 6319.350000) nil "0.10") | 0@@list("PC90021" "MX_C0402_SMALL_T01" list(11173.380000 6234.350000) nil "0.10") | 0@@list("PC9003" "TX_C0402" list(10676.380000 6322.350000) nil "0.10") | 0@@list("PC90100" "TX_C0402" list(13176.380000 6273.350000) nil "0.10") | 0@@list("PC92" "MX_C0805_SMALL_T02" list(9809.810000 3078.630000) nil "0.10") | 0@@list("PC93" "MX_C0805_SMALL_T02" list(9879.810000 3078.630000) nil "0.10") | 0@@list("PC93001" "MX_C0805_SMALL_T02" list(11975.380000 6145.350000) nil "0.10") | 0@@list("PC93002" "TX_C0805_T02_H57" list(12045.380000 6145.350000) nil "0.10") | 0@@list("PC93003" "MX_C0805_SMALL_T02" list(12076.880000 869.350000) nil "0.10") | 0@@list("PC93005" "MX_C0603_SMALL_T01" list(13305.380000 5264.350000) nil "0.10") | 0@@list("PC93007" "MX_C0603_SMALL_T01" list(13180.950000 5128.070000) nil "0.10") | 0@@list("PC93010" "MX_C0402_SMALL_T01" list(12178.380000 5941.350000) nil "0.10") | 0@@list("PC93017" "MX_C0402_SMALL_T01" list(13356.810000 4359.070000) nil "0.10") | 0@@list("PC93019" "MX_C0402_SMALL_T01" list(13176.380000 4602.350000) nil "0.10") | 0@@list("PC93020" "MX_C0402_SMALL_T01" list(13273.380000 4168.350000) nil "0.10") | 0@@list("PC93021" "MX_C0402_SMALL_T01" list(13176.380000 4359.350000) nil "0.10") | 0@@list("PC94" "MX_C0402_SMALL_T01" list(9953.880000 2868.850000) nil "0.10") | 0@@list("PC941489" "MX_C0603_SMALL_T02" list(11898.980000 4938.990000) nil "0.10") | 0@@list("PC941490" "MX_C0603_SMALL_T02" list(11843.980000 4938.990000) nil "0.10") | 0@@list("PC941496" "MX_C0402_SMALL_T01" list(12930.380000 6735.350000) nil "0.10") | 0@@list("PC941497" "MX_C0402_SMALL_T01" list(13370.460000 5893.350000) nil "0.10") | 0@@list("PC941586" "MX_C0402_SMALL_T01" list(10430.380000 6127.350000) nil "0.10") | 0@@list("PC941587" "MX_C0805_SMALL_T02" list(10345.380000 6359.350000) nil "0.10") | 0@@list("PC941588" "MX_C0603_SMALL_T01" list(10218.380000 6076.350000) nil "0.10") | 0@@list("PC941589" "MX_C0402_SMALL_T01" list(10675.950000 6258.070000) nil "0.10") | 0@@list("PC941590" "TX_C0603_T015_H37" list(10331.380000 5893.350000) nil "0.10") | 0@@list("PC9416" "MX_C0402_SMALL_T01" list(10679.380000 649.050000) nil "0.10") | 0@@list("PC941601" "MX_C0805_SMALL_T02" list(12215.380000 703.350000) nil "0.10") | 0@@list("PC941613" "MX_C0402_SMALL_T01" list(10494.380000 678.350000) nil "0.10") | 0@@list("PC941620" "MX_C0603_SMALL_T01" list(12921.380000 6685.350000) nil "0.10") | 0@@list("PC941626" "TX_C0805_T02_H57" list(10415.380000 6359.350000) nil "0.10") | 0@@list("PC941666" "MX_C0402_SMALL_T01" list(13370.380000 5827.350000) nil "0.10") | 0@@list("PC95" "MX_C0402_SMALL_T01" list(9644.810000 2916.610000) nil "0.10") | 0@@list("PC96" "MX_C0603_SMALL_T01" list(9498.810000 3124.630000) nil "0.10") | 0@@list("PC97" "MX_C0603_SMALL_T01" list(9511.760000 2992.630000) nil "0.10") | 0@@list("PC97001" "MX_C0603_SMALL_T02" list(11751.980000 4955.990000) nil "0.10") | 0@@list("PC97002" "MX_C0603_SMALL_T02" list(11631.980000 4955.990000) nil "0.10") | 0@@list("PC97003" "MX_C0603_SMALL_T02" list(11631.980000 4900.990000) nil "0.10") | 0@@list("PC97004" "MX_C0603_SMALL_T02" list(11436.980000 4852.490000) nil "0.10") | 0@@list("PC97005" "MX_C0603_SMALL_T02" list(11751.980000 4625.990000) nil "0.10") | 0@@list("PC97006" "MX_C0603_SMALL_T02" list(11751.980000 4735.990000) nil "0.10") | 0@@list("PC97007" "MX_C0603_SMALL_T02" list(11751.980000 4680.990000) nil "0.10") | 0@@list("PC97008" "MX_C0603_SMALL_T02" list(11631.980000 4845.990000) nil "0.10") | 0@@list("PC97009" "MX_C0603_SMALL_T02" list(11436.980000 4693.430000) nil "0.10") | 0@@list("PC97010" "MX_C0603_SMALL_T02" list(11651.980000 4520.990000) nil "0.10") | 0@@list("PC97011" "MX_C0603_SMALL_T02" list(11631.980000 4735.990000) nil "0.10") | 0@@list("PC97012" "MX_C0603_SMALL_T02" list(11631.980000 4680.990000) nil "0.10") | 0@@list("PC97014" "MX_C0603_SMALL_T02" list(11631.980000 4790.990000) nil "0.10") | 0@@list("PC97015" "MX_C0603_SMALL_T02" list(11751.980000 4790.990000) nil "0.10") | 0@@list("PC97016" "MX_C0603_SMALL_T02" list(11751.980000 4845.990000) nil "0.10") | 0@@list("PC97017" "MX_C0603_SMALL_T02" list(11631.980000 4625.990000) nil "0.10") | 0@@list("PC97018" "MX_C0603_SMALL_T02" list(11436.980000 4800.490000) nil "0.10") | 0@@list("PC97019" "MX_C0603_SMALL_T02" list(11471.980000 4520.990000) nil "0.10") | 0@@list("PC97020" "MX_C0603_SMALL_T02" list(11436.810000 4747.130000) nil "0.10") | 0@@list("PC97021" "MX_C0603_SMALL_T02" list(11436.980000 4956.990000) nil "0.10") | 0@@list("PC97022" "MX_C0603_SMALL_T02" list(11436.980000 4904.490000) nil "0.10") | 0@@list("PC97023" "MX_C0603_SMALL_T02" list(11751.980000 4900.990000) nil "0.10") | 0@@list("PC97024" "MX_C0603_SMALL_T02" list(12008.980000 4635.990000) nil "0.10") | 0@@list("PC97025" "MX_C0603_SMALL_T02" list(11898.980000 4835.990000) nil "0.10") | 0@@list("PC97026" "MX_C0603_SMALL_T02" list(11843.980000 4835.990000) nil "0.10") | 0@@list("PC97027" "MX_C0603_SMALL_T02" list(11843.980000 4745.990000) nil "0.10") | 0@@list("PC97028" "MX_C0603_SMALL_T02" list(12008.980000 4835.990000) nil "0.10") | 0@@list("PC97029" "MX_C0603_SMALL_T02" list(11843.980000 4635.990000) nil "0.10") | 0@@list("PC97030" "MX_C0603_SMALL_T02" list(11898.980000 4635.990000) nil "0.10") | 0@@list("PC97031" "MX_C0603_SMALL_T02" list(11953.980000 4835.990000) nil "0.10") | 0@@list("PC97032" "MX_C0603_SMALL_T02" list(11953.980000 4745.990000) nil "0.10") | 0@@list("PC97033" "MX_C0603_SMALL_T02" list(12008.980000 4745.990000) nil "0.10") | 0@@list("PC97036" "MX_C0603_SMALL_T02" list(11898.980000 4745.990000) nil "0.10") | 0@@list("PC97041" "MX_C0603_SMALL_T02" list(12008.980000 4938.990000) nil "0.10") | 0@@list("PC97042" "MX_C0603_SMALL_T02" list(11953.980000 4938.990000) nil "0.10") | 0@@list("PC97043" "MX_C0603_SMALL_T02" list(11953.980000 4635.990000) nil "0.10") | 0@@list("PC99" "MX_C0402_SMALL_T01" list(9659.810000 3163.630000) nil "0.10") | 0@@list("PC998" "MX_C0805_SMALL_T02" list(13336.380000 3518.350000) nil "0.10") | 0@@list("PC999" "MX_C0805_SMALL_T02" list(13085.380000 6038.350000) nil "0.10") | 0@@list("PCE125" "MX_CESMD_209X209_CHEMICON" list(12143.660000 6382.420000) nil "0.10") | 0@@list("PCE2" "MX_CESMD_260X260_COLAY" list(9816.340000 4284.350000) nil "0.10") | 0@@list("PCE3" "MX_CESMD_260X260_SAN" list(8754.880000 4918.150000) nil "0.10") | 0@@list("PCE31" "MX_CESMD_209X209_CHEMICON" list(12513.310000 6392.420000) nil "0.10") | 0@@list("PCE4" "MX_CESMD_260X260_SAN" list(9045.680000 4918.050000) nil "0.10") | 0@@list("PCE5" "MX_CESMD_260X260_COLAY" list(10989.380000 988.350000) nil "0.10") | 0@@list("PCE6" "MX_CESMD_260X260_COLAY" list(10609.380000 883.350000) nil "0.10") | 0@@list("PCE690" "MX_CESMD_260X260_COLAY" list(9438.380000 2064.350000) nil "0.10") | 0@@list("PCE7" "MX_CESMD_260X260_COLAY" list(9390.380000 1643.350000) nil "0.10") | 0@@list("PCE97030" "MX_CESMD_260X260_SAN" list(11413.380000 5931.350000) nil "0.10") | 0@@list("PD1" "MX_SMA" list(13369.380000 6153.350000) nil "0.10") | 0@@list("PL1" "MX_L0603_SMALL_T02" list(13302.380000 6546.350000) nil "0.10") | 0@@list("PL10" "MX_L0603_SMALL_T02" list(11903.380000 997.350000) nil "0.10") | 0@@list("PL11" "MX_INDUCTOR_2P_453X394_COLA" list(11495.810000 826.630000) nil "0.10") | 0@@list("PL12" "MX_INDUCTOR_2P_453X394_COLA" list(9813.380000 1710.350000) nil "0.10") | 0@@list("PL13" "MX_INDUCTOR_2P_287X260" list(9545.810000 3367.630000) nil "0.10") | 0@@list("PL14" "MX_INDUCTOR_2P_287X260" list(12382.380000 945.150000) nil "0.10") | 0@@list("PL2" "MX_L0603_SMALL_T02" list(13194.380000 6546.350000) nil "0.10") | 0@@list("PL3" "MX_L0603_SMALL_T02" list(13248.380000 6546.350000) nil "0.10") | 0@@list("PL4" "MX_L0603_SMALL_T02" list(13355.380000 6546.350000) nil "0.10") | 0@@list("PL9" "MX_L0603_SMALL_T02" list(11903.380000 1101.350000) nil "0.10") | 0@@list("PL90001" "MX_INDUCTOR_2P_274X260_COLA" list(11789.380000 5945.350000) nil "0.10") | 0@@list("PL90002" "MX_INDUCTOR_2P_274X260_COLA" list(11066.380000 5945.350000) nil "0.10") | 0@@list("PL90010" "MX_L0603_SMALL_T02" list(12997.880000 6034.350000) nil "0.10") | 0@@list("PL90011" "MX_L0603_SMALL_T02" list(12997.880000 6086.350000) nil "0.10") | 0@@list("PL90012" "MX_L0603_SMALL_T02" list(12997.880000 6138.350000) nil "0.10") | 0@@list("PL90013" "MX_L0603_SMALL_T02" list(12997.880000 6190.350000) nil "0.10") | 0@@list("PL93001" "MX_INDUCTOR_2P_274X260_COLA" list(12524.100000 6129.780000) nil "0.10") | 0@@list("PL93002" "MX_INDUCTOR_2P_274X260_COLA" list(13291.510000 4783.530000) nil "0.10") | 0@@list("PL93004" "MX_L0603_SMALL_T02" list(12294.380000 730.350000) nil "0.10") | 0@@list("PL93006" "MX_INDUCTOR_2P_274X260_COLA" list(10547.660000 5945.630000) nil "0.10") | 0@@list("PL93010" "MX_INDUCTOR_2P_287X260" list(8370.380000 4903.350000) nil "0.10") | 0@@list("PQ1" "MX_SI7900EDN_COLAY" list(13349.380000 6387.860000) nil "0.10") | 0@@list("PQ101" "TX_SOT23_2D4_122X55_H44" list(8201.380000 4671.550000) nil "0.10") | 0@@list("PQ102" "TX_SOT23_2D4_122X55_H44" list(7984.380000 4650.880000) nil "0.10") | 0@@list("PQ23" "MX_DFN_8P_26_122X122_2PAD" list(12175.380000 863.350000) nil "0.10") | 0@@list("PQ45" "TX_SOT23_2D4_T01_H43" list(7463.380000 5104.350000) nil "0.10") | 0@@list("PQ7" "MX_DFN_8P_26_122X122_2PAD" list(11866.380000 821.550000) nil "0.10") | 0@@list("PQ93001" "MX_DFN_8P_50_201X248_P_8V" list(12183.380000 6123.850000) nil "0.10") | 0@@list("PQ93002" "MX_DFN_8P_50_201X248_P_8V" list(13304.580000 4481.350000) nil "0.10") | 0@@list("PQ93012" "TX_SOT23_2D4_T01_H43" list(8744.380000 5971.350000) nil "0.10") | 0@@list("PQ93028" "TX_SOT23_2D4_T01_H43" list(7850.380000 3399.350000) nil "0.10") | 0@@list("PQ93040" "MX_DFN_8P_26_122X122_2PAD" list(8046.680000 4940.250000) nil "0.10") | 0@@list("PR1" "MX_R1508" list(13231.380000 6167.350000) nil "0.10") | 0@@list("PR10" "MX_R0402_SMALL_T01" list(13176.380000 6310.350000) nil "0.10") | 0@@list("PR107" "MX_R0402_SMALL_T01" list(9760.850000 2908.620000) nil "0.10") | 0@@list("PR109" "MX_R0402_SMALL_T01" list(9814.380000 2938.350000) nil "0.10") | 0@@list("PR11" "MX_R0402_SMALL_T01" list(13271.380000 6039.350000) nil "0.10") | 0@@list("PR12" "MX_R0402_SMALL_T01" list(13191.380000 6039.350000) nil "0.10") | 0@@list("PR122" "MX_R0402_SMALL_T01" list(7928.380000 1168.350000) nil "0.10") | 0@@list("PR136" "MX_R0402_SMALL_T01" list(12139.380000 1037.350000) nil "0.10") | 0@@list("PR25" "MX_R0603_SMALL_T01" list(8577.380000 5630.350000) nil "0.10") | 0@@list("PR26" "MX_R0402_SMALL_T01" list(8717.380000 5817.350000) nil "0.10") | 0@@list("PR27" "MX_R0402_SMALL_T01" list(8777.380000 5869.350000) nil "0.10") | 0@@list("PR29" "MX_R0402_SMALL_T01" list(8841.380000 5869.350000) nil "0.10") | 0@@list("PR30" "MX_R0805_SMALL_T02" list(8128.780000 5049.450000) nil "0.10") | 0@@list("PR31" "MX_R0402_SMALL_T01" list(8165.280000 4973.550000) nil "0.10") | 0@@list("PR32" "MX_R0402_SMALL_T01" list(9991.380000 4454.350000) nil "0.10") | 0@@list("PR34" "MX_R0402_SMALL_T01" list(8883.380000 5622.350000) nil "0.10") | 0@@list("PR35" "MX_R0402_SMALL_T01" list(8626.380000 5526.350000) nil "0.10") | 0@@list("PR36" "MX_R0805_SMALL_T02" list(8071.180000 4752.310000) nil "0.10") | 0@@list("PR37" "MX_R0402_SMALL_T01" list(8676.380000 5540.350000) nil "0.10") | 0@@list("PR38" "MX_R0402_SMALL_T01" list(8068.580000 4849.450000) nil "0.10") | 0@@list("PR39" "MX_R0402_SMALL_T01" list(8748.380000 5540.350000) nil "0.10") | 0@@list("PR40" "MX_R0402_SMALL_T01" list(9700.380000 4459.350000) nil "0.10") | 0@@list("PR41" "MX_R0603_SMALL_T01" list(8651.380000 5759.350000) nil "0.10") | 0@@list("PR42" "MX_R0402_SMALL_T01" list(8798.380000 5527.350000) nil "0.10") | 0@@list("PR44" "MX_R0402_SMALL_T01" list(8633.380000 5603.350000) nil "0.10") | 0@@list("PR45" "MX_R0402_SMALL_T01" list(8549.380000 5527.350000) nil "0.10") | 0@@list("PR46" "MX_R0402_SMALL_T01" list(8852.380000 5542.350000) nil "0.10") | 0@@list("PR47" "MX_R0402_SMALL_T01" list(8626.380000 5563.350000) nil "0.10") | 0@@list("PR49" "MX_R0805_SMALL_T02" list(12044.380000 1003.350000) nil "0.10") | 0@@list("PR54" "MX_R0402_SMALL_T01" list(12023.950000 916.630000) nil "0.10") | 0@@list("PR55" "MX_R0805_SMALL_T02" list(12004.380000 717.350000) nil "0.10") | 0@@list("PR57" "MX_R0402_SMALL_T01" list(11929.380000 635.350000) nil "0.10") | 0@@list("PR6399" "MX_R0402_SMALL_T01" list(12993.710000 6826.750000) nil "0.10") | 0@@list("PR808" "MX_R0402_SMALL_T01" list(9793.310000 2992.630000) nil "0.10") | 0@@list("PR89001" "MX_R0402_SMALL_T01" list(10229.380000 7040.350000) nil "0.10") | 0@@list("PR89002" "MX_R0402_SMALL_T01" list(10306.380000 7040.350000) nil "0.10") | 0@@list("PR89005" "MX_R0402_SMALL_T01" list(10499.380000 6998.350000) nil "0.10") | 0@@list("PR89007" "MX_R0402_SMALL_T01" list(10250.880000 6497.350000) nil "0.10") | 0@@list("PR8901" "MX_R0402_SMALL_T01" list(10098.380000 6602.350000) nil "0.10") | 0@@list("PR89013" "MX_R0402_SMALL_T01" list(10268.380000 7040.350000) nil "0.10") | 0@@list("PR89015" "MX_R0805_SMALL_T02" list(10425.380000 6932.350000) nil "0.10") | 0@@list("PR89016" "MX_R0402_SMALL_T01" list(10153.880000 6518.350000) nil "0.10") | 0@@list("PR89020" "MX_R0402_SMALL_T01" list(10053.380000 6871.350000) nil "0.10") | 0@@list("PR89021" "MX_R0402_SMALL_T01" list(10175.380000 6566.350000) nil "0.10") | 0@@list("PR89022" "MX_R0402_SMALL_T01" list(10098.380000 6566.350000) nil "0.10") | 0@@list("PR89023" "MX_R0402_SMALL_T01" list(10112.370000 6862.360000) nil "0.10") | 0@@list("PR89024" "MX_R0603_SMALL_T01" list(10052.380000 6783.350000) nil "0.10") | 0@@list("PR89025" "MX_R0402_SMALL_T01" list(10160.380000 6786.350000) nil "0.10") | 0@@list("PR89026" "MX_R0402_SMALL_T01" list(10115.380000 6778.350000) nil "0.10") | 0@@list("PR89027" "MX_R0603_SMALL_T01" list(10052.380000 6687.350000) nil "0.10") | 0@@list("PR89028" "MX_R0402_SMALL_T01" list(10099.380000 6959.350000) nil "0.10") | 0@@list("PR89029" "MX_R0402_SMALL_T01" list(10169.380000 6950.350000) nil "0.10") | 0@@list("PR89030" "MX_R0402_SMALL_T01" list(10053.380000 6826.350000) nil "0.10") | 0@@list("PR89031" "MX_R0603_SMALL_T01" list(10052.380000 6735.350000) nil "0.10") | 0@@list("PR89032" "MX_R0402_SMALL_T01" list(10099.380000 6923.350000) nil "0.10") | 0@@list("PR89035" "MX_R0402_SMALL_T01" list(10324.380000 6893.350000) nil "0.10") | 0@@list("PR89038" "MX_R0402_SMALL_T01" list(10407.380000 6519.350000) nil "0.10") | 0@@list("PR89042" "MX_R0402_SMALL_T01" list(10649.380000 6888.350000) nil "0.10") | 0@@list("PR89044" "MX_R0402_SMALL_T01" list(10594.380000 6848.350000) nil "0.10") | 0@@list("PR89048" "MX_R0402_SMALL_T01" list(10754.380000 6908.350000) nil "0.10") | 0@@list("PR89050" "MX_R0402_SMALL_T01" list(10789.380000 6828.350000) nil "0.10") | 0@@list("PR89056" "MX_R0402_SMALL_T01" list(10734.380000 7028.350000) nil "0.10") | 0@@list("PR89057" "MX_R0603_SMALL_T01" list(10637.380000 6730.350000) nil "0.10") | 0@@list("PR89059" "MX_R0402_SMALL_T01" list(10481.380000 6771.350000) nil "0.10") | 0@@list("PR89060" "MX_R0402_SMALL_T01" list(10419.380000 6720.350000) nil "0.10") | 0@@list("PR89061" "MX_R0603_SMALL_T01" list(10637.380000 6779.350000) nil "0.10") | 0@@list("PR89062" "MX_R0402_SMALL_T01" list(10531.380000 6769.350000) nil "0.10") | 0@@list("PR89063" "MX_R0402_SMALL_T01" list(10508.380000 6843.350000) nil "0.10") | 0@@list("PR89064" "MX_R0402_SMALL_T01" list(10449.380000 6643.350000) nil "0.10") | 0@@list("PR89066" "MX_R0402_SMALL_T01" list(10594.380000 6913.350000) nil "0.10") | 0@@list("PR89067" "MX_R0402_SMALL_T01" list(10544.380000 6653.350000) nil "0.10") | 0@@list("PR89069" "MX_R0402_SMALL_T01" list(10683.380000 6671.350000) nil "0.10") | 0@@list("PR89071" "MX_R0402_SMALL_T01" list(11581.380000 6016.350000) nil "0.10") | 0@@list("PR89072" "MX_R0402_SMALL_T01" list(12304.680000 6010.350000) nil "0.10") | 0@@list("PR89073" "MX_R0402_SMALL_T01" list(12342.380000 6007.850000) nil "0.10") | 0@@list("PR89105" "MX_R0402_SMALL_T01" list(10286.380000 6970.350000) nil "0.10") | 0@@list("PR9" "MX_R0402_SMALL_T01" list(13189.380000 6363.350000) nil "0.10") | 0@@list("PR90001" "MX_R0805_SMALL_T02" list(11704.380000 6488.350000) nil "0.10") | 0@@list("PR90004" "MX_R0402_SMALL_T01" list(11799.380000 6411.350000) nil "0.10") | 0@@list("PR90007" "MX_R0805_SMALL_T02" list(11890.380000 6182.350000) nil "0.10") | 0@@list("PR90008" "MX_R0402_SMALL_T01" list(11873.880000 6268.350000) nil "0.10") | 0@@list("PR90011" "MX_R0805_SMALL_T02" list(11199.380000 6433.350000) nil "0.10") | 0@@list("PR90012" "MX_R0402_SMALL_T01" list(11092.380000 6492.350000) nil "0.10") | 0@@list("PR90015" "MX_R0805_SMALL_T02" list(11199.380000 6167.350000) nil "0.10") | 0@@list("PR90016" "MX_R0402_SMALL_T01" list(11210.380000 6234.350000) nil "0.10") | 0@@list("PR93003" "MX_R0805_SMALL_T02" list(13226.380000 5291.350000) nil "0.10") | 0@@list("PR93005" "MX_R0402_SMALL_T01" list(13153.380000 5290.350000) nil "0.10") | 0@@list("PR93007" "MX_R0805_SMALL_T02" list(13369.380000 5244.350000) nil "0.10") | 0@@list("PR93008" "MX_R0402_SMALL_T01" list(12209.380000 5977.350000) nil "0.10") | 0@@list("PR93011" "MX_R0805_SMALL_T02" list(13390.950000 4246.630000) nil "0.10") | 0@@list("PR93012" "MX_R0402_SMALL_T01" list(13356.810000 4322.070000) nil "0.10") | 0@@list("PR93014" "MX_R1206" list(13275.380000 4282.360000) nil "0.10") | 0@@list("PR93015" "MX_R0805_SMALL_T02" list(13192.380000 4250.350000) nil "0.10") | 0@@list("PR93016" "MX_R0402_SMALL_T01" list(13176.380000 4323.350000) nil "0.10") | 0@@list("PR93067" "MX_R0805_SMALL_T02" list(10694.380000 6162.350000) nil "0.10") | 0@@list("PR93068" "MX_R0603_SMALL_T01" list(10356.380000 5824.350000) nil "0.10") | 0@@list("PR93071" "MX_R0402_SMALL_T01" list(10236.380000 5820.350000) nil "0.10") | 0@@list("PR93097" "MX_R0402_SMALL_T01" list(9606.810000 2916.630000) nil "0.10") | 0@@list("PR93098" "MX_R0805_SMALL_T02" list(10163.380000 5933.350000) nil "0.10") | 0@@list("PR93099" "MX_R0402_SMALL_T01" list(10712.950000 6258.070000) nil "0.10") | 0@@list("PR93156" "MX_R0402_SMALL_T01" list(8124.380000 1288.350000) nil "0.10") | 0@@list("PR97" "MX_R0805_SMALL_T02" list(9503.810000 3064.630000) nil "0.10") | 0@@list("PR99" "MX_R0603_SMALL_T01" list(9519.810000 2923.630000) nil "0.10") | 0@@list("PRT89001" "MX_R0402_SMALL_T01" list(11579.380000 6088.350000) nil "0.10") | 0@@list("PRT89002" "MX_R0402_SMALL_T01" list(12060.380000 6055.350000) nil "0.10") | 0@@list("PRT89003" "MX_R0402_SMALL_T01" list(11621.380000 6016.350000) nil "0.10") | 0@@list("PRT89004" "MX_R0402_SMALL_T01" list(12415.380000 5965.350000) nil "0.10") | 0@@list("PT158" "MX_TPC26T_S4_68" list(11607.380000 6221.350000) nil "0.10") | 0@@list("PT160" "MX_TPC26T_S4_68" list(10891.380000 6225.350000) nil "0.10") | 0@@list("PT161" "MX_TPC26T_S4_68" list(10340.380000 6264.350000) nil "0.10") | 0@@list("PT162" "MX_TPC26T_S4_68" list(10340.380000 6192.350000) nil "0.10") | 0@@list("PU3" "MX_QFN_16P_20_S118_P_2V" list(8784.380000 5680.350000) nil "0.10") | 0@@list("PU30" "MX_SC70_S6_87X55" list(12925.380000 6835.350000) nil "0.10") | 0@@list("PU5" "TX_QFN_22P_20_S161_2PAD" list(9679.810000 3053.630000) nil "0.10") | 0@@list("PU93001" "MX_DFN_8P_20_S79_PAD_ON" list(13199.380000 5204.350000) nil "0.10") | 0@@list("PU93004" "MX_DFN_8P_20_S79_PAD_ON" list(10253.810000 5916.630000) nil "0.10") | 0@@list("Q16" "TX_SOT23_2D4_T01_H43" list(6889.080000 1459.940000) nil "0.10") | 0@@list("Q17" "TX_SOT23_2D4_T01_H43" list(7850.380000 3268.350000) nil "0.10") | 0@@list("Q2" "TX_SOT23_2D4_T01_H43" list(8259.380000 6603.350000) nil "0.10") | 0@@list("Q4000" "TX_SOT23_2D4_122X55_H43" list(7704.380000 5688.850000) nil "0.10") | 0@@list("Q5" "TX_SOT23_2D4_T01_H43" list(10035.020000 3438.600000) nil "0.10") | 0@@list("Q6" "TX_SOT23_2D4_T01_H43" list(10011.990000 3185.850000) nil "0.10") | 0@@list("Q7" "TX_SOT23_2D4_T01_H43" list(9893.820000 3437.600000) nil "0.10") | 0@@list("Q93025" "MX_SOT23_2D4_122X71" list(12859.380000 6983.350000) nil "0.10") | 0@@list("Q93033" "MX_SOT323_S5" list(12027.380000 6983.350000) nil "0.10") | 0@@list("Q93036" "TX_SOT23_2D4_122X55_H44" list(13241.410000 1488.630000) nil "0.10") | 0@@list("Q93041" "MX_SOT23_2D4_122X71" list(10884.380000 6788.350000) nil "0.10") | 0@@list("Q9344" "TX_SOT23_2D4_122X55_H44" list(13241.410000 1306.630000) nil "0.10") | 0@@list("Q9346" "TX_SOT23_2D4_122X55_H44" list(13358.810000 1845.630000) nil "0.10") | 0@@list("Q9432" "TX_SOIC_6P_26_87X53_COLY" list(12454.380000 6588.350000) nil "0.10") | 0@@list("Q9434" "TX_SOT23_2D4_T01_H43" list(7971.380000 2658.350000) nil "0.10") | 0@@list("Q9435" "TX_SOT23_2D4_T01_H43" list(7930.880000 2355.350000) nil "0.10") | 0@@list("Q9438" "TX_SOT23_2D4_122X55_H44" list(7944.380000 1732.350000) nil "0.10") | 0@@list("Q9534" "TX_SOT23_2D4_T01_H43" list(7954.380000 1493.350000) nil "0.10") | 0@@list("Q9535" "TX_SOT23_2D4_T01_H43" list(7954.380000 1363.350000) nil "0.10") | 0@@list("R1" "MX_R0402_SMALL_T01" list(8255.380000 6731.350000) nil "0.10") | 0@@list("R123" "MX_R0402_SMALL_T01" list(8367.810000 919.890000) nil "0.10") | 0@@list("R124" "MX_R0402_SMALL_T01" list(8487.380000 943.350000) nil "0.10") | 0@@list("R182" "MX_R0402_SMALL_T01" list(7073.380000 1068.350000) nil "0.10") | 0@@list("R19" "MX_R0805_SMALL_T02" list(6959.380000 6586.350000) nil "0.10") | 0@@list("R2" "MX_R0402_SMALL_T01" list(8205.380000 6731.350000) nil "0.10") | 0@@list("R20" "MX_R0805_SMALL_T02" list(7029.380000 6586.350000) nil "0.10") | 0@@list("R205" "MX_R0402_SMALL_T01" list(10084.380000 6458.350000) nil "0.10") | 0@@list("R207" "MX_R0402_SMALL_T01" list(7049.380000 1798.350000) nil "0.10") | 0@@list("R21" "MX_R0805_SMALL_T02" list(7194.380000 6586.350000) nil "0.10") | 0@@list("R2101" "MX_R0402_SMALL_T01" list(9334.380000 4593.350000) nil "0.10") | 0@@list("R2103" "MX_R0402_SMALL_T01" list(9261.380000 4596.350000) nil "0.10") | 0@@list("R2104" "MX_R0402_SMALL_T01" list(9189.380000 4596.230000) nil "0.10") | 0@@list("R22" "MX_R0805_SMALL_T02" list(7264.380000 6586.350000) nil "0.10") | 0@@list("R2342" "MX_R0402_SMALL_T01" list(7554.380000 5568.350000) nil "0.10") | 0@@list("R2344" "MX_R0402_SMALL_T01" list(8109.380000 4500.350000) nil "0.10") | 0@@list("R2347" "MX_R0402_SMALL_T01" list(8104.380000 4572.350000) nil "0.10") | 0@@list("R2348" "MX_R0402_SMALL_T01" list(8026.380000 4520.850000) nil "0.10") | 0@@list("R2351" "MX_R0402_SMALL_T01" list(8036.880000 4578.350000) nil "0.10") | 0@@list("R2352" "MX_R0402_SMALL_T01" list(8104.380000 4536.350000) nil "0.10") | 0@@list("R3109" "MX_R0402_SMALL_T01" list(9113.820000 2496.600000) nil "0.10") | 0@@list("R3125" "MX_R0402_SMALL_T01" list(8309.380000 2215.350000) nil "0.10") | 0@@list("R3126" "MX_R0402_SMALL_T01" list(8289.380000 4611.350000) nil "0.10") | 0@@list("R3127" "MX_R0402_SMALL_T01" list(8414.380000 2209.350000) nil "0.10") | 0@@list("R3133" "MX_R0402_SMALL_T01" list(8063.380000 4232.350000) nil "0.10") | 0@@list("R3138" "MX_R0402_SMALL_T01" list(7608.380000 4513.350000) nil "0.10") | 0@@list("R36" "MX_R0402_SMALL_T01" list(8157.380000 940.350000) nil "0.10") | 0@@list("R37" "MX_R0402_SMALL_T01" list(8173.380000 1002.350000) nil "0.10") | 0@@list("R40" "MX_R0402_SMALL_T01" list(8416.380000 4605.350000) nil "0.10") | 0@@list("R4000" "MX_R0805_SMALL_T02" list(7714.380000 5823.350000) nil "0.10") | 0@@list("R4003" "MX_R0402_SMALL_T01" list(7801.380000 5648.350000) nil "0.10") | 0@@list("R4006" "MX_R0402_SMALL_T01" list(7815.880000 5598.350000) nil "0.10") | 0@@list("R4814" "MX_R0805_SMALL_T02" list(13139.810000 1328.630000) nil "0.10") | 0@@list("R4816" "MX_R0805_SMALL_T02" list(13269.810000 1685.630000) nil "0.10") | 0@@list("R4817" "MX_R0805_SMALL_T02" list(13379.810000 1743.630000) nil "0.10") | 0@@list("R4818" "MX_R0805_SMALL_T02" list(13399.810000 1968.630000) nil "0.10") | 0@@list("R4821" "MX_R0805_SMALL_T02" list(13399.380000 2078.350000) nil "0.10") | 0@@list("R55" "MX_R0603_SMALL_T01" list(6873.630000 1358.910000) nil "0.10") | 0@@list("R56" "MX_R0402_SMALL_T01" list(6974.380000 1523.350000) nil "0.10") | 0@@list("R59" "MX_R0603_SMALL_T01" list(7910.380000 3334.350000) nil "0.10") | 0@@list("R60757" "MX_R0805_SMALL_T02" list(9454.380000 3873.350000) nil "0.10") | 0@@list("R60758" "MX_R0805_SMALL_T02" list(9453.380000 3733.350000) nil "0.10") | 0@@list("R60759" "MX_R0805_SMALL_T02" list(9511.380000 3943.350000) nil "0.10") | 0@@list("R60760" "MX_R0805_SMALL_T02" list(9453.380000 3803.350000) nil "0.10") | 0@@list("R6501" "MX_R0402_SMALL_T01" list(7993.380000 1633.350000) nil "0.10") | 0@@list("R6502" "MX_R0402_SMALL_T01" list(8040.380000 1537.350000) nil "0.10") | 0@@list("R69692" "MX_R0402_SMALL_T01" list(7147.810000 1258.630000) nil "0.10") | 0@@list("R69695" "MX_R0402_SMALL_T01" list(7225.380000 851.350000) nil "0.10") | 0@@list("R70" "MX_R0402_SMALL_T01" list(7805.380000 6212.350000) nil "0.10") | 0@@list("R70261" "MX_R0402_SMALL_T01" list(8375.380000 7028.350000) nil "0.10") | 0@@list("R70262" "MX_R0402_SMALL_T01" list(7147.810000 1218.630000) nil "0.10") | 0@@list("R70263" "MX_R0402_SMALL_T01" list(7084.810000 1258.630000) nil "0.10") | 0@@list("R70264" "MX_R0402_SMALL_T01" list(7084.810000 1218.630000) nil "0.10") | 0@@list("R70274" "MX_R0402_SMALL_T01" list(7157.380000 951.850000) nil "0.10") | 0@@list("R70275" "MX_R0402_SMALL_T01" list(7649.810000 918.630000) nil "0.10") | 0@@list("R70279" "MX_R0402_SMALL_T01" list(7016.880000 3776.350000) nil "0.10") | 0@@list("R70280" "MX_R0402_SMALL_T01" list(7065.380000 3775.350000) nil "0.10") | 0@@list("R70290" "MX_R0402_SMALL_T01" list(7923.380000 2520.350000) nil "0.10") | 0@@list("R70291" "MX_R0402_SMALL_T01" list(7935.380000 2470.350000) nil "0.10") | 0@@list("R70292" "MX_R0402_SMALL_T01" list(8068.380000 1468.350000) nil "0.10") | 0@@list("R70294" "MX_R0402_SMALL_T01" list(7208.810000 4158.070000) nil "0.10") | 0@@list("R70295" "MX_R0402_SMALL_T01" list(8029.380000 1633.350000) nil "0.10") | 0@@list("R70297" "MX_R0402_SMALL_T01" list(7884.380000 1633.350000) nil "0.10") | 0@@list("R70299" "MX_R0402_SMALL_T01" list(8009.380000 1278.350000) nil "0.10") | 0@@list("R70300" "TX_R0402" list(10094.380000 3243.350000) nil "0.10") | 0@@list("R71" "MX_R0402_SMALL_T01" list(7570.380000 6183.350000) nil "0.10") | 0@@list("R7202" "MX_R0402_SMALL_T01" list(7074.380000 2968.350000) nil "0.10") | 0@@list("R7203" "MX_R0402_SMALL_T01" list(7109.380000 3153.350000) nil "0.10") | 0@@list("R7209" "MX_R0402_SMALL_T01" list(7146.380000 3153.350000) nil "0.10") | 0@@list("R7210" "MX_R0402_SMALL_T01" list(7289.380000 3143.350000) nil "0.10") | 0@@list("R7215" "MX_R0402_SMALL_T01" list(7344.380000 3208.350000) nil "0.10") | 0@@list("R7216" "MX_R0402_SMALL_T01" list(7364.380000 3142.350000) nil "0.10") | 0@@list("R79" "MX_R0402_SMALL_T01" list(8712.380000 5869.350000) nil "0.10") | 0@@list("R80" "MX_R0402_SMALL_T01" list(7570.380000 6145.350000) nil "0.10") | 0@@list("R8828" "MX_R0402_SMALL_T01" list(13139.810000 1238.630000) nil "0.10") | 0@@list("R8829" "MX_R0402_SMALL_T01" list(13269.380000 1593.350000) nil "0.10") | 0@@list("R93100" "MX_R0402_SMALL_T01" list(12974.380000 7003.350000) nil "0.10") | 0@@list("R93101" "MX_R0402_SMALL_T01" list(12104.380000 7028.350000) nil "0.10") | 0@@list("R93111" "MX_R0805_SMALL_T02" list(13139.810000 1513.630000) nil "0.10") | 0@@list("R93112" "MX_R0402_SMALL_T01" list(13139.810000 1423.630000) nil "0.10") | 0@@list("R93118" "MX_R0402_SMALL_T01" list(7536.380000 4085.350000) nil "0.10") | 0@@list("R99508" "MX_R0402_SMALL_T01" list(11629.380000 6533.350000) nil "0.10") | 0@@list("R99514" "MX_R0402_SMALL_T01" list(7328.380000 3158.350000) nil "0.10") | 0@@list("R99515" "MX_R0603_SMALL_T01" list(7984.380000 2988.350000) nil "0.10") | 0@@list("R99516" "MX_R0402_SMALL_T01" list(8100.380000 4608.350000) nil "0.10") | 0@@list("R99518" "MX_R0402_SMALL_T01" list(8848.380000 5798.350000) nil "0.10") | 0@@list("R99521" "MX_R0402_SMALL_T01" list(9864.380000 2863.350000) nil "0.10") | 0@@list("R99522" "MX_R0402_SMALL_T01" list(9707.980000 2852.680000) nil "0.10") | 0@@list("R99523" "MX_R0402_SMALL_T01" list(9621.380000 1111.350000) nil "0.10") | 0@@list("R99529" "TX_R0402" list(8050.380000 1573.350000) nil "0.10") | 0@@list("RF3" "MX_C0402_SMALL_T01" list(9022.880000 2367.350000) nil "0.10") | 0@@list("RN107" "TX_2R4P0201_35X28" list(9859.380000 1128.350000) nil "0.10") | 0@@list("RN108" "TX_2R4P0201_35X28" list(9929.380000 1128.350000) nil "0.10") | 0@@list("RN109" "MX_2R4P0402" list(9519.810000 1058.630000) nil "0.10") | 0@@list("RN133" "MX_4R8P0603" list(12324.380000 6623.310000) nil "0.10") | 0@@list("RN134" "MX_4R8P0603" list(12041.880000 6648.310000) nil "0.10") | 0@@list("RN149" "MX_2R4P0402" list(9454.660000 1058.920000) nil "0.10") | 0@@list("RN80" "MX_2R4P0402" list(8388.660000 6380.920000) nil "0.10") | 0@@list("RN86" "MX_2R4P0402" list(8448.660000 6380.920000) nil "0.10") | 0@@list("RN89" "MX_2R4P0402" list(9179.180000 6688.990000) nil "0.10") | 0@@list("RN90" "TX_2R4P0201_35X28" list(9543.010000 6267.280000) nil "0.10") | 0@@list("RN91" "TX_2R4P0201_35X28" list(9616.300000 6269.630000) nil "0.10") | 0@@list("RN95" "MX_2R4P0402" list(9239.950000 6689.630000) nil "0.10") | 0@@list("S1C80" "MX_C0402_SMALL_T01" list(9022.380000 2235.350000) nil "0.10") | 0@@list("S1C81" "MX_C0402_SMALL_T01" list(9020.880000 2122.850000) nil "0.10") | 0@@list("SC1" "MX_C0402_SMALL_T01" list(9856.810000 1223.130000) nil "0.10") | 0@@list("SC13" "MX_C0402_SMALL_T01" list(8102.380000 4465.350000) nil "0.10") | 0@@list("SC14" "MX_C0402_SMALL_T01" list(8055.380000 4426.350000) nil "0.10") | 0@@list("SC144" "MX_C0402_SMALL_T01" list(9270.380000 1214.350000) nil "0.10") | 0@@list("SC145" "MX_C0402_SMALL_T01" list(9306.380000 1214.350000) nil "0.10") | 0@@list("SC15" "MX_C0402_SMALL_T01" list(8058.280000 4284.450000) nil "0.10") | 0@@list("SC16" "MX_C0402_SMALL_T01" list(8096.380000 4321.350000) nil "0.10") | 0@@list("SC17" "MX_C0402_SMALL_T01" list(7994.380000 3952.350000) nil "0.10") | 0@@list("SC18" "MX_C0402_SMALL_T01" list(7994.380000 4016.350000) nil "0.10") | 0@@list("SC2" "MX_C0402_SMALL_T01" list(9892.810000 1223.130000) nil "0.10") | 0@@list("SC21" "MX_C0402_SMALL_T01" list(8133.730000 3905.230000) nil "0.10") | 0@@list("SC22" "MX_C0402_SMALL_T01" list(8133.730000 3868.350000) nil "0.10") | 0@@list("SC25" "TX_C0201" list(8024.380000 2893.350000) nil "0.10") | 0@@list("SC26" "MX_C0402_SMALL_T01" list(8283.380000 2867.350000) nil "0.10") | 0@@list("SC29" "MX_C0402_SMALL_T01" list(8378.380000 3342.350000) nil "0.10") | 0@@list("SC30" "MX_C0402_SMALL_T01" list(8337.380000 3282.350000) nil "0.10") | 0@@list("SC31" "MX_C0402_SMALL_T01" list(8908.500000 4617.350000) nil "0.10") | 0@@list("SC32" "MX_C0402_SMALL_T01" list(8834.500000 4580.350000) nil "0.10") | 0@@list("SC7" "MX_C0402_SMALL_T01" list(9643.380000 6173.040000) nil "0.10") | 0@@list("SC8" "MX_C0402_SMALL_T01" list(9607.380000 6172.730000) nil "0.10") | 0@@list("SC83" "MX_C0402_SMALL_T01" list(8049.380000 2843.350000) nil "0.10") | 0@@list("SC84" "MX_C0402_SMALL_T01" list(8363.380000 4620.350000) nil "0.10") | 0@@list("SC85" "MX_C0402_SMALL_T01" list(8662.380000 4695.140000) nil "0.10") | 0@@list("SC86" "MX_C0402_SMALL_T01" list(8727.880000 4648.350000) nil "0.10") | 0@@list("SC87" "MX_C0402_SMALL_T01" list(7551.380000 1608.350000) nil "0.10") | 0@@list("SC88" "MX_C0402_SMALL_T01" list(9262.380000 5733.230000) nil "0.10") | 0@@list("SC89" "MX_C0402_SMALL_T01" list(9225.380000 5733.350000) nil "0.10") | 0@@list("SCB125" "MX_C0402_SMALL_T01" list(7979.380000 3118.350000) nil "0.10") | 0@@list("SCB126" "MX_C0402_SMALL_T01" list(12852.380000 6732.350000) nil "0.10") | 0@@list("SCB127" "MX_C0805_SMALL_T02" list(7936.380000 3062.350000) nil "0.10") | 0@@list("SCB27" "MX_C0402_SMALL_T01" list(8124.380000 3297.350000) nil "0.10") | 0@@list("SR104" "MX_R0402_SMALL_T01" list(9369.380000 3368.350000) nil "0.10") | 0@@list("SR105" "MX_R0402_SMALL_T01" list(9384.380000 3473.350000) nil "0.10") | 0@@list("SR110" "MX_R0402_SMALL_T01" list(7961.880000 3646.390000) nil "0.10") | 0@@list("SR111" "MX_R0402_SMALL_T01" list(7961.880000 3610.390000) nil "0.10") | 0@@list("SR120" "MX_R0402_SMALL_T01" list(8109.880000 3687.850000) nil "0.10") | 0@@list("SR121" "MX_R0402_SMALL_T01" list(8075.880000 3633.850000) nil "0.10") | 0@@list("SR122" "MX_R0402_SMALL_T01" list(8055.380000 3683.350000) nil "0.10") | 0@@list("SR123" "MX_R0402_SMALL_T01" list(8659.380000 6063.350000) nil "0.10") | 0@@list("SR124" "MX_R0402_SMALL_T01" list(7973.380000 4334.350000) nil "0.10") | 0@@list("SR125" "MX_R0402_SMALL_T01" list(7987.280000 4282.450000) nil "0.10") | 0@@list("SR132" "MX_R0402_SMALL_T01" list(8021.880000 4390.650000) nil "0.10") | 0@@list("SR133" "MX_R0402_SMALL_T01" list(8029.380000 4462.350000) nil "0.10") | 0@@list("SR136" "MX_R0402_SMALL_T01" list(8496.680000 4609.730000) nil "0.10") | 0@@list("SR137" "MX_R0402_SMALL_T01" list(8459.680000 4609.730000) nil "0.10") | 0@@list("SR153" "MX_R0402_SMALL_T01" list(8514.680000 4695.420000) nil "0.10") | 0@@list("SR158" "MX_R0402_SMALL_T01" list(8590.180000 4696.920000) nil "0.10") | 0@@list("SR16" "MX_R0402_SMALL_T01" list(7976.380000 3494.350000) nil "0.10") | 0@@list("SR160" "MX_R0402_SMALL_T01" list(7957.880000 3964.850000) nil "0.10") | 0@@list("SR161" "MX_R0402_SMALL_T01" list(7958.380000 4030.350000) nil "0.10") | 0@@list("SR170" "MX_R0402_SMALL_T01" list(8092.380000 4064.350000) nil "0.10") | 0@@list("SR171" "MX_R0402_SMALL_T01" list(8086.880000 3990.350000) nil "0.10") | 0@@list("SR173" "MX_R0402_SMALL_T01" list(8551.180000 4695.420000) nil "0.10") | 0@@list("SR18" "MX_R0402_SMALL_T01" list(8612.960000 3261.590000) nil "0.10") | 0@@list("SR184" "MX_R0402_SMALL_T01" list(8098.380000 4027.350000) nil "0.10") | 0@@list("SR185" "MX_R0402_SMALL_T01" list(8176.380000 3979.350000) nil "0.10") | 0@@list("SR20" "MX_R0402_SMALL_T01" list(9333.380000 3099.350000) nil "0.10") | 0@@list("SR211" "MX_R0402_SMALL_T01" list(7975.380000 3883.350000) nil "0.10") | 0@@list("SR213" "MX_R0402_SMALL_T01" list(9774.380000 1333.350000) nil "0.10") | 0@@list("SR217" "MX_R0402_SMALL_T01" list(6964.380000 2608.350000) nil "0.10") | 0@@list("SR22" "MX_R0402_SMALL_T01" list(9370.380000 3254.350000) nil "0.10") | 0@@list("SR220" "MX_R0402_SMALL_T01" list(7627.880000 1608.350000) nil "0.10") | 0@@list("SR221" "MX_R0402_SMALL_T01" list(7516.380000 2462.350000) nil "0.10") | 0@@list("SR222" "MX_R0402_SMALL_T01" list(8659.380000 3064.850000) nil "0.10") | 0@@list("SR230" "MX_R0402_SMALL_T01" list(8024.380000 3879.350000) nil "0.10") | 0@@list("SR251" "MX_R0402_SMALL_T01" list(8105.380000 3480.350000) nil "0.10") | 0@@list("SR252" "MX_R0402_SMALL_T01" list(8067.960000 3406.350000) nil "0.10") | 0@@list("SR253" "MX_R0402_SMALL_T01" list(8072.380000 3443.350000) nil "0.10") | 0@@list("SR254" "MX_R0402_SMALL_T01" list(8072.380000 3368.350000) nil "0.10") | 0@@list("SR255" "MX_R0402_SMALL_T01" list(8283.380000 2948.350000) nil "0.10") | 0@@list("SR257" "MX_R0402_SMALL_T01" list(8024.380000 2933.350000) nil "0.10") | 0@@list("SR264" "MX_R0402_SMALL_T01" list(8362.380000 4673.350000) nil "0.10") | 0@@list("SR267" "MX_R0402_SMALL_T01" list(9399.380000 5048.350000) nil "0.10") | 0@@list("SR280" "MX_R0402_SMALL_T01" list(7598.380000 1452.350000) nil "0.10") | 0@@list("SR289" "MX_R0402_SMALL_T01" list(8180.380000 2828.350000) nil "0.10") | 0@@list("SR291" "MX_R0402_SMALL_T01" list(8283.380000 2829.350000) nil "0.10") | 0@@list("SR292" "MX_R0402_SMALL_T01" list(8326.880000 4620.350000) nil "0.10") | 0@@list("SR316" "MX_R0402_SMALL_T01" list(9391.380000 4221.350000) nil "0.10") | 0@@list("SR320" "MX_R0402_SMALL_T01" list(8414.380000 3309.350000) nil "0.10") | 0@@list("SR321" "MX_R0402_SMALL_T01" list(8898.380000 4580.350000) nil "0.10") | 0@@list("SR322" "MX_R0402_SMALL_T01" list(9225.380000 4596.230000) nil "0.10") | 0@@list("SR35" "MX_R0402_SMALL_T01" list(8574.380000 3240.350000) nil "0.10") | 0@@list("SR3701" "MX_R0402_SMALL_T01" list(9509.380000 5937.350000) nil "0.10") | 0@@list("SR404" "MX_R0402_SMALL_T01" list(9330.380000 3063.350000) nil "0.10") | 0@@list("SR41" "MX_R0402_SMALL_T01" list(8724.380000 6063.350000) nil "0.10") | 0@@list("SR416" "MX_R0402_SMALL_T01" list(7956.380000 2913.350000) nil "0.10") | 0@@list("SR44" "MX_R0402_SMALL_T01" list(8031.880000 3531.350000) nil "0.10") | 0@@list("SR552" "MX_R0402_SMALL_T01" list(8777.380000 4657.350000) nil "0.10") | 0@@list("SR672" "MX_R0402_SMALL_T01" list(7920.380000 3818.350000) nil "0.10") | 0@@list("SR674" "MX_R0402_SMALL_T01" list(8043.880000 3785.850000) nil "0.10") | 0@@list("SR698" "MX_R0402_SMALL_T01" list(8100.380000 4645.350000) nil "0.10") | 0@@list("SR699" "MX_R0402_SMALL_T01" list(7924.380000 4788.350000) nil "0.10") | 0@@list("SR700" "MX_R0402_SMALL_T01" list(7935.380000 4545.850000) nil "0.10") | 0@@list("SR701" "MX_R0402_SMALL_T01" list(7941.380000 4509.850000) nil "0.10") | 0@@list("SR702" "MX_R0402_SMALL_T01" list(8101.380000 4685.350000) nil "0.10") | 0@@list("SR703" "MX_R0402_SMALL_T01" list(7955.380000 4473.750000) nil "0.10") | 0@@list("SR764" "MX_R0402_SMALL_T01" list(8626.180000 4696.920000) nil "0.10") | 0@@list("SR765" "MX_R0402_SMALL_T01" list(8610.180000 4607.630000) nil "0.10") | 0@@list("SR766" "MX_R0402_SMALL_T01" list(8646.180000 4607.630000) nil "0.10") | 0@@list("SR7795" "MX_R0402_SMALL_T01" list(7598.380000 1671.850000) nil "0.10") | 0@@list("SR7796" "MX_R0402_SMALL_T01" list(7939.380000 3882.350000) nil "0.10") | 0@@list("SR7802" "MX_R0402_SMALL_T01" list(7565.810000 4996.630000) nil "0.10") | 0@@list("SR7813" "MX_R0402_SMALL_T01" list(7086.810000 1354.130000) nil "0.10") | 0@@list("SR7814" "MX_R0402_SMALL_T01" list(7021.810000 1360.130000) nil "0.10") | 0@@list("SR7838" "MX_R0402_SMALL_T01" list(7960.380000 3454.350000) nil "0.10") | 0@@list("SR7842" "MX_R0402_SMALL_T01" list(8061.380000 3905.850000) nil "0.10") | 0@@list("SR7844" "MX_R0402_SMALL_T01" list(7928.380000 3702.850000) nil "0.10") | 0@@list("SR7853" "MX_R0402_SMALL_T01" list(8708.380000 3339.350000) nil "0.10") | 0@@list("SR7862" "MX_R0402_SMALL_T01" list(7961.880000 3574.390000) nil "0.10") | 0@@list("SR7868" "MX_R0402_SMALL_T01" list(8028.380000 3569.350000) nil "0.10") | 0@@list("SR7870" "MX_R0402_SMALL_T01" list(8057.880000 3733.350000) nil "0.10") | 0@@list("SR7871" "MX_R0402_SMALL_T01" list(7994.380000 3739.350000) nil "0.10") | 0@@list("SR7872" "MX_R0402_SMALL_T01" list(7998.380000 3690.350000) nil "0.10") | 0@@list("SR7874" "MX_R0402_SMALL_T01" list(8140.380000 3731.350000) nil "0.10") | 0@@list("SR7875" "MX_R0402_SMALL_T01" list(8142.380000 3767.350000) nil "0.10") | 0@@list("SR7876" "MX_R0402_SMALL_T01" list(8560.380000 1922.350000) nil "0.10") | 0@@list("SR7880" "MX_R0402_SMALL_T01" list(9559.380000 2358.350000) nil "0.10") | 0@@list("SR7884" "MX_R0402_SMALL_T01" list(6964.810000 1353.630000) nil "0.10") | 0@@list("SR7885" "MX_R0402_SMALL_T01" list(8932.380000 2272.850000) nil "0.10") | 0@@list("SR7886" "MX_R0402_SMALL_T01" list(8932.380000 2236.350000) nil "0.10") | 0@@list("SR7902" "MX_R0402_SMALL_T01" list(10900.380000 7014.350000) nil "0.10") | 0@@list("SR7903" "MX_R0402_SMALL_T01" list(11167.380000 7028.350000) nil "0.10") | 0@@list("SR7904" "MX_R0402_SMALL_T01" list(11679.380000 6548.350000) nil "0.10") | 0@@list("SR7906" "MX_R0402_SMALL_T01" list(10899.380000 6963.350000) nil "0.10") | 0@@list("SR7907" "MX_R0402_SMALL_T01" list(11156.380000 6529.350000) nil "0.10") | 0@@list("SR7922" "MX_R0402_SMALL_T01" list(8194.380000 2888.350000) nil "0.10") | 0@@list("SR7923" "MX_R0402_SMALL_T01" list(8059.380000 2988.350000) nil "0.10") | 0@@list("SR7929" "MX_R0402_SMALL_T01" list(9311.380000 3309.350000) nil "0.10") | 0@@list("SR7930" "MX_R0402_SMALL_T01" list(9364.380000 3306.350000) nil "0.10") | 0@@list("SR7932" "MX_R0402_SMALL_T01" list(8214.380000 2238.360000) nil "0.10") | 0@@list("SR7933" "MX_R0402_SMALL_T01" list(8249.390000 2168.350000) nil "0.10") | 0@@list("SR7934" "MX_R0402_SMALL_T01" list(8094.380000 4103.350000) nil "0.10") | 0@@list("SR7935" "MX_R0402_SMALL_T01" list(8094.380000 4141.050000) nil "0.10") | 0@@list("SR7940" "MX_R0402_SMALL_T01" list(7891.380000 3737.350000) nil "0.10") | 0@@list("SR7942" "MX_R0402_SMALL_T01" list(7422.380000 4266.350000) nil "0.10") | 0@@list("SR7943" "MX_R0402_SMALL_T01" list(8066.380000 4189.350000) nil "0.10") | 0@@list("SR7956" "MX_R0402_SMALL_T01" list(9369.380000 3408.350000) nil "0.10") | 0@@list("SR7975" "MX_R0402_SMALL_T01" list(8044.380000 3295.350000) nil "0.10") | 0@@list("SR7982" "MX_R0402_SMALL_T01" list(7624.380000 3243.350000) nil "0.10") | 0@@list("SR7983" "MX_R0402_SMALL_T01" list(7624.380000 3283.350000) nil "0.10") | 0@@list("SR7988" "MX_R0402_SMALL_T01" list(8129.380000 2888.350000) nil "0.10") | 0@@list("SR7989" "MX_R0402_SMALL_T01" list(7961.080000 4123.250000) nil "0.10") | 0@@list("SR7993" "MX_R0402_SMALL_T01" list(9559.380000 2398.350000) nil "0.10") | 0@@list("SR7996" "MX_R0402_SMALL_T01" list(8304.380000 2151.350000) nil "0.10") | 0@@list("SR7997" "MX_R0402_SMALL_T01" list(8382.380000 2142.350000) nil "0.10") | 0@@list("SR7998" "MX_R0402_SMALL_T01" list(9541.380000 5654.350000) nil "0.10") | 0@@list("SR7999" "MX_R0402_SMALL_T01" list(9568.380000 5923.350000) nil "0.10") | 0@@list("SR8000" "MX_R0402_SMALL_T01" list(9509.380000 5981.350000) nil "0.10") | 0@@list("SR8001" "MX_R0402_SMALL_T01" list(8089.380000 2187.350000) nil "0.10") | 0@@list("SR8002" "MX_R0402_SMALL_T01" list(9509.380000 5896.350000) nil "0.10") | 0@@list("SR817" "MX_R0402_SMALL_T01" list(7657.380000 6142.350000) nil "0.10") | 0@@list("SR818" "MX_R0402_SMALL_T01" list(7621.380000 6142.350000) nil "0.10") | 0@@list("SR87" "MX_R0402_SMALL_T01" list(8724.380000 4598.350000) nil "0.10") | 0@@list("SR916" "MX_R0402_SMALL_T01" list(7021.810000 1397.130000) nil "0.10") | 0@@list("SSD_Q2" "TX_SOT23_2D4_122X55_H44" list(7304.380000 3860.350000) nil "0.10") | 0@@list("ST24" "MX_TPC26T_S4_68" list(8779.380000 4581.350000) nil "0.10") | 0@@list("ST32" "MX_TPC26T_S4_68" list(7285.380000 4053.350000) nil "0.10") | 0@@list("SW_RST1" "MX_SW_4P_181X126" list(6901.810000 1183.630000) nil "0.10") | 0@@list("TC1" "MX_C0402_SMALL_T01" list(7084.810000 4987.630000) nil "0.10") | 0@@list("TC2" "MX_C0402_SMALL_T01" list(7120.810000 4987.630000) nil "0.10") | 0@@list("TC3" "MX_C0402_SMALL_T01" list(7280.810000 4983.630000) nil "0.10") | 0@@list("TC4" "MX_C0402_SMALL_T01" list(7316.810000 4983.630000) nil "0.10") | 0@@list("TC5" "MX_C0402_SMALL_T01" list(7182.810000 4980.630000) nil "0.10") | 0@@list("TC6" "MX_C0402_SMALL_T01" list(7218.810000 4980.630000) nil "0.10") | 0@@list("TC7" "MX_C0402_SMALL_T01" list(7377.310000 4984.630000) nil "0.10") | 0@@list("TC8" "MX_C0402_SMALL_T01" list(7413.310000 4984.630000) nil "0.10") | 0@@list("TUC24" "MX_C0603_SMALL_T01" list(8364.380000 6919.350000) nil "0.10") | 0@@list("TUC31" "MX_C0603_SMALL_T01" list(8431.380000 6970.350000) nil "0.10") | 0@@list("TUC33" "MX_C0603_SMALL_T01" list(9704.380000 1105.350000) nil "0.10") | 0@@list("TUC34" "MX_C0603_SMALL_T01" list(9666.380000 1238.350000) nil "0.10") | 0@@list("TUC35" "TX_C0805_T02_H55" list(8449.320000 6816.290000) nil "0.10") | 0@@list("TUC38" "TX_C0805_T02_H55" list(9604.380000 1057.350000) nil "0.10") | 0@@list("U9435" "TX_SOIC_16P_50_413X299_WIN" list(9007.380000 3116.350000) nil "0.10") | 0@@list("UU22" "MX_SOT23_S5_H57" list(8343.980000 6800.260000) nil "0.10") | 0@@list("UU66" "TX_SOT23_S5_2D4_T02X01_H57" list(9760.380000 1220.350000) nil "0.10") | 0@@list("VD11" "MX_SOT323" list(12570.630000 6602.100000) nil "0.10") | 0@@list("X3R14" "MX_R0402_SMALL_T01" list(7507.110000 4508.920000) nil "0.10") | 0@@list("X3R20" "MX_R0402_SMALL_T01" list(7701.380000 4446.350000) nil "0.10") | 0@@list("X3R21" "MX_R0402_SMALL_T01" list(7558.380000 4498.350000) nil "0.10") | 0@@list("Y18" "MX_XTAL_4P_126X98_HELE" list(8893.500000 4705.350000) nil "0.10") | 0@@list("Y5" "MX_XTAL_4P_272X55" list(8276.380000 3158.850000) nil "0.10") | 100@@5s-ipcfl-cg.a00r@@P143000044-PC@@eric2_tseng@@Jan 24 14:12:56 2019 | 1@@list("DIMM1" "MX_DDR4_260P_20_4HOD_FOX" list(11687.400000 2422.440000) nil "0.13") | 1@@list("DIMM2" "MX_DDR4_260P_20_4H_STD_FX" list(11687.010000 2894.880000) nil "0.13") | 1@@list("U6" "MX_QFN_48P_16_S240_PAD_9V" list(7489.810000 1188.450000) nil "0.08") | 1@@list("XU1" "MX_SOCKET1151_FOXN_3HD" list(11642.920000 4737.400000) nil "0.13") | 2@@list("" "INDEXB_CROSS" list(11881.380000 827.350000) t "0.10") | 2@@list("" "INDEXB_CROSS" list(6915.810000 1086.630000) t "0.10") | 2@@list("" "INDEXB_CROSS" list(7274.380000 6532.350000) t "0.10") | 2@@list("" "INDEXB_CROSS" list(9429.380000 5685.350000) t "0.10") | 2@@list("AC208" "MX_C0805_SMALL_T02" list(8512.380000 5755.350000) t "0.10") | 2@@list("AC209" "MX_C0402_SMALL_T01" list(8528.380000 5583.350000) t "0.10") | 2@@list("AC47" "MX_C0402_SMALL_T01" list(7018.810000 4191.350000) t "0.10") | 2@@list("AC5" "MX_C0402_SMALL_T01" list(7711.810000 1379.630000) t "0.10") | 2@@list("AC52" "MX_C0603_SMALL_T01" list(7754.810000 1382.630000) t "0.10") | 2@@list("AC53" "MX_C0402_SMALL_T01" list(7688.380000 1159.850000) t "0.10") | 2@@list("AC6" "MX_C0402_SMALL_T01" list(8172.710000 4679.280000) t "0.10") | 2@@list("AC82" "MX_C0603_SMALL_T01" list(7655.310000 1350.630000) t "0.10") | 2@@list("AC88" "MX_C0603_SMALL_T01" list(7652.810000 1064.630000) t "0.10") | 2@@list("AC89" "MX_C0603_SMALL_T01" list(7732.380000 1069.350000) t "0.10") | 2@@list("APR10" "MX_R0402_SMALL_T01" list(8674.310000 2527.350000) t "0.10") | 2@@list("APR117" "MX_R0402_SMALL_T01" list(7062.810000 4786.630000) t "0.10") | 2@@list("APR127" "MX_R0402_SMALL_T01" list(7826.380000 2112.350000) t "0.10") | 2@@list("APR128" "MX_R0402_SMALL_T01" list(7863.380000 2112.350000) t "0.10") | 2@@list("APR130" "MX_R0402_SMALL_T01" list(12124.810000 1958.630000) t "0.10") | 2@@list("APR131" "MX_R0402_SMALL_T01" list(12224.810000 1991.630000) t "0.10") | 2@@list("APR134" "MX_R0402_SMALL_T01" list(8134.380000 2604.350000) t "0.10") | 2@@list("APR135" "MX_R0402_SMALL_T01" list(8817.380000 2727.350000) t "0.10") | 2@@list("APR6" "MX_R0402_SMALL_T01" list(8436.380000 2504.350000) t "0.10") | 2@@list("APR7" "MX_R0402_SMALL_T01" list(8004.380000 2052.350000) t "0.10") | 2@@list("APR8" "MX_R0402_SMALL_T01" list(8610.380000 2522.780000) t "0.10") | 2@@list("APR9" "MX_R0402_SMALL_T01" list(9037.380000 2440.350000) t "0.10") | 2@@list("AQ17" "TX_SOIC_6P_26_87X53_COLY" list(10980.600000 6992.780000) t "0.10") | 2@@list("AR19" "MX_R0402_SMALL_T01" list(7834.380000 1022.850000) t "0.10") | 2@@list("AR29" "MX_R0402_SMALL_T01" list(7871.380000 1022.850000) t "0.10") | 2@@list("AR30" "MX_L0603" list(13350.380000 2145.370000) t "0.10") | 2@@list("AR31" "MX_L0603" list(13280.380000 2143.370000) t "0.10") | 2@@list("AR38" "MX_R0603_SMALL_T01" list(7855.380000 1084.350000) t "0.10") | 2@@list("AR41" "MX_R0402_SMALL_T01" list(10047.880000 5083.350000) t "0.10") | 2@@list("C15" "MX_C0402_SMALL_T01" list(8089.880000 3599.230000) t "0.10") | 2@@list("C16" "MX_C0402_SMALL_T01" list(8085.380000 3634.930000) t "0.10") | 2@@list("C17" "MX_C0402_SMALL_T01" list(8095.880000 3672.050000) t "0.10") | 2@@list("C18" "MX_C0402_SMALL_T01" list(8091.880000 3709.350000) t "0.10") | 2@@list("C200" "MX_C0402_SMALL_T01" list(8343.380000 4276.350000) t "0.10") | 2@@list("C202" "MX_C0402_SMALL_T01" list(10050.880000 6345.350000) t "0.10") | 2@@list("C258" "MX_C0402_SMALL_T01" list(13318.380000 2327.350000) t "0.10") | 2@@list("C306" "MX_C0402_SMALL_T01" list(8788.380000 5626.350000) t "0.10") | 2@@list("C4004" "MX_C0402_SMALL_T015" list(7389.380000 5728.350000) t "0.10") | 2@@list("C4005" "MX_C0402_SMALL_T015" list(7389.380000 5663.350000) t "0.10") | 2@@list("C4018" "MX_C0402_SMALL_T01" list(7460.380000 5934.850000) t "0.10") | 2@@list("C4019" "MX_C0402_SMALL_T01" list(7496.380000 5934.850000) t "0.10") | 2@@list("C4020" "MX_C0402_SMALL_T01" list(7388.380000 5921.350000) t "0.10") | 2@@list("C4021" "MX_C0402_SMALL_T01" list(7424.380000 5921.350000) t "0.10") | 2@@list("C4022" "MX_C0402_SMALL_T01" list(7759.380000 5698.350000) t "0.10") | 2@@list("C4023" "MX_C0402_SMALL_T01" list(7724.380000 5768.350000) t "0.10") | 2@@list("C4024" "MX_C0402_SMALL_T01" list(7535.380000 6014.350000) t "0.10") | 2@@list("C45" "MX_C0402_SMALL_T01" list(8788.380000 5590.350000) t "0.10") | 2@@list("C7201" "MX_C0603_SMALL_T01" list(7116.380000 2831.350000) t "0.10") | 2@@list("C7202" "MX_C0603_SMALL_T01" list(7431.380000 2824.350000) t "0.10") | 2@@list("C7203" "MX_C0402_SMALL_T01" list(7151.380000 3070.350000) t "0.10") | 2@@list("C7204" "MX_C0402_SMALL_T01" list(7155.380000 3025.350000) t "0.10") | 2@@list("C7205" "TX_C0201" list(7259.380000 2794.350000) t "0.10") | 2@@list("C7206" "TX_C0201" list(7531.380000 3062.350000) t "0.10") | 2@@list("C7207" "TX_C0201" list(7531.380000 3088.350000) t "0.10") | 2@@list("C7208" "MX_C0402_SMALL_T01" list(7066.380000 2991.350000) t "0.10") | 2@@list("C7209" "TX_C0402_H24" list(7393.880000 3162.350000) t "0.10") | 2@@list("C7210" "MX_C0402_SMALL_T01" list(7393.380000 3125.350000) t "0.10") | 2@@list("C81" "MX_C0402_SMALL_T01" list(7563.380000 4708.350000) t "0.10") | 2@@list("C82" "MX_C0402_SMALL_T01" list(7611.660000 4797.070000) t "0.10") | 2@@list("C83" "MX_C0402_SMALL_T01" list(9752.290000 5874.600000) t "0.10") | 2@@list("C8301" "MX_C0402_SMALL_T01" list(6911.710000 2156.950000) t "0.10") | 2@@list("C8302" "MX_C0402_SMALL_T01" list(6958.380000 5409.350000) t "0.10") | 2@@list("C8303" "MX_C0402_SMALL_T01" list(6959.780000 3178.680000) t "0.10") | 2@@list("C8304" "MX_C0402_SMALL_T01" list(6966.380000 2156.350000) t "0.10") | 2@@list("C8305" "MX_C0402_SMALL_T01" list(10296.870000 1249.910000) t "0.10") | 2@@list("C8306" "MX_C0402_SMALL_T01" list(10337.870000 1249.910000) t "0.10") | 2@@list("C8307" "MX_C0402_SMALL_T01" list(10364.870000 961.910000) t "0.10") | 2@@list("C8309" "MX_C0402_SMALL_T01" list(11714.380000 4502.350000) t "0.10") | 2@@list("C8310" "MX_C0402_SMALL_T01" list(10443.380000 3349.350000) t "0.10") | 2@@list("C8311" "MX_C0402_SMALL_T01" list(12569.380000 3719.350000) t "0.10") | 2@@list("C8312" "MX_C0402_SMALL_T01" list(11382.380000 4501.350000) t "0.10") | 2@@list("C8313" "MX_C0402_SMALL_T01" list(9151.380000 4494.350000) t "0.10") | 2@@list("C8314" "MX_C0402_SMALL_T01" list(8841.380000 3820.850000) t "0.10") | 2@@list("C8315" "MX_C0402_SMALL_T01" list(8939.380000 4054.350000) t "0.10") | 2@@list("C8316" "MX_C0805_SMALL_T02" list(8950.380000 1223.350000) t "0.10") | 2@@list("C85" "TX_C0402_H24" list(7788.810000 4724.630000) t "0.10") | 2@@list("C86" "MX_C0603_SMALL_T01" list(8208.380000 4390.350000) t "0.10") | 2@@list("C94" "MX_C0402_SMALL_T01" list(11219.810000 1993.630000) t "0.10") | 2@@list("C941490" "MX_C0603_SMALL_T02" list(10539.730000 1443.630000) t "0.10") | 2@@list("C941491" "MX_C0603_SMALL_T02" list(10591.730000 1443.630000) t "0.10") | 2@@list("C941631" "MX_C0603_SMALL_T02" list(11234.860000 4973.630000) t "0.10") | 2@@list("C941632" "MX_C0603_SMALL_T02" list(11235.860000 4921.630000) t "0.10") | 2@@list("C941635" "MX_C0402_SMALL_T01" list(9352.880000 2081.350000) t "0.10") | 2@@list("C941643" "MX_C0603_SMALL_T01" list(8469.380000 4198.850000) t "0.10") | 2@@list("C941644" "MX_C0603_SMALL_T01" list(8717.860000 4075.350000) t "0.10") | 2@@list("C9478" "MX_C0402_SMALL_T01" list(6895.380000 6176.350000) t "0.10") | 2@@list("CB4132" "MX_C0402_SMALL_T01" list(11955.810000 2757.130000) t "0.10") | 2@@list("CB4135" "MX_C0402_SMALL_T01" list(10214.810000 5282.630000) t "0.10") | 2@@list("D3105" "MX_S0402_AMAZ_COLAY_T01" list(7439.890000 6107.710000) t "0.10") | 2@@list("D3601" "MX_ESD_10P_20_98X39_NXP" list(9584.380000 6268.350000) t "0.10") | 2@@list("D4309" "MX_SOT323" list(7942.130000 2193.100000) t "0.10") | 2@@list("D4C10" "MX_C0603_SMALL_T02" list(11295.690000 2780.630000) t "0.10") | 2@@list("D4C11" "MX_C0402_SMALL_T01" list(11285.810000 2824.630000) t "0.10") | 2@@list("D4C12" "MX_C0402_SMALL_T01" list(10437.810000 2278.630000) t "0.10") | 2@@list("D4C13" "TX_C0201_T009_H14" list(10417.810000 2178.630000) t "0.10") | 2@@list("D4C14" "TX_C0201_T009_H14" list(10437.810000 2241.630000) t "0.10") | 2@@list("D4C15" "TX_C0201_T009_H14" list(10394.810000 2583.630000) t "0.10") | 2@@list("D4C16" "MX_C0402_SMALL_T01" list(11972.380000 2175.350000) t "0.10") | 2@@list("D4C17" "MX_C0603_SMALL_T01" list(10470.810000 2718.130000) t "0.10") | 2@@list("D4C18" "MX_C0402_SMALL_T01" list(10446.810000 2760.130000) t "0.10") | 2@@list("D4C19" "MX_C0402_SMALL_T01" list(10458.810000 2918.630000) t "0.10") | 2@@list("D4C20" "MX_C0201" list(11529.810000 2282.130000) t "0.10") | 2@@list("D4C21" "MX_C0603_SMALL_T02" list(11320.380000 2257.350000) t "0.10") | 2@@list("D4C22" "MX_C0402_SMALL_T01" list(11402.380000 2253.350000) t "0.10") | 2@@list("D4C23" "MX_C0402_SMALL_T01" list(11285.810000 2863.630000) t "0.10") | 2@@list("D4C24" "MX_C0402_SMALL_T01" list(11365.380000 2253.350000) t "0.10") | 2@@list("D4C25" "MX_C0402_SMALL_T01" list(11439.380000 2253.350000) t "0.10") | 2@@list("D4C26" "MX_C0402_SMALL_T01" list(11817.810000 3076.630000) t "0.10") | 2@@list("D4C27" "MX_C0402_SMALL_T01" list(11394.380000 2600.350000) t "0.10") | 2@@list("D4C28" "MX_C0402_SMALL_T01" list(9292.380000 6284.350000) t "0.10") | 2@@list("D4C32" "MX_C0402_SMALL_T01" list(11992.380000 2285.350000) t "0.10") | 2@@list("D4C33" "MX_C0402_SMALL_T01" list(11529.810000 2210.130000) t "0.10") | 2@@list("D4C34" "MX_C0402_SMALL_T01" list(11289.380000 2683.350000) t "0.10") | 2@@list("D4C5" "MX_C0402_SMALL_T01" list(12005.810000 2740.630000) t "0.10") | 2@@list("D4C9" "MX_C0201" list(11532.380000 2657.350000) t "0.10") | 2@@list("D4CB10" "MX_C0201" list(11006.940000 2622.080000) t "0.10") | 2@@list("D4CB11" "MX_C0201" list(12084.380000 2275.350000) t "0.10") | 2@@list("D4CB12" "MX_C0201" list(11806.590000 2576.630000) t "0.10") | 2@@list("D4CB13" "MX_C0201" list(12259.380000 2584.350000) t "0.10") | 2@@list("D4CB14" "MX_C0201" list(11765.380000 2671.350000) t "0.10") | 2@@list("D4CB15" "MX_C0201" list(11574.810000 2657.630000) t "0.10") | 2@@list("D4CB16" "MX_C0402_SMALL_T01" list(12499.410000 2263.630000) t "0.10") | 2@@list("D4CB17" "MX_C0603_SMALL_T02" list(10734.060000 2717.630000) t "0.10") | 2@@list("D4CB18" "MX_C0603_SMALL_T02" list(10526.810000 3057.630000) t "0.10") | 2@@list("D4CB19" "MX_C0603_SMALL_T02" list(12901.380000 2740.350000) t "0.10") | 2@@list("D4CB20" "MX_C0603_SMALL_T02" list(12695.380000 2949.350000) t "0.10") | 2@@list("D4CB21" "MX_C0603_SMALL_T02" list(12853.380000 2208.350000) t "0.10") | 2@@list("D4CB22" "MX_C0603_SMALL_T02" list(10596.300000 2599.260000) t "0.10") | 2@@list("D4CB23" "MX_C0603_SMALL_T02" list(10734.450000 2273.630000) t "0.10") | 2@@list("D4CB24" "MX_C0603_SMALL_T02" list(12677.380000 2564.350000) t "0.10") | 2@@list("D4CB5" "MX_C0201" list(11534.380000 2938.350000) t "0.10") | 2@@list("D4CB6" "MX_C0201" list(11087.380000 2581.350000) t "0.10") | 2@@list("D4CB7" "MX_C0201" list(11160.440000 2745.630000) t "0.10") | 2@@list("D4CB8" "MX_C0201" list(12444.380000 2713.350000) t "0.10") | 2@@list("D4CB9" "MX_C0201" list(11200.200000 2253.630000) t "0.10") | 2@@list("D4CE1" "MX_C7343D_H79" list(11439.380000 3267.350000) t "0.10") | 2@@list("D4CE2" "MX_C7343D_H79" list(11758.810000 2242.630000) t "0.10") | 2@@list("D4R14" "MX_R0402_SMALL_T01" list(11662.380000 2375.650000) t "0.10") | 2@@list("D4R16" "MX_R0402_SMALL_T01" list(10414.380000 2374.350000) t "0.10") | 2@@list("D4R18" "MX_R0402_SMALL_T01" list(11239.810000 2250.020000) t "0.10") | 2@@list("D4R19" "MX_R0402_SMALL_T01" list(11529.810000 2246.130000) t "0.10") | 2@@list("D4R2" "MX_R0402_SMALL_T01" list(11689.810000 2733.630000) t "0.10") | 2@@list("D4R20" "MX_R0402_SMALL_T01" list(11529.810000 2169.350000) t "0.10") | 2@@list("D4R22" "MX_R0402_SMALL_T01" list(10345.310000 2267.630000) t "0.10") | 2@@list("D4R7" "MX_R0402_SMALL_T01" list(11201.810000 2742.630000) t "0.10") | 2@@list("D4R8" "MX_R0402_SMALL_T01" list(11373.810000 2715.130000) t "0.10") | 2@@list("D4R9" "MX_R0402_SMALL_T01" list(11373.810000 2751.130000) t "0.10") | 2@@list("D4T2" "MX_TPC26T_S4_68" list(11389.380000 2813.350000) t "0.10") | 2@@list("D4T3" "MX_TPC26T_S4_68" list(11300.380000 2421.350000) t "0.10") | 2@@list("D4T4" "MX_TPC26T_S4_68" list(11299.380000 2352.350000) t "0.10") | 2@@list("D521" "MX_SOT323" list(11038.210000 1863.070000) t "0.10") | 2@@list("D522" "MX_SOT323" list(8090.130000 2208.100000) t "0.10") | 2@@list("D5501" "MX_S0402_AMAZ_COLAY" list(6955.880000 1246.350000) t "0.10") | 2@@list("D5502" "MX_S0402_AMAZ_COLAY" list(6851.380000 1289.350000) t "0.10") | 2@@list("D5503" "MX_S0402_AMAZ_COLAY" list(6899.880000 1245.350000) t "0.10") | 2@@list("ECR103" "MX_R0402_SMALL_T01" list(8035.380000 3861.850000) t "0.10") | 2@@list("ECR107" "MX_R0402_SMALL_T01" list(7766.380000 3108.350000) t "0.10") | 2@@list("ECR108" "MX_R0402_SMALL_T01" list(7727.380000 3108.350000) t "0.10") | 2@@list("ECR109" "MX_R0402_SMALL_T01" list(7842.380000 3109.350000) t "0.10") | 2@@list("ECR110" "MX_R0402_SMALL_T01" list(7804.380000 3108.350000) t "0.10") | 2@@list("ECR142" "MX_R0402_SMALL_T01" list(7939.380000 4400.350000) t "0.10") | 2@@list("ECR159" "MX_R0402_SMALL_T01" list(8418.380000 5747.350000) t "0.10") | 2@@list("ECR160" "MX_R0402_SMALL_T01" list(8418.380000 5683.350000) t "0.10") | 2@@list("F3R70" "MX_R0402_SMALL_T01" list(7476.380000 2989.700000) t "0.10") | 2@@list("FCB2" "MX_C0402_SMALL_T01" list(13088.380000 3126.350000) t "0.10") | 2@@list("FD1" "MX_SOT323" list(13087.630000 3015.600000) t "0.10") | 2@@list("H1" "HOLE_C315D181N_M2_P2_V8" list(9929.530000 5564.180000) nil "0.10") | 2@@list("H5" "HOLE_C315D181N_M2_P2_V8" list(13315.360000 5564.180000) nil "0.10") | 2@@list("H9" "HOLE_C394D157N_M2_P2_V8_SPE" list(9954.740000 2190.160000) nil "0.10") | 2@@list("HC11" "MX_C0603_SMALL_T02" list(9051.880000 4589.850000) t "0.10") | 2@@list("HC12" "MX_C0603_SMALL_T02" list(9051.880000 4537.850000) t "0.10") | 2@@list("HC13" "MX_C0603_SMALL_T02" list(9148.880000 4055.730000) t "0.10") | 2@@list("HC14" "TX_C0201_T009_H14" list(8963.380000 3840.470000) t "0.10") | 2@@list("HC16" "TX_C0201_T009_H14" list(8775.500000 4061.350000) t "0.10") | 2@@list("HC17" "TX_C0201_T009_H14" list(8894.260000 3826.350000) t "0.10") | 2@@list("HC18" "TX_C0201_T009_H14" list(8801.880000 3841.350000) t "0.10") | 2@@list("HC19" "MX_C0603_SMALL_T02" list(9254.380000 3541.350000) t "0.10") | 2@@list("HC20" "MX_C0603_SMALL_T02" list(9254.380000 3489.350000) t "0.10") | 2@@list("HC21" "TX_C0201_T009_H14" list(9243.380000 3439.350000) t "0.10") | 2@@list("HC23" "TX_C0201_T009_H14" list(8826.380000 4153.350000) t "0.10") | 2@@list("HC24" "TX_C0201_T009_H14" list(9222.380000 4492.350000) t "0.10") | 2@@list("HC25" "TX_C0201_T009_H14" list(8902.180000 4051.850000) t "0.10") | 2@@list("HC26" "TX_C0201_T009_H14" list(9187.380000 4492.350000) t "0.10") | 2@@list("HC27" "TX_C0201_T009_H14" list(8775.500000 3995.350000) t "0.10") | 2@@list("HC28" "TX_C0201_T009_H14" list(8789.260000 4153.350000) t "0.10") | 2@@list("HC29" "TX_C0201_T009_H14" list(8816.260000 3906.350000) t "0.10") | 2@@list("HC30" "MX_C0402_SMALL_T01" list(12081.380000 5066.350000) t "0.10") | 2@@list("HC31" "MX_C0402_SMALL_T01" list(11141.380000 4953.350000) t "0.10") | 2@@list("HC6" "MX_C0402_SMALL_T01" list(13354.380000 2272.350000) t "0.10") | 2@@list("HC7" "MX_C0402_SMALL_T01" list(13283.380000 2272.350000) t "0.10") | 2@@list("HCB4" "TX_C0201" list(7199.810000 2112.630000) t "0.10") | 2@@list("HCB5" "MX_C0402_SMALL_T01" list(10024.380000 4456.350000) t "0.10") | 2@@list("HR10" "MX_R0402_SMALL_T01" list(11208.810000 5032.630000) t "0.10") | 2@@list("HR12" "MX_R0402_SMALL_T01" list(12084.810000 4483.630000) t "0.10") | 2@@list("HR14" "MX_R0402_SMALL_T01" list(12127.380000 4998.350000) t "0.10") | 2@@list("HR15" "MX_R0402_SMALL_T01" list(12125.880000 4933.350000) t "0.10") | 2@@list("HR23" "MX_R0402_SMALL_T01" list(12089.880000 4933.350000) t "0.10") | 2@@list("HR29" "MX_R0402_SMALL_T01" list(12024.970000 5079.410000) t "0.10") | 2@@list("HR33" "MX_R0402_SMALL_T01" list(12081.380000 5002.350000) t "0.10") | 2@@list("HR346" "MX_R0402_SMALL_T01" list(9975.380000 5190.350000) t "0.10") | 2@@list("HR347" "MX_R0402_SMALL_T01" list(9969.380000 5081.350000) t "0.10") | 2@@list("HR35" "MX_R0402_SMALL_T01" list(11132.810000 5003.420000) t "0.10") | 2@@list("HR36" "MX_R0402_SMALL_T01" list(9969.380000 5045.350000) t "0.10") | 2@@list("HR367" "MX_R0402_SMALL_T01" list(10186.380000 5318.850000) t "0.10") | 2@@list("HR37" "MX_R0402_SMALL_T01" list(9969.380000 5003.350000) t "0.10") | 2@@list("HR372" "MX_R0402_SMALL_T01" list(10122.810000 5221.630000) t "0.10") | 2@@list("HR374" "MX_R0402_SMALL_T01" list(9969.380000 4646.350000) t "0.10") | 2@@list("HR377" "MX_R0402_SMALL_T01" list(10211.810000 5209.630000) t "0.10") | 2@@list("HR378" "MX_R0402_SMALL_T01" list(10211.810000 5173.630000) t "0.10") | 2@@list("HR38" "MX_R0402_SMALL_T01" list(9969.380000 4967.350000) t "0.10") | 2@@list("HR383" "MX_R0402_SMALL_T01" list(10126.810000 5257.630000) t "0.10") | 2@@list("HR385" "MX_R0402_SMALL_T01" list(9975.380000 5228.350000) t "0.10") | 2@@list("HR39" "MX_R0402_SMALL_T01" list(9969.380000 4928.350000) t "0.10") | 2@@list("HR392" "MX_R0402_SMALL_T01" list(9969.380000 4718.350000) t "0.10") | 2@@list("HR40" "MX_R0402_SMALL_T01" list(9969.380000 4873.350000) t "0.10") | 2@@list("HR41" "MX_R0402_SMALL_T01" list(9969.380000 4832.350000) t "0.10") | 2@@list("HR410" "MX_R0402_SMALL_T01" list(8451.380000 4603.230000) t "0.10") | 2@@list("HR42" "MX_R0402_SMALL_T01" list(9969.380000 4795.850000) t "0.10") | 2@@list("HR424" "MX_R0603_SMALL_T01" list(8624.380000 3969.350000) t "0.10") | 2@@list("HR43" "MX_R0402_SMALL_T01" list(9969.380000 4754.350000) t "0.10") | 2@@list("HR64" "MX_R0402_SMALL_T01" list(11199.380000 4545.990000) t "0.10") | 2@@list("HR70" "MX_R0402_SMALL_T01" list(7501.810000 1031.630000) t "0.10") | 2@@list("HR72" "MX_R0603_SMALL_T01" list(8575.880000 4027.350000) t "0.10") | 2@@list("HR74" "MX_R0603_SMALL_T01" list(8571.380000 3859.350000) t "0.10") | 2@@list("HR9" "MX_R0402_SMALL_T01" list(11170.810000 5032.130000) t "0.10") | 2@@list("HR91" "MX_R0402_SMALL_T01" list(10079.810000 5161.630000) t "0.10") | 2@@list("HR93" "MX_R0402_SMALL_T01" list(9969.380000 4682.350000) t "0.10") | 2@@list("HR98" "MX_R0402_SMALL_T01" list(10024.380000 4419.350000) t "0.10") | 2@@list("HT1" "MX_TPC26T_S4_68" list(12585.810000 3651.630000) t "0.10") | 2@@list("HT10" "MX_TPC26T_S4_68" list(11356.380000 4943.350000) t "0.10") | 2@@list("HT11" "MX_TPC26T_S4_68" list(10378.380000 3240.350000) t "0.10") | 2@@list("HT12" "MX_TPC26T_S4_68" list(10378.380000 5807.350000) t "0.10") | 2@@list("HT13" "MX_TPC26T_S4_68" list(10306.380000 5819.350000) t "0.10") | 2@@list("HT14" "MX_TPC26T_S4_68" list(10334.380000 5943.350000) t "0.10") | 2@@list("HT15" "MX_TPC26T_S4_68" list(10461.380000 5777.350000) t "0.10") | 2@@list("HT16" "MX_TPC26T_S4_68" list(11250.380000 5026.350000) t "0.10") | 2@@list("HT17" "MX_TPC26T_S4_68" list(11421.380000 5048.350000) t "0.10") | 2@@list("HT18" "MX_TPC26T_S4_68" list(12687.810000 3637.630000) t "0.10") | 2@@list("HT2" "MX_TPC26T_S4_68" list(10278.380000 5888.350000) t "0.10") | 2@@list("HT20" "MX_TPC26T_S4_68" list(12587.380000 6015.350000) t "0.10") | 2@@list("HT22" "MX_TPC26T_S4_68" list(12996.810000 4500.730000) t "0.10") | 2@@list("HT26" "MX_TPC26T_S4_68" list(10550.380000 5762.350000) t "0.10") | 2@@list("HT27" "MX_TPC26T_S4_68" list(11352.460000 5014.210000) t "0.10") | 2@@list("HT28" "MX_TPC26T_S4_68" list(11493.460000 5063.210000) t "0.10") | 2@@list("HT29" "MX_TPC26T_S4_68" list(10330.380000 5754.350000) t "0.10") | 2@@list("HT3" "MX_TPC26T_S4_68" list(13049.380000 4453.350000) t "0.10") | 2@@list("HT30" "MX_TPC26T_S4_68" list(11414.320000 4979.110000) t "0.10") | 2@@list("HT31" "MX_TPC26T_S4_68" list(11340.380000 5081.350000) t "0.10") | 2@@list("HT32" "MX_TPC26T_S4_68" list(10347.380000 5875.350000) t "0.10") | 2@@list("HT33" "MX_TPC26T_S4_68" list(12634.320000 5965.110000) t "0.10") | 2@@list("HT34" "MX_TPC26T_S4_68" list(11190.380000 4582.350000) t "0.10") | 2@@list("HT37" "MX_TPC26T_S4_68" list(11754.320000 4469.110000) t "0.10") | 2@@list("HT38" "MX_TPC26T_S4_68" list(12983.380000 4425.350000) t "0.10") | 2@@list("HT39" "MX_TPC26T_S4_68" list(11128.380000 4612.350000) t "0.10") | 2@@list("HT4" "MX_TPC26T_S4_68" list(10196.380000 5878.350000) t "0.10") | 2@@list("HT40" "MX_TPC26T_S4_68" list(10421.380000 5864.350000) t "0.10") | 2@@list("HT41" "MX_TPC26T_S4_68" list(13354.320000 6543.290000) t "0.10") | 2@@list("HT42" "MX_TPC26T_S4_68" list(13257.320000 6600.290000) t "0.10") | 2@@list("HT43" "MX_TPC26T_S4_68" list(13282.320000 6535.290000) t "0.10") | 2@@list("HT44" "MX_TPC26T_S4_68" list(13331.380000 6608.350000) t "0.10") | 2@@list("HT46" "MX_TPC26T_S4_68" list(9576.320000 2066.290000) t "0.10") | 2@@list("HT47" "MX_TPC26T_S4_68" list(9649.320000 2789.290000) t "0.10") | 2@@list("HT48" "MX_TPC26T_S4_68" list(9380.320000 3083.290000) t "0.10") | 2@@list("HT49" "MX_TPC26T_S4_68" list(9322.320000 3120.290000) t "0.10") | 2@@list("HT5" "MX_TPC26T_S4_68" list(10618.380000 5753.350000) t "0.10") | 2@@list("HT50" "MX_TPC26T_S4_68" list(9640.320000 2028.290000) t "0.10") | 2@@list("HT56" "MX_TPC26T_S4_68" list(9078.320000 5823.290000) t "0.10") | 2@@list("HT57" "MX_TPC26T_S4_68" list(8922.320000 5823.290000) t "0.10") | 2@@list("HT58" "MX_TPC26T_S4_68" list(8779.320000 5762.290000) t "0.10") | 2@@list("HT59" "MX_TPC26T_S4_68" list(8651.800000 5862.580000) t "0.10") | 2@@list("HT6" "MX_TPC26T_S4_68" list(10386.380000 5708.350000) t "0.10") | 2@@list("HT60" "MX_TPC26T_S4_68" list(9000.320000 5823.290000) t "0.10") | 2@@list("HT61" "MX_TPC26T_S4_68" list(9244.320000 2008.290000) t "0.10") | 2@@list("HT62" "MX_TPC26T_S4_68" list(9146.320000 2008.290000) t "0.10") | 2@@list("HT63" "MX_TPC26T_S4_68" list(9048.320000 2008.290000) t "0.10") | 2@@list("HT64" "MX_TPC26T_S4_68" list(9198.320000 2072.290000) t "0.10") | 2@@list("HT65" "MX_TPC26T_S4_68" list(9080.320000 2072.290000) t "0.10") | 2@@list("HT66" "MX_TPC26T_S4_68" list(11043.380000 5805.290000) t "0.10") | 2@@list("HT67" "MX_TPC26T_S4_68" list(11348.320000 5805.290000) t "0.10") | 2@@list("HT68" "MX_TPC26T_S4_68" list(11425.320000 5805.290000) t "0.10") | 2@@list("HT69" "MX_TPC26T_S4_68" list(11406.320000 5881.290000) t "0.10") | 2@@list("HT7" "MX_TPC26T_S4_68" list(10260.810000 5580.630000) t "0.10") | 2@@list("HT70" "MX_TPC26T_S4_68" list(11297.320000 5881.290000) t "0.10") | 2@@list("HT71" "MX_TPC26T_S4_68" list(11207.320000 5883.290000) t "0.10") | 2@@list("HT72" "MX_TPC26T_S4_68" list(11113.320000 5881.290000) t "0.10") | 2@@list("HT73" "MX_TPC26T_S4_68" list(11015.320000 5881.290000) t "0.10") | 2@@list("HT74" "MX_TPC26T_S4_68" list(11141.320000 5805.290000) t "0.10") | 2@@list("HT75" "MX_TPC26T_S4_68" list(11248.320000 5805.290000) t "0.10") | 2@@list("HT76" "MX_TPC26T_S4_68" list(10074.380000 1761.350000) t "0.10") | 2@@list("HT77" "MX_TPC26T_S4_68" list(11716.380000 4693.350000) t "0.10") | 2@@list("HT78" "MX_TPC26T_S4_68" list(13177.380000 4397.350000) t "0.10") | 2@@list("HT8" "MX_TPC26T_S4_68" list(10417.380000 5934.350000) t "0.10") | 2@@list("HT82" "MX_TPC26T_S4_68" list(11307.380000 4637.350000) t "0.10") | 2@@list("HT9" "MX_TPC26T_S4_68" list(10398.380000 3312.350000) t "0.10") | 2@@list("L82" "MX_L0603_SMALL_T02" list(8683.360000 5651.350000) t "0.10") | 2@@list("L93006" "MX_L0603_SMALL_T02" list(11164.810000 1998.630000) t "0.10") | 2@@list("LC3" "MX_C0402_SMALL_T01" list(6894.380000 6219.350000) t "0.10") | 2@@list("LC4" "MX_C1206_H75" list(6906.380000 6834.350000) t "0.10") | 2@@list("LC6" "MX_C0402_SMALL_T01" list(7349.380000 6104.350000) t "0.10") | 2@@list("LC9" "TX_C0201_T009_H14" list(6895.380000 6256.350000) t "0.10") | 2@@list("LR9" "MX_R0402_SMALL_T01" list(7313.380000 6104.350000) t "0.10") | 2@@list("LT11" "MX_TPC26T_S4_68" list(8113.380000 4049.350000) t "0.10") | 2@@list("LT12" "MX_TPC26T_S4_68" list(8452.380000 3998.350000) t "0.10") | 2@@list("LT9" "MX_TPC26T_S4_68" list(8250.380000 4168.850000) t "0.10") | 2@@list("M1C101" "MX_C0402_SMALL_T01" list(10871.380000 7028.350000) t "0.10") | 2@@list("M1C111" "MX_C0402_SMALL_T01" list(10870.380000 6978.350000) t "0.10") | 2@@list("M1C43" "MX_C0402_SMALL_T01" list(11603.950000 1779.070000) t "0.10") | 2@@list("M1C44" "MX_C0402_SMALL_T01" list(11826.810000 1940.630000) t "0.10") | 2@@list("M1C66" "MX_C0402_SMALL_T01" list(7273.810000 2607.630000) t "0.10") | 2@@list("M1C67" "MX_C0402_SMALL_T01" list(7157.810000 2608.630000) t "0.10") | 2@@list("M1C69" "MX_C0402_SMALL_T01" list(8780.380000 2581.350000) t "0.10") | 2@@list("M1C70" "MX_C0402_SMALL_T01" list(8780.380000 2545.350000) t "0.10") | 2@@list("M1C79" "MX_C0402_SMALL_T01" list(9358.380000 6261.850000) t "0.10") | 2@@list("M1C80" "MX_C0402_SMALL_T01" list(9207.380000 6298.350000) t "0.10") | 2@@list("M1C88" "MX_C0402_SMALL_T01" list(9681.380000 6298.350000) t "0.10") | 2@@list("M1C89" "MX_C0402_SMALL_T01" list(10050.880000 6307.350000) t "0.10") | 2@@list("M1C96" "MX_C0402_SMALL_T01" list(10598.950000 1258.070000) t "0.10") | 2@@list("M1C97" "MX_C0402_SMALL_T01" list(10655.810000 1424.630000) t "0.10") | 2@@list("M1C99" "MX_C0402_SMALL_T01" list(10718.380000 784.350000) t "0.10") | 2@@list("M1R10" "MX_R0402_SMALL_T01" list(8618.380000 4268.230000) t "0.10") | 2@@list("M1R15" "MX_R0402_SMALL_T01" list(8342.380000 3976.350000) t "0.10") | 2@@list("M1R16" "MX_R0402_SMALL_T01" list(8198.380000 4776.350000) t "0.10") | 2@@list("MC5401" "MX_C0402_SMALL_T01" list(7355.380000 892.350000) t "0.10") | 2@@list("MC8301" "MX_C0402_SMALL_T01" list(7580.380000 1139.350000) t "0.10") | 2@@list("MC8302" "MX_C0402_SMALL_T01" list(7461.810000 1101.630000) t "0.10") | 2@@list("MC8305" "MX_C0402_SMALL_T01" list(8164.380000 1063.850000) t "0.10") | 2@@list("MQ27" "TX_SOT23_2D4_T01_H43" list(10129.380000 5983.350000) t "0.10") | 2@@list("MQ28" "TX_SOT23_2D4_T01_H43" list(9794.380000 6026.350000) t "0.10") | 2@@list("O2C1" "MX_C0402_SMALL_T01" list(7499.880000 3900.350000) t "0.10") | 2@@list("O2C7" "MX_C0402_SMALL_T01" list(7563.380000 3906.350000) t "0.10") | 2@@list("O2CB1" "MX_C0402_SMALL_T01" list(7839.380000 4222.350000) t "0.10") | 2@@list("O2CB10" "MX_C0402_SMALL_T01" list(7835.380000 4105.350000) t "0.10") | 2@@list("O2CB11" "MX_C0402_SMALL_T01" list(7836.880000 4150.350000) t "0.10") | 2@@list("O2CB15" "MX_C0402_SMALL_T01" list(7647.880000 3881.850000) t "0.10") | 2@@list("O2CB16" "MX_C0402_SMALL_T01" list(7018.810000 4228.630000) t "0.10") | 2@@list("O2CB17" "MX_C0402_SMALL_T01" list(7227.410000 4695.250000) t "0.10") | 2@@list("O2CB2" "MX_C0402_SMALL_T01" list(7289.810000 3907.920000) t "0.10") | 2@@list("O2CB20" "MX_C0402_SMALL_T01" list(7868.380000 3943.350000) t "0.10") | 2@@list("O2CB21" "MX_C0402_SMALL_T01" list(7857.380000 4758.350000) t "0.10") | 2@@list("O2CB3" "MX_C0402_SMALL_T01" list(7204.810000 3915.350000) t "0.10") | 2@@list("O2CB4" "MX_C0402_SMALL_T01" list(7009.810000 4043.920000) t "0.10") | 2@@list("O2CB5" "MX_C0402_SMALL_T01" list(7526.310000 4730.630000) t "0.10") | 2@@list("O2CB6" "MX_C0402_SMALL_T01" list(7436.380000 3902.350000) t "0.10") | 2@@list("O2CB8" "MX_C0402_SMALL_T01" list(7838.380000 4485.350000) t "0.10") | 2@@list("O2Q2" "MX_SOT363_PHILIPS" list(7174.810000 4923.630000) t "0.10") | 2@@list("O2Q3" "MX_SOT363_PHILIPS" list(7343.530000 4913.630000) t "0.10") | 2@@list("O2Q4" "MX_SOT363_PHILIPS" list(8283.810000 4691.430000) t "0.10") | 2@@list("O2Q5" "MX_SOT363_PHILIPS" list(8533.380000 5667.350000) t "0.10") | 2@@list("O2R1" "MX_R0402_SMALL_T01" list(7959.380000 4043.350000) t "0.10") | 2@@list("O2R10" "MX_R0402_SMALL_T01" list(7641.380000 3107.850000) t "0.10") | 2@@list("O2R12" "MX_R0402_SMALL_T01" list(7196.810000 4853.630000) t "0.10") | 2@@list("O2R13" "MX_R0402_SMALL_T01" list(7344.810000 5026.630000) t "0.10") | 2@@list("O2R14" "MX_R0402_SMALL_T01" list(7321.660000 5082.780000) t "0.10") | 2@@list("O2R15" "MX_R0402_SMALL_T01" list(7354.310000 4987.630000) t "0.10") | 2@@list("O2R25" "MX_R0402_SMALL_T01" list(7641.380000 3144.350000) t "0.10") | 2@@list("OR120" "MX_R0402_SMALL_T01" list(7023.660000 4444.630000) t "0.10") | 2@@list("OR122" "MX_R0402_SMALL_T01" list(7023.340000 4516.630000) t "0.10") | 2@@list("OR123" "MX_R0402_SMALL_T01" list(7010.340000 4552.630000) t "0.10") | 2@@list("OR124" "MX_R0402_SMALL_T01" list(7101.380000 3915.350000) t "0.10") | 2@@list("OR125" "MX_R0402_SMALL_T01" list(7037.810000 3915.350000) t "0.10") | 2@@list("OR132" "MX_R0402_SMALL_T01" list(7248.100000 4771.780000) t "0.10") | 2@@list("OR133" "MX_R0402_SMALL_T01" list(7285.100000 4771.780000) t "0.10") | 2@@list("OR134" "MX_R0402_SMALL_T01" list(7362.160000 4791.920000) t "0.10") | 2@@list("OR135" "MX_R0402_SMALL_T01" list(7352.310000 4690.130000) t "0.10") | 2@@list("OR136" "MX_R0402_SMALL_T01" list(7399.810000 4792.130000) t "0.10") | 2@@list("OR137" "MX_R0402_SMALL_T01" list(7388.810000 4711.130000) t "0.10") | 2@@list("OR142" "MX_R0402_SMALL_T01" list(7009.810000 4117.630000) t "0.10") | 2@@list("OR152" "MX_R0402_SMALL_T01" list(8232.380000 4621.350000) t "0.10") | 2@@list("OR154" "MX_R0402_SMALL_T01" list(7646.380000 3271.350000) t "0.10") | 2@@list("OR22" "MX_R0402_SMALL_T01" list(7514.810000 4795.130000) t "0.10") | 2@@list("OR29" "MX_R0402_SMALL_T01" list(7692.100000 4797.780000) t "0.10") | 2@@list("OR3" "MX_R0402_SMALL_T01" list(7812.380000 4010.350000) t "0.10") | 2@@list("OR34" "MX_R0402_SMALL_T01" list(7649.380000 4797.350000) t "0.10") | 2@@list("OR37" "MX_R0402_SMALL_T01" list(7325.160000 4791.920000) t "0.10") | 2@@list("OR68" "MX_R0402_SMALL_T01" list(7461.310000 4816.830000) t "0.10") | 2@@list("OR69" "MX_R0402_SMALL_T01" list(7461.310000 4780.830000) t "0.10") | 2@@list("OR70" "MX_R0402_SMALL_T01" list(7461.310000 4744.830000) t "0.10") | 2@@list("OR71" "MX_R0402_SMALL_T01" list(7461.310000 4708.830000) t "0.10") | 2@@list("OR73" "MX_R0402_SMALL_T01" list(7105.810000 4667.180000) t "0.10") | 2@@list("OR74" "MX_R0402_SMALL_T01" list(7105.810000 4704.280000) t "0.10") | 2@@list("OR75" "MX_R0402_SMALL_T01" list(7105.810000 4740.180000) t "0.10") | 2@@list("OR76" "MX_R0402_SMALL_T01" list(7051.340000 4935.630000) t "0.10") | 2@@list("OR77" "MX_R0402_SMALL_T01" list(7196.810000 4817.630000) t "0.10") | 2@@list("OR78" "MX_R0402_SMALL_T01" list(7198.810000 4781.630000) t "0.10") | 2@@list("OR79" "MX_R0402_SMALL_T01" list(7196.810000 4745.130000) t "0.10") | 2@@list("PC102" "MX_C0402_SMALL_T01" list(9722.810000 3111.630000) t "0.10") | 2@@list("PC106" "MX_C0402_SMALL_T01" list(9670.380000 4363.350000) t "0.10") | 2@@list("PC107" "MX_C0603_SMALL_T02" list(9557.380000 4248.350000) t "0.10") | 2@@list("PC108" "MX_C0603_SMALL_T01" list(9485.380000 4382.350000) t "0.10") | 2@@list("PC109" "MX_C0402_SMALL_T01" list(10824.380000 1993.350000) t "0.10") | 2@@list("PC110" "TX_C0201_T009_H14" list(10786.380000 1869.350000) t "0.10") | 2@@list("PC111" "MX_C0603_SMALL_T01" list(10779.810000 1933.630000) t "0.10") | 2@@list("PC112" "MX_C0603_SMALL_T01" list(10344.810000 1878.630000) t "0.10") | 2@@list("PC113" "MX_C0603_SMALL_T01" list(10394.810000 1878.630000) t "0.10") | 2@@list("PC114" "MX_C0402_SMALL_T01" list(10399.810000 1958.630000) t "0.10") | 2@@list("PC115" "TX_C0201_T009_H14" list(8155.380000 1351.350000) t "0.10") | 2@@list("PC116" "TX_C0201_T009_H14" list(7917.380000 1327.350000) t "0.10") | 2@@list("PC117" "MX_C0603_SMALL_T01" list(12392.310000 1488.630000) t "0.10") | 2@@list("PC118" "MX_C0603_SMALL_T01" list(12326.810000 1246.630000) t "0.10") | 2@@list("PC119" "MX_C0402_SMALL_T01" list(11913.380000 1136.350000) t "0.10") | 2@@list("PC120" "MX_C0402_SMALL_T01" list(12170.810000 1604.630000) t "0.10") | 2@@list("PC123" "MX_C0402_SMALL_T01" list(12149.380000 818.350000) t "0.10") | 2@@list("PC124" "MX_C0402_SMALL_T01" list(12219.810000 1588.630000) t "0.10") | 2@@list("PC125" "MX_C0402_SMALL_T01" list(12204.380000 898.350000) t "0.10") | 2@@list("PC126" "MX_C0603_SMALL_T01" list(12577.810000 1498.630000) t "0.10") | 2@@list("PC127" "MX_C0402_SMALL_T01" list(12272.380000 1032.350000) t "0.10") | 2@@list("PC128" "TX_C0201_T009_H14" list(12296.810000 1588.630000) t "0.10") | 2@@list("PC130" "MX_C0402_SMALL_T01" list(12083.810000 1586.630000) t "0.10") | 2@@list("PC134" "MX_C0603_SMALL_T01" list(12029.810000 1313.630000) t "0.10") | 2@@list("PC135" "MX_C0603_SMALL_T01" list(12069.810000 1408.630000) t "0.10") | 2@@list("PC22" "MX_C0603_SMALL_T01" list(9147.380000 5819.350000) t "0.10") | 2@@list("PC23" "MX_C0603_SMALL_T01" list(9029.380000 5585.350000) t "0.10") | 2@@list("PC29" "MX_C0402_SMALL_T01" list(7979.480000 4892.050000) t "0.10") | 2@@list("PC32" "MX_C0402_SMALL_T01" list(7909.380000 4876.350000) t "0.10") | 2@@list("PC39" "MX_C0603_SMALL_T02" list(11199.380000 4709.350000) t "0.10") | 2@@list("PC4" "MX_C0805_SMALL_T02" list(13275.380000 6251.350000) t "0.10") | 2@@list("PC40" "MX_C0603_SMALL_T02" list(11199.380000 4761.350000) t "0.10") | 2@@list("PC41" "MX_C0603_SMALL_T02" list(11233.380000 4868.350000) t "0.10") | 2@@list("PC42" "MX_C0603_SMALL_T02" list(11199.380000 4656.850000) t "0.10") | 2@@list("PC43" "MX_C0603_SMALL_T02" list(11232.380000 4813.350000) t "0.10") | 2@@list("PC45" "MX_C0805_SMALL_T02" list(11775.380000 1100.350000) t "0.10") | 2@@list("PC46" "MX_C0805_SMALL_T02" list(11775.380000 1026.350000) t "0.10") | 2@@list("PC48" "MX_C0805_SMALL_T02" list(11809.380000 953.350000) t "0.10") | 2@@list("PC50" "MX_C0603_SMALL_T01" list(11226.810000 1579.630000) t "0.10") | 2@@list("PC51" "MX_C0603_SMALL_T01" list(11004.810000 1263.630000) t "0.10") | 2@@list("PC53" "MX_C0603_SMALL_T01" list(11198.810000 1480.630000) t "0.10") | 2@@list("PC54" "MX_C0603_SMALL_T01" list(10884.810000 1488.630000) t "0.10") | 2@@list("PC59" "MX_C0402_SMALL_T01" list(11806.380000 702.850000) t "0.10") | 2@@list("PC60" "MX_C0402_SMALL_T01" list(11204.810000 1398.630000) t "0.10") | 2@@list("PC61" "MX_C0402_SMALL_T01" list(10909.810000 1410.130000) t "0.10") | 2@@list("PC62" "MX_C0402_SMALL_T01" list(10814.810000 1390.630000) t "0.10") | 2@@list("PC63" "MX_C0805_SMALL_T02" list(10078.380000 1433.350000) t "0.10") | 2@@list("PC6301" "MX_C0402_SMALL_T01" list(8205.380000 6174.350000) t "0.10") | 2@@list("PC6302" "MX_C0603_SMALL_T02_H37" list(8281.380000 5867.350000) t "0.10") | 2@@list("PC6303" "MX_C0805_SMALL_T02" list(8343.380000 5856.350000) t "0.10") | 2@@list("PC6304" "MX_C0402_SMALL_T01" list(8197.380000 5872.350000) t "0.10") | 2@@list("PC6305" "MX_C0805_SMALL_T02" list(8432.380000 5876.350000) t "0.10") | 2@@list("PC6306" "MX_C0402_SMALL_T01" list(8456.380000 6023.350000) t "0.10") | 2@@list("PC6307" "MX_C0402_SMALL_T01" list(8015.380000 5833.350000) t "0.10") | 2@@list("PC6308" "MX_C0402_SMALL_T01" list(8234.380000 5872.350000) t "0.10") | 2@@list("PC64" "MX_C0805_SMALL_T02" list(10150.380000 1433.350000) t "0.10") | 2@@list("PC65" "MX_C0603_SMALL_T01" list(11059.810000 1642.630000) t "0.10") | 2@@list("PC66" "MX_C0402_SMALL_T01" list(10176.450000 1607.630000) t "0.10") | 2@@list("PC67" "MX_C0402_SMALL_T01" list(10847.310000 1298.630000) t "0.10") | 2@@list("PC68" "MX_C0402_SMALL_T01" list(10175.660000 1706.780000) t "0.10") | 2@@list("PC72" "MX_C0402_SMALL_T01" list(10105.380000 1890.350000) t "0.10") | 2@@list("PC73" "MX_C0402_SMALL_T01" list(10964.810000 1643.630000) t "0.10") | 2@@list("PC74" "MX_C0402_SMALL_T01" list(10911.310000 1568.630000) t "0.10") | 2@@list("PC75" "MX_C0402_SMALL_T01" list(10824.810000 1588.630000) t "0.10") | 2@@list("PC76" "TX_C0201_T009_H14" list(9480.380000 2032.350000) t "0.10") | 2@@list("PC760" "MX_C0402_SMALL_T01" list(8144.380000 4309.350000) t "0.10") | 2@@list("PC7601" "MX_C0603_SMALL_T01" list(9269.880000 2760.350000) t "0.10") | 2@@list("PC7602" "MX_C0603_SMALL_T01" list(9269.880000 2712.850000) t "0.10") | 2@@list("PC7603" "MX_C0402_SMALL_T01" list(9344.880000 2716.350000) t "0.10") | 2@@list("PC7604" "MX_C0603_SMALL_T01" list(9263.380000 2352.350000) t "0.10") | 2@@list("PC7605" "MX_C0603_SMALL_T01" list(9176.380000 2418.350000) t "0.10") | 2@@list("PC7606" "MX_C0402_SMALL_T01" list(9460.380000 2424.350000) t "0.10") | 2@@list("PC7607" "MX_C0402_SMALL_T01" list(7948.380000 1267.350000) t "0.10") | 2@@list("PC761" "MX_C0402_SMALL_T01" list(8169.380000 4452.350000) t "0.10") | 2@@list("PC762" "MX_C0402_SMALL_T01" list(7939.380000 4528.350000) t "0.10") | 2@@list("PC78" "MX_C0402_SMALL_T01" list(9539.380000 2034.350000) t "0.10") | 2@@list("PC7801" "TX_C0201_T009_H14" list(8155.380000 1303.350000) t "0.10") | 2@@list("PC7802" "TX_C0201_T009_H14" list(7946.380000 1327.350000) t "0.10") | 2@@list("PC79" "MX_C0603_SMALL_T01" list(9438.380000 2219.550000) t "0.10") | 2@@list("PC804" "MX_C0805_SMALL_T02" list(9580.380000 3995.350000) t "0.10") | 2@@list("PC81" "MX_C0402_SMALL_T01" list(9515.380000 2213.350000) t "0.10") | 2@@list("PC8498" "MX_C0402_SMALL_T01" list(8564.380000 2047.350000) t "0.10") | 2@@list("PC8499" "MX_C0402_SMALL_T01" list(8507.380000 1998.350000) t "0.10") | 2@@list("PC89003" "MX_C0402_SMALL_T01" list(10114.380000 6778.350000) t "0.10") | 2@@list("PC89004" "MX_C0402_SMALL_T01" list(10445.380000 6980.350000) t "0.10") | 2@@list("PC89005" "MX_C0402_SMALL_T01" list(10294.380000 6508.350000) t "0.10") | 2@@list("PC89007" "MX_C0402_SMALL_T01" list(10193.380000 6958.350000) t "0.10") | 2@@list("PC89009" "MX_C0402_SMALL_T01" list(10358.380000 6970.350000) t "0.10") | 2@@list("PC89010" "MX_C0402_SMALL_T01" list(10224.380000 6593.350000) t "0.10") | 2@@list("PC89011" "MX_C0402_SMALL_T01" list(10129.380000 6573.350000) t "0.10") | 2@@list("PC89012" "MX_C0402_SMALL_T01" list(10120.380000 6898.350000) t "0.10") | 2@@list("PC89013" "MX_C0402_SMALL_T01" list(10164.380000 6798.350000) t "0.10") | 2@@list("PC89015" "MX_C0402_SMALL_T01" list(10191.380000 6658.350000) t "0.10") | 2@@list("PC89022" "MX_C0402_SMALL_T01" list(10191.380000 6728.350000) t "0.10") | 2@@list("PC89024" "MX_C0402_SMALL_T01" list(10734.380000 6763.350000) t "0.10") | 2@@list("PC89025" "MX_C0402_SMALL_T01" list(10596.380000 6800.350000) t "0.10") | 2@@list("PC89026" "MX_C0402_SMALL_T01" list(10568.380000 6624.350000) t "0.10") | 2@@list("PC89027" "MX_C0402_SMALL_T01" list(10677.380000 6883.350000) t "0.10") | 2@@list("PC89028" "MX_C0402_SMALL_T01" list(10606.990000 6858.350000) t "0.10") | 2@@list("PC89029" "MX_C0402_SMALL_T01" list(10671.380000 6703.350000) t "0.10") | 2@@list("PC89030" "MX_C0402_SMALL_T01" list(10614.380000 6688.350000) t "0.10") | 2@@list("PC89031" "MX_C0402_SMALL_T01" list(10613.380000 6900.350000) t "0.10") | 2@@list("PC89036" "MX_C0402_SMALL_T01" list(10214.380000 6508.350000) t "0.10") | 2@@list("PC89037" "MX_C0402_SMALL_T01" list(10535.380000 6978.350000) t "0.10") | 2@@list("PC90001" "TX_C0805_T02_H57" list(11591.380000 6299.350000) t "0.10") | 2@@list("PC90002" "MX_C0805_SMALL_T02_H55" list(11729.380000 6273.350000) t "0.10") | 2@@list("PC90003" "MX_C0805_SMALL_T02" list(11940.380000 6303.350000) t "0.10") | 2@@list("PC90005" "MX_C0603_SMALL_T01" list(11483.380000 6120.350000) t "0.10") | 2@@list("PC90007" "TX_C0603_T015_H37" list(11375.380000 6273.350000) t "0.10") | 2@@list("PC90009" "MX_C0402_SMALL_T01" list(11889.380000 6173.350000) t "0.10") | 2@@list("PC9001" "TX_C0402" list(11791.380000 6316.350000) t "0.10") | 2@@list("PC90016" "MX_C0603_SMALL_T01" list(10880.380000 6183.350000) t "0.10") | 2@@list("PC90019" "TX_C0603_T015_H37" list(10737.880000 6328.350000) t "0.10") | 2@@list("PC90020" "MX_C0402_SMALL_T01" list(10937.380000 6171.350000) t "0.10") | 2@@list("PC93006" "MX_C0402_SMALL_T01" list(12213.380000 6200.350000) t "0.10") | 2@@list("PC93008" "MX_C0402_SMALL_T01" list(12088.380000 6097.350000) t "0.10") | 2@@list("PC93009" "MX_C0402_SMALL_T01" list(11981.380000 6120.350000) t "0.10") | 2@@list("PC93012" "MX_C0805_SMALL_T02" list(13299.380000 4678.350000) t "0.10") | 2@@list("PC93013" "MX_C0805_SMALL_T02" list(13299.380000 4608.350000) t "0.10") | 2@@list("PC93016" "MX_C0603_SMALL_T01" list(12985.380000 5041.350000) t "0.10") | 2@@list("PC93018" "TX_C0603_T015_H37" list(13042.880000 5265.350000) t "0.10") | 2@@list("PC941483" "MX_C0402_SMALL_T01" list(12054.810000 1713.630000) t "0.10") | 2@@list("PC941484" "MX_C0603_SMALL_T01" list(12184.380000 1271.350000) t "0.10") | 2@@list("PC941485" "TX_C0201_T009_H14" list(12077.380000 1313.350000) t "0.10") | 2@@list("PC941488" "MX_C0402_SMALL_T01" list(12070.810000 1525.630000) t "0.10") | 2@@list("PC941491" "MX_C0603_SMALL_T02" list(11320.810000 4823.630000) t "0.10") | 2@@list("PC941492" "MX_C0603_SMALL_T02" list(11319.810000 4743.630000) t "0.10") | 2@@list("PC941493" "MX_C0603_SMALL_T02" list(11379.810000 4648.630000) t "0.10") | 2@@list("PC941494" "MX_C0603_SMALL_T02" list(11442.810000 4648.630000) t "0.10") | 2@@list("PC941502" "MX_C0402_SMALL_T01" list(8099.380000 6055.350000) t "0.10") | 2@@list("PC941579" "MX_C0402_SMALL_T01" list(9568.380000 2143.350000) t "0.10") | 2@@list("PC941580" "MX_C0402_SMALL_T01" list(9568.380000 2106.350000) t "0.10") | 2@@list("PC941582" "MX_C0402_SMALL_T01" list(9352.880000 2117.350000) t "0.10") | 2@@list("PC941584" "MX_C0402_SMALL_T01" list(13229.380000 2253.350000) t "0.10") | 2@@list("PC941585" "MX_C0402_SMALL_T01" list(13405.380000 2251.350000) t "0.10") | 2@@list("PC941591" "MX_C0402_SMALL_T01" list(10597.380000 6472.350000) t "0.10") | 2@@list("PC941602" "TX_C0201_T009_H14" list(8456.380000 1945.350000) t "0.10") | 2@@list("PC941603" "MX_C0402_SMALL_T01" list(8399.380000 2128.350000) t "0.10") | 2@@list("PC941604" "MX_C0402_SMALL_T01" list(8289.380000 1935.350000) t "0.10") | 2@@list("PC941605" "MX_C0402_SMALL_T01" list(8577.860000 1996.220000) t "0.10") | 2@@list("PC941608" "MX_C0402_SMALL_T01" list(8371.380000 1934.350000) t "0.10") | 2@@list("PC941609" "MX_C0402_SMALL_T01" list(8289.380000 1971.350000) t "0.10") | 2@@list("PC941610" "MX_C0603_SMALL_T01" list(8503.390000 2132.550000) t "0.10") | 2@@list("PC941611" "MX_C0603_SMALL_T01" list(10677.380000 663.350000) t "0.10") | 2@@list("PC941612" "MX_C0402_SMALL_T01" list(10549.380000 866.350000) t "0.10") | 2@@list("PC941614" "MX_C0402_SMALL_T01" list(10718.380000 747.350000) t "0.10") | 2@@list("PC941617" "MX_C0402_SMALL_T01" list(10508.380000 650.350000) t "0.10") | 2@@list("PC941618" "MX_C0603_SMALL_T01" list(10612.380000 857.860000) t "0.10") | 2@@list("PC941619" "MX_C0402_SMALL_T01" list(10489.380000 768.350000) t "0.10") | 2@@list("PC941622" "MX_C0805_SMALL_T02" list(11869.380000 6323.350000) t "0.10") | 2@@list("PC941623" "MX_C0402_SMALL_T01" list(10349.380000 6183.350000) t "0.10") | 2@@list("PC941663" "MX_C0603_SMALL_T02" list(11685.600000 4829.350000) t "0.10") | 2@@list("PC941664" "MX_C0603_SMALL_T02" list(11685.600000 4889.350000) t "0.10") | 2@@list("PC941665" "MX_C0603_SMALL_T02" list(11685.600000 4948.350000) t "0.10") | 2@@list("PC941667" "TX_C0201_T009_H14" list(9480.380000 2004.350000) t "0.10") | 2@@list("PC941669" "TX_C0201_T009_H14" list(10786.380000 1840.350000) t "0.10") | 2@@list("PC941670" "TX_C0201_T009_H14" list(12108.380000 1313.350000) t "0.10") | 2@@list("PC941671" "TX_C0201_T009_H14" list(8537.580000 1948.350000) t "0.10") | 2@@list("PC97013" "MX_C0603_SMALL_T02" list(11335.810000 4894.130000) t "0.10") | 2@@list("PC97034" "MX_C0603_SMALL_T02" list(12114.810000 4743.630000) t "0.10") | 2@@list("PC97035" "MX_C0603_SMALL_T02" list(12959.380000 4928.350000) t "0.10") | 2@@list("PC97037" "MX_C0603_SMALL_T02" list(12016.380000 4628.350000) t "0.10") | 2@@list("PC97038" "MX_C0603_SMALL_T02" list(12979.380000 4578.350000) t "0.10") | 2@@list("PC97039" "MX_C0603_SMALL_T02" list(12144.810000 4628.630000) t "0.10") | 2@@list("PC97040" "MX_C0603_SMALL_T02" list(12089.810000 4628.630000) t "0.10") | 2@@list("PCE97032" "MX_C7343D_H83" list(11951.380000 4870.850000) t "0.10") | 2@@list("PD4" "MX_SOT323" list(9092.130000 5726.100000) t "0.10") | 2@@list("PD8" "MX_SOT323" list(8054.130000 6144.600000) t "0.10") | 2@@list("PL7" "MX_L0603_SMALL_T02" list(11903.380000 1078.350000) t "0.10") | 2@@list("PL8" "MX_L0603_SMALL_T02" list(11903.380000 1026.350000) t "0.10") | 2@@list("PQ22" "MX_SOT323_S5" list(9456.380000 4167.350000) t "0.10") | 2@@list("PQ24" "TX_SOT23_2D4_T01_H43" list(12290.380000 1800.350000) t "0.10") | 2@@list("PQ25" "TX_SOT23_2D4_T01_H43" list(12150.380000 1800.350000) t "0.10") | 2@@list("PQ6301" "TX_SOT23_2D4_T01_H43" list(7874.380000 6117.350000) t "0.10") | 2@@list("PQ8" "MX_DFN_8P_26_122X122_2PAD" list(10091.380000 1622.350000) t "0.10") | 2@@list("PQ93010" "TX_SOT23_2D4_T01_H43" list(7925.380000 5956.350000) t "0.10") | 2@@list("PQ93030" "TX_SOT23_2D4_T01_H43" list(7870.180000 4673.350000) t "0.10") | 2@@list("PQ93031" "TX_SOT23_2D4_T01_H43" list(8018.970000 4672.350000) t "0.10") | 2@@list("PQ9823" "TX_SOT23_2D4_T01_H43" list(7221.380000 5324.350000) t "0.10") | 2@@list("PR101" "MX_R1206" list(9595.810000 3130.630000) t "0.10") | 2@@list("PR1017" "MX_R0402_SMALL_T01" list(9729.850000 2871.600000) t "0.10") | 2@@list("PR111" "MX_R0402_SMALL_T01" list(9454.910000 4304.830000) t "0.10") | 2@@list("PR113" "MX_R0402_SMALL_T01" list(9492.910000 4304.830000) t "0.10") | 2@@list("PR115" "MX_R0402_SMALL_T01" list(9489.380000 4017.350000) t "0.10") | 2@@list("PR116" "MX_R0402_SMALL_T01" list(10767.810000 2043.630000) t "0.10") | 2@@list("PR117" "MX_R0603_SMALL_T01" list(10799.810000 1785.630000) t "0.10") | 2@@list("PR119" "MX_R0402_SMALL_T01" list(10363.810000 1958.630000) t "0.10") | 2@@list("PR120" "MX_R0402_SMALL_T01" list(10384.810000 2013.630000) t "0.10") | 2@@list("PR121" "MX_R0402_SMALL_T01" list(7911.380000 1267.350000) t "0.10") | 2@@list("PR123" "MX_R0402_SMALL_T01" list(9526.380000 4017.350000) t "0.10") | 2@@list("PR124" "MX_R0603_SMALL_T01" list(12412.430000 1537.630000) t "0.10") | 2@@list("PR125" "MX_R0805_SMALL_T02" list(12259.810000 1243.630000) t "0.10") | 2@@list("PR126" "MX_R0402_SMALL_T01" list(12259.810000 1588.630000) t "0.10") | 2@@list("PR127" "MX_R0805_SMALL_T02" list(12038.380000 867.350000) t "0.10") | 2@@list("PR128" "MX_R0402_SMALL_T01" list(12209.810000 1690.630000) t "0.10") | 2@@list("PR129" "MX_R0402_SMALL_T01" list(12159.810000 1690.630000) t "0.10") | 2@@list("PR130" "MX_R0402_SMALL_T01" list(12149.380000 855.350000) t "0.10") | 2@@list("PR131" "MX_R0402_SMALL_T01" list(12259.810000 1678.630000) t "0.10") | 2@@list("PR132" "MX_R0402_SMALL_T01" list(12107.810000 1701.630000) t "0.10") | 2@@list("PR133" "MX_R1206" list(12313.380000 919.350000) t "0.10") | 2@@list("PR134" "MX_R0805_SMALL_T02" list(12135.380000 1055.530000) t "0.10") | 2@@list("PR135" "MX_R0402_SMALL_T01" list(12309.810000 1678.630000) t "0.10") | 2@@list("PR139" "MX_R1206_H26" list(12589.810000 1244.630000) t "0.10") | 2@@list("PR141" "MX_R1206_H26" list(12589.810000 1427.630000) t "0.10") | 2@@list("PR2" "MX_R0603_SMALL_T01" list(13264.380000 6386.350000) t "0.10") | 2@@list("PR214" "MX_R0402_SMALL_T01" list(12079.380000 1623.350000) t "0.10") | 2@@list("PR28" "MX_R0805_SMALL_T02" list(8941.380000 5712.350000) t "0.10") | 2@@list("PR3" "MX_R0603_SMALL_T01" list(13314.380000 6386.350000) t "0.10") | 2@@list("PR33" "MX_R1206" list(7957.380000 4956.350000) t "0.10") | 2@@list("PR4" "MX_R0603_SMALL_T01" list(13364.380000 6386.350000) t "0.10") | 2@@list("PR5" "MX_R0603_SMALL_T01" list(13414.380000 6386.350000) t "0.10") | 2@@list("PR51" "MX_R0603_SMALL_T01" list(10814.810000 1468.630000) t "0.10") | 2@@list("PR52" "MX_R0805_SMALL_T02" list(11309.810000 1556.130000) t "0.10") | 2@@list("PR53" "MX_R0805_SMALL_T02" list(11071.810000 1264.130000) t "0.10") | 2@@list("PR56" "MX_R1206" list(11671.380000 791.350000) t "0.10") | 2@@list("PR58" "MX_R0402_SMALL_T01" list(11015.810000 1631.630000) t "0.10") | 2@@list("PR59" "MX_R0603_SMALL_T01" list(11289.810000 1408.630000) t "0.10") | 2@@list("PR60" "MX_R0402_SMALL_T01" list(10924.810000 1353.630000) t "0.10") | 2@@list("PR61" "MX_R0402_SMALL_T01" list(10864.810000 1410.130000) t "0.10") | 2@@list("PR62" "MX_R0402_SMALL_T01" list(10814.810000 1426.630000) t "0.10") | 2@@list("PR63" "MX_R0402_SMALL_T01" list(10959.810000 1568.630000) t "0.10") | 2@@list("PR64" "MX_R0402_SMALL_T01" list(10919.810000 1298.630000) t "0.10") | 2@@list("PR65" "MX_R0805_SMALL_T02" list(11120.810000 1646.630000) t "0.10") | 2@@list("PR66" "MX_R0402_SMALL_T01" list(10810.810000 1298.630000) t "0.10") | 2@@list("PR67" "MX_R0805_SMALL_T02" list(10286.380000 1589.350000) t "0.10") | 2@@list("PR68" "MX_R0402_SMALL_T01" list(10212.950000 1607.630000) t "0.10") | 2@@list("PR71" "MX_R0805_SMALL_T02" list(10287.380000 1677.350000) t "0.10") | 2@@list("PR72" "MX_R1206" list(9966.380000 1815.350000) t "0.10") | 2@@list("PR73" "MX_R0402_SMALL_T01" list(10213.380000 1706.350000) t "0.10") | 2@@list("PR74" "MX_R0402_SMALL_T01" list(10964.810000 1682.630000) t "0.10") | 2@@list("PR7401" "MX_R0805_SMALL_T02" list(9577.380000 4140.350000) t "0.10") | 2@@list("PR75" "MX_R0402_SMALL_T01" list(10874.810000 1568.630000) t "0.10") | 2@@list("PR76" "MX_R0402_SMALL_T01" list(10824.810000 1548.630000) t "0.10") | 2@@list("PR760" "MX_R0402_SMALL_T01" list(7902.380000 4528.350000) t "0.10") | 2@@list("PR7601" "MX_R0402_SMALL_T01" list(9344.880000 2754.350000) t "0.10") | 2@@list("PR7602" "MX_R0402_SMALL_T01" list(9408.380000 2716.350000) t "0.10") | 2@@list("PR7607" "MX_R0402_SMALL_T01" list(9460.380000 2386.350000) t "0.10") | 2@@list("PR7608" "MX_R0603_SMALL_T01" list(9140.380000 2350.350000) t "0.10") | 2@@list("PR7609" "MX_R0402_SMALL_T01" list(9460.380000 2462.350000) t "0.10") | 2@@list("PR761" "MX_R0402_SMALL_T01" list(7954.380000 4460.350000) t "0.10") | 2@@list("PR7701" "MX_R0402_SMALL_T01" list(12325.810000 1537.630000) t "0.10") | 2@@list("PR8402" "MX_R0805_SMALL_T02" list(8662.380000 2117.350000) t "0.10") | 2@@list("PR8405" "MX_R0805_SMALL_T02" list(10584.380000 653.350000) t "0.10") | 2@@list("PR89004" "MX_R0402_SMALL_T01" list(10229.380000 6958.350000) t "0.10") | 2@@list("PR89006" "MX_R0402_SMALL_T01" list(10306.380000 6958.350000) t "0.10") | 2@@list("PR89008" "MX_R0402_SMALL_T01" list(10157.380000 6958.350000) t "0.10") | 2@@list("PR89010" "MX_R0402_SMALL_T01" list(10128.380000 6613.350000) t "0.10") | 2@@list("PR89011" "MX_R0402_SMALL_T01" list(10184.380000 6898.350000) t "0.10") | 2@@list("PR89012" "MX_R0402_SMALL_T01" list(10114.380000 6818.350000) t "0.10") | 2@@list("PR89014" "MX_R0402_SMALL_T01" list(10268.380000 6958.350000) t "0.10") | 2@@list("PR89017" "MX_R0402_SMALL_T01" list(10184.380000 6593.350000) t "0.10") | 2@@list("PR89018" "MX_R0402_SMALL_T01" list(10120.380000 6858.350000) t "0.10") | 2@@list("PR89019" "MX_R0402_SMALL_T01" list(10201.380000 6806.350000) t "0.10") | 2@@list("PR89034" "MX_R0402_SMALL_T01" list(10104.380000 6723.350000) t "0.10") | 2@@list("PR89036" "MX_R0402_SMALL_T01" list(10499.380000 6978.350000) t "0.10") | 2@@list("PR89037" "MX_R0402_SMALL_T01" list(10104.380000 6686.350000) t "0.10") | 2@@list("PR89039" "MX_R0402_SMALL_T01" list(10154.380000 6703.350000) t "0.10") | 2@@list("PR89040" "MX_R0402_SMALL_T01" list(10254.380000 6508.350000) t "0.10") | 2@@list("PR89041" "MX_R0402_SMALL_T01" list(10374.380000 6508.350000) t "0.10") | 2@@list("PR89043" "MX_R0402_SMALL_T01" list(10734.380000 6803.350000) t "0.10") | 2@@list("PR89045" "MX_R0402_SMALL_T01" list(10604.380000 6624.350000) t "0.10") | 2@@list("PR89046" "MX_R0402_SMALL_T01" list(10646.380000 6817.350000) t "0.10") | 2@@list("PR89047" "MX_R0402_SMALL_T01" list(10691.380000 6631.350000) t "0.10") | 2@@list("PR89049" "MX_R0402_SMALL_T01" list(10334.380000 6508.350000) t "0.10") | 2@@list("PR89052" "MX_R0402_SMALL_T01" list(10578.380000 6688.350000) t "0.10") | 2@@list("PR89053" "MX_R0402_SMALL_T01" list(10678.380000 6933.350000) t "0.10") | 2@@list("PR89054" "MX_R0402_SMALL_T01" list(10613.380000 6937.350000) t "0.10") | 2@@list("PR89055" "MX_R0402_SMALL_T01" list(10650.380000 6740.350000) t "0.10") | 2@@list("PR89065" "MX_R0402_SMALL_T01" list(10414.380000 6508.350000) t "0.10") | 2@@list("PR89068" "MX_R0402_SMALL_T01" list(10244.380000 6428.350000) t "0.10") | 2@@list("PR89070" "MX_R0402_SMALL_T01" list(10408.380000 6980.350000) t "0.10") | 2@@list("PR90002" "MX_R0603_SMALL_T01" list(11237.380000 6229.350000) t "0.10") | 2@@list("PR90003" "MX_R0805_SMALL_T02" list(11376.380000 6061.350000) t "0.10") | 2@@list("PR90005" "MX_R0402_SMALL_T01" list(11293.380000 6167.350000) t "0.10") | 2@@list("PR90006" "MX_R1206" list(11774.370000 6143.350000) t "0.10") | 2@@list("PR90009" "MX_R0603_SMALL_T01" list(10814.380000 6318.350000) t "0.10") | 2@@list("PR90010" "MX_R0805_SMALL_T02" list(10769.380000 6138.350000) t "0.10") | 2@@list("PR90013" "MX_R0402_SMALL_T01" list(10700.380000 6244.350000) t "0.10") | 2@@list("PR90014" "MX_R1206" list(11052.390000 6155.350000) t "0.10") | 2@@list("PR93001" "MX_R0805_SMALL_T02" list(12229.380000 6269.350000) t "0.10") | 2@@list("PR93002" "MX_R0603_SMALL_T01" list(13122.100000 5142.920000) t "0.10") | 2@@list("PR93004" "MX_R0402_SMALL_T01" list(12249.380000 6200.350000) t "0.10") | 2@@list("PR93006" "MX_R1206" list(12100.380000 6182.350000) t "0.10") | 2@@list("PR93009" "MX_R0603_SMALL_T01" list(13016.880000 5339.350000) t "0.10") | 2@@list("PR93010" "MX_R0805_SMALL_T02" list(12950.380000 5154.350000) t "0.10") | 2@@list("PR93013" "MX_R0402_SMALL_T01" list(12977.380000 5259.350000) t "0.10") | 2@@list("PR93024" "MX_R0402_SMALL_T01" list(12134.810000 1603.130000) t "0.10") | 2@@list("PR93026" "TX_R0402" list(12384.810000 1433.630000) t "0.10") | 2@@list("PR93028" "MX_R1206_H26" list(12589.810000 1337.630000) t "0.10") | 2@@list("PR93038" "MX_R0402_SMALL_T01" list(8474.380000 5823.350000) t "0.10") | 2@@list("PR93039" "MX_R0402_SMALL_T01" list(8410.380000 5823.350000) t "0.10") | 2@@list("PR93046" "MX_R0402_SMALL_T01" list(7979.380000 5833.350000) t "0.10") | 2@@list("PR93051" "MX_R0402_SMALL_T01" list(7978.380000 5883.350000) t "0.10") | 2@@list("PR93052" "MX_R0402_SMALL_T01" list(7914.380000 5860.350000) t "0.10") | 2@@list("PR93054" "MX_R0402_SMALL_T01" list(8059.380000 6055.350000) t "0.10") | 2@@list("PR93055" "MX_R0402_SMALL_T01" list(8456.380000 6096.350000) t "0.10") | 2@@list("PR93060" "MX_R0402_SMALL_T01" list(8549.380000 5902.350000) t "0.10") | 2@@list("PR93061" "MX_R0402_SMALL_T01" list(8375.380000 6172.350000) t "0.10") | 2@@list("PR93062" "MX_R0402_SMALL_T01" list(8007.380000 6076.350000) t "0.10") | 2@@list("PR93063" "MX_R0402_SMALL_T01" list(7780.380000 6087.350000) t "0.10") | 2@@list("PR93066" "MX_R1206" list(10492.390000 6150.350000) t "0.10") | 2@@list("PR93069" "MX_R0402_SMALL_T01" list(10602.380000 6508.350000) t "0.10") | 2@@list("PR93070" "MX_R0805_SMALL_T02" list(10688.380000 6485.350000) t "0.10") | 2@@list("PR93083" "MX_R0402_SMALL_T01" list(9153.380000 3278.350000) t "0.10") | 2@@list("PR93158" "MX_R0805_SMALL_T02" list(9339.380000 2279.350000) t "0.10") | 2@@list("PR93162" "MX_R0402_SMALL_T01" list(8087.380000 5838.350000) t "0.10") | 2@@list("PR93163" "MX_R0402_SMALL_T01" list(8051.380000 5838.350000) t "0.10") | 2@@list("PR93164" "MX_R0402_SMALL_T01" list(8123.380000 5878.350000) t "0.10") | 2@@list("PR93165" "MX_R0402_SMALL_T01" list(8159.380000 5878.350000) t "0.10") | 2@@list("PR93166" "MX_R0402_SMALL_T01" list(9511.890000 2474.790000) t "0.10") | 2@@list("PR96" "MX_R0402_SMALL_T01" list(9639.380000 2858.350000) t "0.10") | 2@@list("PT156" "MX_TPC26T_S4_68" list(12507.380000 1502.350000) t "0.10") | 2@@list("PT157" "MX_TPC26T_S4_68" list(8038.380000 4847.350000) t "0.10") | 2@@list("PT159" "MX_TPC26T_S4_68" list(13287.810000 6097.630000) t "0.10") | 2@@list("PT163" "MX_TPC26T_S4_68" list(11039.380000 6333.350000) t "0.10") | 2@@list("PT264" "MX_TPC26T_S4_68" list(9722.380000 5309.350000) t "0.10") | 2@@list("PU10" "MX_DFN_14P_16_118X79_P_ANP" list(9463.380000 2123.350000) t "0.10") | 2@@list("PU6" "MX_SOIC_8P_50_201X236PNIK4V" list(10579.810000 1928.630000) t "0.10") | 2@@list("PU7" "MX_SOT23_S5_2D4_H51" list(8050.810000 1289.630000) t "0.10") | 2@@list("PU76" "MX_SOT23_S5_2D4_H51" list(8055.370000 4395.350000) t "0.10") | 2@@list("PU7601" "MX_SOIC_8P_50_201X236PNIK4V" list(9314.380000 2533.350000) t "0.10") | 2@@list("PU8401" "MX_DFN_14P_16_118X79_P_ANP" list(8430.810000 2036.630000) t "0.10") | 2@@list("PU8402" "MX_DFN_14P_16_118X79_P_ANP" list(10591.810000 762.070000) t "0.10") | 2@@list("PU90001" "MX_DFN_8P_20_S79_PAD_ON" list(11401.380000 6195.350000) t "0.10") | 2@@list("PU90002" "MX_DFN_8P_20_S79_PAD_ON" list(10780.380000 6225.850000) t "0.10") | 2@@list("PU93002" "MX_DFN_8P_20_S79_PAD_ON" list(13040.380000 5123.350000) t "0.10") | 2@@list("PU93003" "MX_SO8_H69" list(8279.660000 6031.620000) t "0.10") | 2@@list("Q1" "MX_SOT23" list(7749.380000 2928.350000) t "0.10") | 2@@list("Q4001" "TX_SOT23_2D4_122X55_H44" list(7739.380000 5980.350000) t "0.10") | 2@@list("Q7201" "TX_SOT23_2D4_T01_H43" list(7042.380000 3110.350000) t "0.10") | 2@@list("Q8" "TX_SOT23_2D4_T01_H43" list(11488.380000 1162.350000) t "0.10") | 2@@list("Q93" "TX_SOT23_2D4_T01_H43" list(9077.620000 2185.350000) t "0.10") | 2@@list("Q93035" "TX_SOT23_2D4_122X55_H44" list(11286.810000 1814.630000) t "0.10") | 2@@list("Q93037" "TX_SOT23_2D4_T01_H43" list(11570.480000 1435.340000) t "0.10") | 2@@list("Q93038" "TX_SOT23_2D4_T01_H43" list(11569.840000 1567.200000) t "0.10") | 2@@list("Q9308" "TX_SOT23_2D4_T01_H43" list(13283.460000 1865.920000) t "0.10") | 2@@list("Q9309" "TX_SOT23_2D4_T01_H43" list(13290.460000 1997.920000) t "0.10") | 2@@list("Q9345" "TX_SOT23_2D4_122X55_H44" list(13283.810000 1727.630000) t "0.10") | 2@@list("Q940" "TX_SOT23_2D4_T01_H43" list(8940.380000 2248.350000) t "0.10") | 2@@list("Q941" "TX_SOT23_2D4_T01_H43" list(7922.380000 1686.350000) t "0.10") | 2@@list("Q942" "TX_SOT23_2D4_T01_H43" list(8104.380000 1703.350000) t "0.10") | 2@@list("Q9433" "MX_SOT23_2D4_122X71" list(7048.380000 5353.350000) t "0.10") | 2@@list("Q9436" "TX_SOT23_2D4_T01_H43" list(8015.380000 1553.350000) t "0.10") | 2@@list("Q9437" "TX_SOT23_2D4_T01_H43" list(8062.380000 1423.350000) t "0.10") | 2@@list("Q9537" "TX_SOT23_2D4_T01_H43" list(11568.660000 1695.920000) t "0.10") | 2@@list("Q9540" "TX_SOT23_2D4_T01_H43" list(11766.660000 1564.920000) t "0.10") | 2@@list("Q9541" "TX_SOT23_2D4_T01_H43" list(11574.810000 1297.630000) t "0.10") | 2@@list("Q9542" "TX_SOT23_2D4_T01_H43" list(11766.660000 1435.920000) t "0.10") | 2@@list("Q9543" "TX_SOT23_2D4_T01_H43" list(11706.660000 1906.920000) t "0.10") | 2@@list("Q9544" "TX_SOT23_2D4_T01_H43" list(11935.810000 1850.630000) t "0.10") | 2@@list("R113" "MX_R0402_SMALL_T01" list(7619.810000 1253.630000) t "0.10") | 2@@list("R181" "MX_R0402_SMALL_T01" list(7741.810000 1508.630000) t "0.10") | 2@@list("R203" "MX_R0402_SMALL_T01" list(13354.380000 2235.350000) t "0.10") | 2@@list("R204" "MX_R0402_SMALL_T01" list(13283.380000 2235.350000) t "0.10") | 2@@list("R2102" "MX_R0402_SMALL_T01" list(9220.380000 4596.230000) t "0.10") | 2@@list("R23" "MX_R0805_SMALL_T02" list(7053.380000 6705.350000) t "0.10") | 2@@list("R2341" "MX_R0402_SMALL_T01" list(8193.380000 4218.350000) t "0.10") | 2@@list("R2343" "MX_R0402_SMALL_T01" list(8136.380000 4231.350000) t "0.10") | 2@@list("R2345" "MX_R0402_SMALL_T01" list(8100.380000 4577.350000) t "0.10") | 2@@list("R2346" "MX_R0402_SMALL_T01" list(7656.380000 4903.350000) t "0.10") | 2@@list("R2349" "MX_R0402_SMALL_T01" list(7976.380000 4601.850000) t "0.10") | 2@@list("R2350" "MX_R0402_SMALL_T01" list(8101.880000 4537.350000) t "0.10") | 2@@list("R2353" "MX_R0402_SMALL_T01" list(8525.380000 4407.070000) t "0.10") | 2@@list("R2354" "MX_R0402_SMALL_T01" list(8489.380000 4408.070000) t "0.10") | 2@@list("R2420" "MX_R0402_SMALL_T01" list(8763.380000 4420.350000) t "0.10") | 2@@list("R3108" "MX_R0402_SMALL_T01" list(9109.380000 2418.350000) t "0.10") | 2@@list("R3110" "MX_R0402_SMALL_T01" list(8868.470000 4362.020000) t "0.10") | 2@@list("R3128" "MX_R0402_SMALL_T01" list(8433.380000 4412.350000) t "0.10") | 2@@list("R3132" "MX_R0402_SMALL_T01" list(8483.380000 4041.850000) t "0.10") | 2@@list("R3134" "MX_R0402_SMALL_T01" list(8493.380000 4157.350000) t "0.10") | 2@@list("R3135" "MX_R0402_SMALL_T01" list(8064.830000 4166.350000) t "0.10") | 2@@list("R3136" "MX_R0402_SMALL_T01" list(8887.380000 2377.350000) t "0.10") | 2@@list("R38" "MX_R0402_SMALL_T01" list(9197.380000 3144.350000) t "0.10") | 2@@list("R39" "MX_R0402_SMALL_T01" list(8483.880000 4475.850000) t "0.10") | 2@@list("R4001" "MX_R0402_SMALL_T01" list(7576.380000 6014.350000) t "0.10") | 2@@list("R4002" "MX_R0402_SMALL_T01" list(7565.880000 5950.350000) t "0.10") | 2@@list("R4004" "MX_R0402_SMALL_T01" list(7614.380000 5950.350000) t "0.10") | 2@@list("R4005" "MX_R0402_SMALL_T01" list(7799.180000 5894.850000) t "0.10") | 2@@list("R4009" "MX_R0402_SMALL_T01" list(7379.380000 5793.290000) t "0.10") | 2@@list("R4010" "MX_R0402_SMALL_T01" list(7674.380000 5698.350000) t "0.10") | 2@@list("R4815" "MX_R0805_SMALL_T02" list(13399.810000 1738.630000) t "0.10") | 2@@list("R4820" "MX_R0805_SMALL_T02" list(13399.810000 1868.630000) t "0.10") | 2@@list("R60" "MX_R0402_SMALL_T01" list(7927.380000 4203.350000) t "0.10") | 2@@list("R62" "MX_R0402_SMALL_T01" list(13113.380000 2912.350000) t "0.10") | 2@@list("R637" "MX_R0402_SMALL_T01" list(8054.380000 3757.350000) t "0.10") | 2@@list("R651" "MX_R0603_SMALL_T01" list(11466.810000 1691.630000) t "0.10") | 2@@list("R658" "MX_R0603_SMALL_T01" list(11892.810000 1435.630000) t "0.10") | 2@@list("R661" "MX_R0603_SMALL_T01" list(11584.810000 1910.010000) t "0.10") | 2@@list("R663" "MX_R0402_SMALL_T01" list(11790.810000 1940.630000) t "0.10") | 2@@list("R69683" "MX_R0603_SMALL_T01" list(11877.810000 1570.630000) t "0.10") | 2@@list("R69684" "MX_R0603_SMALL_T01" list(11712.810000 1305.630000) t "0.10") | 2@@list("R69867" "MX_R0402_SMALL_T01" list(7051.340000 4974.630000) t "0.10") | 2@@list("R70259" "MX_R0402_SMALL_T01" list(9299.380000 6208.350000) t "0.10") | 2@@list("R70273" "MX_R0402_SMALL_T01" list(7440.380000 1047.350000) t "0.10") | 2@@list("R70293" "MX_R0402_SMALL_T01" list(7945.380000 1446.350000) t "0.10") | 2@@list("R70301" "MX_R0402_SMALL_T01" list(10479.810000 1435.630000) t "0.10") | 2@@list("R7204" "MX_R0402_SMALL_T01" list(7462.380000 3076.350000) t "0.10") | 2@@list("R7205" "MX_R0402_SMALL_T01" list(7327.380000 3156.350000) t "0.10") | 2@@list("R7206" "MX_R0402_SMALL_T01" list(7252.380000 3156.350000) t "0.10") | 2@@list("R7211" "MX_R0402_SMALL_T01" list(7461.380000 3126.350000) t "0.10") | 2@@list("R7212" "MX_R0402_SMALL_T01" list(7155.380000 2989.380000) t "0.10") | 2@@list("R7213" "MX_R0402_SMALL_T01" list(7482.380000 2910.640000) t "0.10") | 2@@list("R7217" "MX_R0402_SMALL_T01" list(7073.380000 2867.350000) t "0.10") | 2@@list("R7218" "MX_R0402_SMALL_T01" list(7036.380000 2867.350000) t "0.10") | 2@@list("R931" "MX_R0402_SMALL_T01" list(9010.380000 2145.350000) t "0.10") | 2@@list("R93103" "MX_R0402_SMALL_T01" list(11128.310000 1923.630000) t "0.10") | 2@@list("R93104" "MX_R0402_SMALL_T01" list(11253.810000 1917.630000) t "0.10") | 2@@list("R93105" "MX_R0402_SMALL_T01" list(11286.910000 1955.630000) t "0.10") | 2@@list("R93106" "MX_R0402_SMALL_T01" list(11430.810000 1819.630000) t "0.10") | 2@@list("R93107" "MX_R0402_SMALL_T01" list(11374.810000 1756.630000) t "0.10") | 2@@list("R93108" "MX_R0402_SMALL_T01" list(11374.810000 1838.620000) t "0.10") | 2@@list("R93109" "MX_R0402_SMALL_T01" list(11074.810000 2031.630000) t "0.10") | 2@@list("R93110" "MX_R0402_SMALL_T01" list(11052.810000 1955.630000) t "0.10") | 2@@list("R93115" "MX_R0402_SMALL_T01" list(8300.380000 4621.350000) t "0.10") | 2@@list("R93116" "MX_R0402_SMALL_T01" list(8272.310000 4774.430000) t "0.10") | 2@@list("R93117" "MX_R0402_SMALL_T01" list(8308.310000 4774.430000) t "0.10") | 2@@list("R93119" "MX_R0402_SMALL_T01" list(10111.380000 5088.350000) t "0.10") | 2@@list("R93121" "MX_R0603_SMALL_T01" list(11447.810000 1435.630000) t "0.10") | 2@@list("R93122" "MX_R0603_SMALL_T01" list(11468.510000 1571.020000) t "0.10") | 2@@list("R93166" "MX_R0402_SMALL_T01" list(9679.380000 2858.350000) t "0.10") | 2@@list("R932" "MX_R0603_SMALL_T01" list(9050.380000 2271.350000) t "0.10") | 2@@list("R933" "MX_R0402_SMALL_T01" list(8109.380000 1610.350000) t "0.10") | 2@@list("R934" "MX_R0603_SMALL_T01" list(8089.380000 1811.350000) t "0.10") | 2@@list("R99511" "MX_R0402_SMALL_T01" list(7146.380000 2910.640000) t "0.10") | 2@@list("R99512" "MX_R0402_SMALL_T01" list(7343.380000 3218.350000) t "0.10") | 2@@list("R99513" "MX_R0402_SMALL_T01" list(7353.350000 2831.350000) t "0.10") | 2@@list("R99517" "MX_R0402_SMALL_T01" list(9806.380000 6309.350000) t "0.10") | 2@@list("R99519" "MX_R0402_SMALL_T01" list(8785.390000 3614.350000) t "0.10") | 2@@list("R99527" "TX_R0603_SHORT" list(8242.380000 5153.350000) t "0.10") | 2@@list("R99528" "MX_R0402_SMALL_T01" list(10039.370000 3298.340000) t "0.10") | 2@@list("R99530" "MX_R0402_SMALL_T01" list(11052.810000 1992.400000) t "0.10") | 2@@list("R99532" "MX_R0402_SMALL_T01" list(10961.380000 1934.350000) t "0.10") | 2@@list("R99535" "MX_R0402_SMALL_T01" list(8478.380000 5583.350000) t "0.10") | 2@@list("R99536" "MX_R0402_SMALL_T01" list(8422.380000 5583.350000) t "0.10") | 2@@list("RN93" "TX_2R4P0201_35X28" list(9532.380000 6186.350000) t "0.10") | 2@@list("RN94" "TX_2R4P0201_35X28" list(9606.810000 6163.630000) t "0.10") | 2@@list("RO1" "MX_R0402_SMALL_T01" list(7049.340000 4861.630000) t "0.10") | 2@@list("RO2" "MX_R0402_SMALL_T01" list(7049.340000 4897.630000) t "0.10") | 2@@list("SC12" "MX_C0402_SMALL_T01" list(8679.580000 4604.130000) t "0.10") | 2@@list("SC146" "TX_C0201" list(8897.380000 3728.850000) t "0.10") | 2@@list("SC19" "MX_C0402_SMALL_T01" list(8181.880000 4016.350000) t "0.10") | 2@@list("SC20" "MX_C0402_SMALL_T01" list(8177.380000 3972.350000) t "0.10") | 2@@list("SC23" "MX_C0402_SMALL_T01" list(7647.880000 3918.350000) t "0.10") | 2@@list("SC24" "MX_C0402_SMALL_T01" list(8751.380000 4470.350000) t "0.10") | 2@@list("SC27" "MX_C0402_SMALL_T01" list(8341.380000 3459.350000) t "0.10") | 2@@list("SC28" "MX_C0402_SMALL_T01" list(8071.380000 3520.230000) t "0.10") | 2@@list("SC52" "MX_C0402_SMALL_T01" list(7809.880000 4067.350000) t "0.10") | 2@@list("SC72" "MX_C0402_SMALL_T01" list(8079.880000 3807.350000) t "0.10") | 2@@list("SC73" "MX_C0402_SMALL_T01" list(8310.880000 3725.350000) t "0.10") | 2@@list("SCB119" "MX_C0402_SMALL_T01" list(7836.380000 4382.350000) t "0.10") | 2@@list("SCB121" "MX_C0402_SMALL_T01" list(8039.380000 3707.850000) t "0.10") | 2@@list("SCB122" "MX_C0402_SMALL_T01" list(8686.380000 3746.230000) t "0.10") | 2@@list("SCB123" "MX_C0402_SMALL_T01" list(8742.260000 3752.230000) t "0.10") | 2@@list("SCB124" "MX_C0402_SMALL_T01" list(8566.380000 3936.350000) t "0.10") | 2@@list("SCB68" "MX_C0402_SMALL_T01" list(7875.380000 4335.350000) t "0.10") | 2@@list("SCB69" "MX_C0402_SMALL_T01" list(7837.380000 4431.350000) t "0.10") | 2@@list("SCB70" "MX_C0402_SMALL_T01" list(7852.380000 4278.350000) t "0.10") | 2@@list("SCB75" "MX_C0402_SMALL_T01" list(7009.810000 4081.630000) t "0.10") | 2@@list("SR103" "MX_R0402_SMALL_T01" list(8956.380000 3551.350000) t "0.10") | 2@@list("SR108" "MX_R0402_SMALL_T01" list(8781.380000 3369.350000) t "0.10") | 2@@list("SR112" "MX_R0402_SMALL_T01" list(8830.880000 3700.350000) t "0.10") | 2@@list("SR115" "MX_R0402_SMALL_T01" list(8751.380000 3422.350000) t "0.10") | 2@@list("SR116" "MX_R0402_SMALL_T01" list(9435.880000 6047.350000) t "0.10") | 2@@list("SR117" "MX_R0402_SMALL_T01" list(9178.380000 3106.350000) t "0.10") | 2@@list("SR118" "MX_R0402_SMALL_T01" list(8880.880000 3681.350000) t "0.10") | 2@@list("SR134" "MX_R0402_SMALL_T01" list(7883.380000 2940.350000) t "0.10") | 2@@list("SR135" "MX_R0402_SMALL_T01" list(7640.380000 2897.350000) t "0.10") | 2@@list("SR151" "MX_R0402_SMALL_T01" list(7110.660000 2126.920000) t "0.10") | 2@@list("SR154" "MX_R0402_SMALL_T01" list(7565.810000 2112.630000) t "0.10") | 2@@list("SR155" "MX_R0402_SMALL_T01" list(7527.810000 2112.630000) t "0.10") | 2@@list("SR162" "MX_R0402_SMALL_T01" list(7252.810000 2112.630000) t "0.10") | 2@@list("SR163" "MX_R0402_SMALL_T01" list(8094.380000 4014.350000) t "0.10") | 2@@list("SR164" "MX_R0402_SMALL_T01" list(8095.880000 3978.350000) t "0.10") | 2@@list("SR165" "MX_R0402_SMALL_T01" list(7225.660000 2674.420000) t "0.10") | 2@@list("SR166" "MX_R0402_SMALL_T01" list(7160.810000 2112.630000) t "0.10") | 2@@list("SR167" "MX_R0402_SMALL_T01" list(7312.810000 2607.630000) t "0.10") | 2@@list("SR168" "MX_R0402_SMALL_T01" list(8131.880000 3891.350000) t "0.10") | 2@@list("SR169" "MX_R0402_SMALL_T01" list(8131.880000 3855.350000) t "0.10") | 2@@list("SR17" "MX_R0402_SMALL_T01" list(8483.380000 3821.350000) t "0.10") | 2@@list("SR21" "MX_R0402_SMALL_T01" list(9296.880000 3335.770000) t "0.10") | 2@@list("SR212" "MX_R0402_SMALL_T01" list(8069.380000 3395.350000) t "0.10") | 2@@list("SR214" "MX_R0402_SMALL_T01" list(7859.380000 2194.350000) t "0.10") | 2@@list("SR215" "MX_R0402_SMALL_T01" list(7864.380000 2013.350000) t "0.10") | 2@@list("SR216" "MX_R0402_SMALL_T01" list(7754.380000 2658.350000) t "0.10") | 2@@list("SR218" "MX_R0402_SMALL_T01" list(7864.380000 2443.350000) t "0.10") | 2@@list("SR219" "MX_R0402_SMALL_T01" list(8002.380000 4042.350000) t "0.10") | 2@@list("SR226" "MX_R0402_SMALL_T01" list(8390.380000 4087.350000) t "0.10") | 2@@list("SR228" "MX_R0402_SMALL_T01" list(8316.380000 4093.350000) t "0.10") | 2@@list("SR229" "MX_R0402_SMALL_T01" list(8333.030000 4020.350000) t "0.10") | 2@@list("SR23" "MX_R0402_SMALL_T01" list(9085.380000 3507.350000) t "0.10") | 2@@list("SR237" "MX_R0402_SMALL_T01" list(9333.380000 2996.350000) t "0.10") | 2@@list("SR24" "MX_R0402_SMALL_T01" list(8360.380000 3743.350000) t "0.10") | 2@@list("SR25" "MX_R0402_SMALL_T01" list(8255.380000 3759.850000) t "0.10") | 2@@list("SR256" "MX_R0402_SMALL_T01" list(7646.380000 3235.350000) t "0.10") | 2@@list("SR258" "MX_R0402_SMALL_T01" list(8249.380000 4043.350000) t "0.10") | 2@@list("SR259" "MX_R0402_SMALL_T01" list(8777.880000 4587.850000) t "0.10") | 2@@list("SR265" "MX_R0402_SMALL_T01" list(12069.380000 2109.850000) t "0.10") | 2@@list("SR266" "MX_R0402_SMALL_T01" list(8763.380000 4535.350000) t "0.10") | 2@@list("SR27" "TX_R0402" list(8665.380000 3551.350000) t "0.10") | 2@@list("SR272" "MX_R0402_SMALL_T01" list(8325.380000 3619.350000) t "0.10") | 2@@list("SR277" "MX_R0402_SMALL_T01" list(8930.380000 3411.350000) t "0.10") | 2@@list("SR28" "TX_R0402" list(8505.380000 3555.350000) t "0.10") | 2@@list("SR288" "MX_R0402_SMALL_T01" list(8071.380000 3556.230000) t "0.10") | 2@@list("SR29" "TX_R0402" list(8484.380000 3434.350000) t "0.10") | 2@@list("SR290" "MX_R0402_SMALL_T01" list(8377.380000 3459.350000) t "0.10") | 2@@list("SR297" "MX_R0402_SMALL_T01" list(8757.050000 3522.350000) t "0.10") | 2@@list("SR298" "MX_R0402_SMALL_T01" list(8988.380000 3467.350000) t "0.10") | 2@@list("SR315" "MX_R0402_SMALL_T01" list(8947.380000 4488.340000) t "0.10") | 2@@list("SR338" "MX_R0402_SMALL_T01" list(8717.500000 3995.350000) t "0.10") | 2@@list("SR34" "MX_R0402_SMALL_T01" list(8419.880000 3818.850000) t "0.10") | 2@@list("SR342" "MX_R0402_SMALL_T01" list(9056.380000 3161.350000) t "0.10") | 2@@list("SR343" "MX_R0402_SMALL_T01" list(9147.380000 3054.470000) t "0.10") | 2@@list("SR344" "MX_R0402_SMALL_T01" list(8862.380000 3277.350000) t "0.10") | 2@@list("SR345" "MX_R0402_SMALL_T01" list(8825.380000 3277.350000) t "0.10") | 2@@list("SR346" "MX_R0402_SMALL_T01" list(9050.380000 3314.350000) t "0.10") | 2@@list("SR39" "MX_R0402_SMALL_T01" list(8808.380000 3188.350000) t "0.10") | 2@@list("SR40" "MX_R0402_SMALL_T01" list(8860.380000 3172.350000) t "0.10") | 2@@list("SR400" "MX_R0402_SMALL_T01" list(9322.380000 3202.350000) t "0.10") | 2@@list("SR401" "MX_R0402_SMALL_T01" list(9233.380000 3278.350000) t "0.10") | 2@@list("SR402" "MX_R0402_SMALL_T01" list(8680.380000 3344.230000) t "0.10") | 2@@list("SR403" "MX_R0402_SMALL_T01" list(8717.380000 3330.230000) t "0.10") | 2@@list("SR406" "MX_R0402_SMALL_T01" list(8592.380000 3774.350000) t "0.10") | 2@@list("SR407" "MX_R0402_SMALL_T01" list(9184.380000 3054.350000) t "0.10") | 2@@list("SR410" "MX_R0402_SMALL_T01" list(8064.830000 4129.350000) t "0.10") | 2@@list("SR411" "MX_R0402_SMALL_T01" list(8259.380000 4237.350000) t "0.10") | 2@@list("SR420" "MX_R0402_SMALL_T01" list(9333.380000 3034.350000) t "0.10") | 2@@list("SR46" "MX_R0402_SMALL_T01" list(9197.380000 3180.350000) t "0.10") | 2@@list("SR50" "MX_R0402_SMALL_T01" list(9179.380000 3558.350000) t "0.10") | 2@@list("SR52" "MX_R0402_SMALL_T01" list(8994.380000 3403.350000) t "0.10") | 2@@list("SR53" "MX_R0402_SMALL_T01" list(9019.380000 3156.850000) t "0.10") | 2@@list("SR546" "MX_R0402_SMALL_T01" list(8982.380000 3011.350000) t "0.10") | 2@@list("SR547" "MX_R0402_SMALL_T01" list(8916.380000 3256.350000) t "0.10") | 2@@list("SR548" "MX_R0402_SMALL_T01" list(9006.380000 3234.350000) t "0.10") | 2@@list("SR549" "MX_R0402_SMALL_T01" list(9062.380000 3095.230000) t "0.10") | 2@@list("SR57" "MX_R0402_SMALL_T01" list(9132.380000 3144.350000) t "0.10") | 2@@list("SR624" "MX_R0402_SMALL_T01" list(7336.810000 2112.630000) t "0.10") | 2@@list("SR625" "MX_R0402_SMALL_T01" list(7299.810000 2112.630000) t "0.10") | 2@@list("SR669" "MX_R0402_SMALL_T01" list(9056.500000 3045.350000) t "0.10") | 2@@list("SR673" "MX_R0402_SMALL_T01" list(8215.880000 3825.850000) t "0.10") | 2@@list("SR70" "MX_R0402_SMALL_T01" list(8799.680000 3422.350000) t "0.10") | 2@@list("SR71" "MX_R0402_SMALL_T01" list(8817.050000 3546.350000) t "0.10") | 2@@list("SR72" "MX_R0402_SMALL_T01" list(9026.380000 3558.350000) t "0.10") | 2@@list("SR73" "MX_R0402_SMALL_T01" list(8972.380000 3669.350000) t "0.10") | 2@@list("SR75" "MX_R0402_SMALL_T01" list(8372.380000 4607.350000) t "0.10") | 2@@list("SR750" "MX_R0402_SMALL_T01" list(7584.810000 2607.630000) t "0.10") | 2@@list("SR751" "MX_R0402_SMALL_T01" list(7547.810000 2607.630000) t "0.10") | 2@@list("SR752" "MX_R0402_SMALL_T01" list(7507.810000 2607.630000) t "0.10") | 2@@list("SR753" "MX_R0402_SMALL_T01" list(7467.810000 2607.630000) t "0.10") | 2@@list("SR754" "MX_R0402_SMALL_T01" list(7427.810000 2607.630000) t "0.10") | 2@@list("SR755" "MX_R0402_SMALL_T01" list(7387.810000 2607.630000) t "0.10") | 2@@list("SR756" "MX_R0402_SMALL_T01" list(7351.380000 2643.350000) t "0.10") | 2@@list("SR758" "MX_R0402_SMALL_T01" list(7194.810000 2607.630000) t "0.10") | 2@@list("SR759" "MX_R0402_SMALL_T01" list(7113.880000 2659.350000) t "0.10") | 2@@list("SR760" "MX_R0402_SMALL_T01" list(6991.380000 2680.350000) t "0.10") | 2@@list("SR763" "MX_R0402_SMALL_T01" list(8629.880000 4676.850000) t "0.10") | 2@@list("SR767" "MX_R0402_SMALL_T01" list(7084.810000 2608.630000) t "0.10") | 2@@list("SR768" "MX_R0402_SMALL_T01" list(7047.380000 2673.350000) t "0.10") | 2@@list("SR769" "MX_R0402_SMALL_T01" list(8636.880000 4604.850000) t "0.10") | 2@@list("SR773" "MX_R0402_SMALL_T01" list(10214.810000 5246.630000) t "0.10") | 2@@list("SR774" "MX_R0402_SMALL_T01" list(9960.380000 4456.350000) t "0.10") | 2@@list("SR775" "MX_R0402_SMALL_T01" list(7048.810000 2608.630000) t "0.10") | 2@@list("SR776" "MX_R0402_SMALL_T01" list(7013.060000 2608.940000) t "0.10") | 2@@list("SR777" "MX_R0402_SMALL_T01" list(7121.310000 2608.630000) t "0.10") | 2@@list("SR778" "MX_R0402_SMALL_T01" list(7006.380000 2544.350000) t "0.10") | 2@@list("SR7785" "MX_R0402_SMALL_T01" list(8579.380000 3552.350000) t "0.10") | 2@@list("SR7791" "MX_R0402_SMALL_T01" list(8033.380000 3395.350000) t "0.10") | 2@@list("SR7792" "MX_R0402_SMALL_T01" list(8185.380000 3575.350000) t "0.10") | 2@@list("SR7794" "MX_R0402_SMALL_T01" list(7609.380000 4685.350000) t "0.10") | 2@@list("SR78" "MX_R0402_SMALL_T01" list(9113.380000 2294.350000) t "0.10") | 2@@list("SR7803" "MX_R0402_SMALL_T01" list(9322.380000 3165.350000) t "0.10") | 2@@list("SR7815" "MX_R0402_SMALL_T01" list(9127.880000 3613.850000) t "0.10") | 2@@list("SR7816" "MX_R0402_SMALL_T01" list(8994.380000 3339.350000) t "0.10") | 2@@list("SR7817" "MX_R0402_SMALL_T01" list(8942.380000 3119.380000) t "0.10") | 2@@list("SR7829" "MX_R0402_SMALL_T01" list(8942.500000 3082.880000) t "0.10") | 2@@list("SR7830" "MX_R0402_SMALL_T01" list(9197.380000 3278.350000) t "0.10") | 2@@list("SR7831" "MX_R0402_SMALL_T01" list(9149.380000 3328.350000) t "0.10") | 2@@list("SR7832" "MX_R0402_SMALL_T01" list(8677.880000 3419.470000) t "0.10") | 2@@list("SR7833" "MX_R0402_SMALL_T01" list(8639.880000 3419.470000) t "0.10") | 2@@list("SR7834" "MX_R0402_SMALL_T01" list(8828.880000 3227.350000) t "0.10") | 2@@list("SR7841" "MX_R0402_SMALL_T01" list(8197.380000 4182.350000) t "0.10") | 2@@list("SR7843" "MX_R0402_SMALL_T01" list(8353.380000 4093.350000) t "0.10") | 2@@list("SR7847" "MX_R0402_SMALL_T01" list(8197.380000 4146.350000) t "0.10") | 2@@list("SR7848" "MX_R0402_SMALL_T01" list(8810.380000 3114.350000) t "0.10") | 2@@list("SR7849" "MX_R0402_SMALL_T01" list(9366.380000 3403.350000) t "0.10") | 2@@list("SR7850" "MX_R0402_SMALL_T01" list(9176.380000 3507.350000) t "0.10") | 2@@list("SR7851" "MX_R0402_SMALL_T01" list(8781.380000 3674.350000) t "0.10") | 2@@list("SR7852" "MX_R0402_SMALL_T01" list(9322.380000 3239.350000) t "0.10") | 2@@list("SR7854" "MX_R0402_SMALL_T01" list(8135.880000 3542.850000) t "0.10") | 2@@list("SR7855" "MX_R0402_SMALL_T01" list(8069.380000 3447.350000) t "0.10") | 2@@list("SR7856" "MX_R0402_SMALL_T01" list(8069.380000 3483.350000) t "0.10") | 2@@list("SR7857" "MX_R0402_SMALL_T01" list(8210.380000 3410.350000) t "0.10") | 2@@list("SR7858" "MX_R0402_SMALL_T01" list(8931.360000 3735.350000) t "0.10") | 2@@list("SR7873" "MX_R0402_SMALL_T01" list(8144.880000 3805.350000) t "0.10") | 2@@list("SR7877" "MX_R0402_SMALL_T01" list(9302.380000 2097.350000) t "0.10") | 2@@list("SR7878" "MX_R0402_SMALL_T01" list(8275.380000 3439.350000) t "0.10") | 2@@list("SR7879" "MX_R0402_SMALL_T01" list(8309.880000 3761.350000) t "0.10") | 2@@list("SR7882" "MX_R0402_SMALL_T01" list(8214.880000 3897.350000) t "0.10") | 2@@list("SR7883" "MX_R0402_SMALL_T01" list(8340.380000 3885.850000) t "0.10") | 2@@list("SR7887" "MX_R0402_SMALL_T01" list(8984.380000 2413.350000) t "0.10") | 2@@list("SR7889" "MX_R0402_SMALL_T01" list(11946.080000 1976.020000) t "0.10") | 2@@list("SR7895" "MX_R0402_SMALL_T01" list(8340.380000 3849.850000) t "0.10") | 2@@list("SR7896" "MX_R0402_SMALL_T01" list(8215.380000 3462.350000) t "0.10") | 2@@list("SR7897" "MX_R0402_SMALL_T01" list(8095.380000 3942.350000) t "0.10") | 2@@list("SR79" "MX_R0402_SMALL_T01" list(7886.380000 1543.350000) t "0.10") | 2@@list("SR7914" "MX_R0402_SMALL_T01" list(8301.380000 4425.350000) t "0.10") | 2@@list("SR7919" "MX_R0402_SMALL_T01" list(8465.380000 4272.350000) t "0.10") | 2@@list("SR7920" "MX_R0402_SMALL_T01" list(8360.380000 4312.350000) t "0.10") | 2@@list("SR7921" "MX_R0402_SMALL_T01" list(8701.010000 4163.040000) t "0.10") | 2@@list("SR7924" "MX_R0402_SMALL_T01" list(8514.380000 4268.350000) t "0.10") | 2@@list("SR7925" "MX_R0402_SMALL_T01" list(8564.380000 4232.850000) t "0.10") | 2@@list("SR7928" "MX_R0402_SMALL_T01" list(8568.380000 4421.350000) t "0.10") | 2@@list("SR7931" "MX_R0402_SMALL_T01" list(9179.380000 3398.350000) t "0.10") | 2@@list("SR7938" "MX_R0402_SMALL_T01" list(8502.380000 3939.350000) t "0.10") | 2@@list("SR7939" "MX_R0402_SMALL_T01" list(8279.380000 4093.350000) t "0.10") | 2@@list("SR7941" "MX_R0402_SMALL_T01" list(8117.380000 4141.350000) t "0.10") | 2@@list("SR7944" "MX_R0402_SMALL_T01" list(8332.380000 3542.850000) t "0.10") | 2@@list("SR7945" "MX_R0402_SMALL_T01" list(8456.380000 3770.350000) t "0.10") | 2@@list("SR7946" "MX_R0402_SMALL_T01" list(8495.380000 3755.350000) t "0.10") | 2@@list("SR7947" "MX_R0402_SMALL_T01" list(8332.380000 3578.850000) t "0.10") | 2@@list("SR7948" "MX_R0402_SMALL_T01" list(9043.380000 3463.350000) t "0.10") | 2@@list("SR7949" "MX_R0402_SMALL_T01" list(9041.380000 3378.350000) t "0.10") | 2@@list("SR7950" "MX_R0402_SMALL_T01" list(9077.880000 3647.850000) t "0.10") | 2@@list("SR7951" "MX_R0402_SMALL_T01" list(9091.380000 3597.350000) t "0.10") | 2@@list("SR7953" "MX_R0402_SMALL_T01" list(9610.980000 2526.850000) t "0.10") | 2@@list("SR7954" "MX_R0402_SMALL_T01" list(9054.380000 3739.350000) t "0.10") | 2@@list("SR7955" "MX_R0402_SMALL_T01" list(8893.880000 3642.850000) t "0.10") | 2@@list("SR7966" "MX_R0402_SMALL_T01" list(9669.380000 2543.350000) t "0.10") | 2@@list("SR7976" "MX_R0402_SMALL_T01" list(8808.380000 3150.350000) t "0.10") | 2@@list("SR7977" "MX_R0402_SMALL_T01" list(9129.380000 3418.350000) t "0.10") | 2@@list("SR7979" "MX_R0402_SMALL_T01" list(8189.380000 4093.350000) t "0.10") | 2@@list("SR7990" "MX_R0402_SMALL_T01" list(9135.380000 1148.350000) t "0.10") | 2@@list("SR7991" "MX_R0402_SMALL_T01" list(8794.380000 4259.850000) t "0.10") | 2@@list("SR7994" "MX_R0402_SMALL_T01" list(10109.380000 5898.350000) t "0.10") | 2@@list("SR7995" "MX_R0402_SMALL_T01" list(9834.380000 5960.350000) t "0.10") | 2@@list("SR823" "MX_R0402_SMALL_T01" list(7231.810000 2607.630000) t "0.10") | 2@@list("SR84" "MX_R0402_SMALL_T01" list(8853.380000 3583.350000) t "0.10") | 2@@list("SR85" "MX_R0402_SMALL_T01" list(8969.880000 3719.030000) t "0.10") | 2@@list("SR86" "MX_R0402_SMALL_T01" list(8909.380000 3447.350000) t "0.10") | 2@@list("SR88" "MX_R0402_SMALL_T01" list(8918.380000 3513.940000) t "0.10") | 2@@list("SR897" "MX_R0402_SMALL_T01" list(8556.380000 3774.350000) t "0.10") | 2@@list("SR9" "MX_R0402_SMALL_T01" list(9178.380000 3468.350000) t "0.10") | 2@@list("SR909" "MX_R0402_SMALL_T01" list(8214.730000 3861.350000) t "0.10") | 2@@list("SR911" "MX_R0402_SMALL_T01" list(8282.380000 3543.350000) t "0.10") | 2@@list("SR912" "MX_R0402_SMALL_T01" list(8159.380000 3936.350000) t "0.10") | 2@@list("SR93" "MX_R0402_SMALL_T01" list(8716.100000 4604.050000) t "0.10") | 2@@list("ST1" "MX_TPC26T_S4_68" list(10748.310000 1468.630000) t "0.10") | 2@@list("ST16" "MX_TPC26T_S4_68" list(8163.380000 4498.350000) t "0.10") | 2@@list("ST17" "MX_TPC26T_S4_68" list(8735.880000 4273.350000) t "0.10") | 2@@list("ST20" "MX_TPC26T_S4_68" list(8730.380000 3634.350000) t "0.10") | 2@@list("ST25" "MX_TPC26T_S4_68" list(8804.380000 4338.850000) t "0.10") | 2@@list("ST26" "MX_TPC26T_S4_68" list(10692.810000 1413.630000) t "0.10") | 2@@list("ST3" "MX_TPC26T_S4_68" list(8283.380000 3858.350000) t "0.10") | 2@@list("ST31" "MX_TPC26T_S4_68" list(9338.380000 3497.350000) t "0.10") | 2@@list("ST33" "MX_TPC26T_S4_68" list(8532.880000 3345.350000) t "0.10") | 2@@list("ST34" "MX_TPC26T_S4_68" list(8934.380000 3308.350000) t "0.10") | 2@@list("TC10" "MX_C0402_SMALL_T01" list(7881.910000 5127.530000) t "0.10") | 2@@list("TC11" "MX_C0402_SMALL_T01" list(8001.910000 5127.530000) t "0.10") | 2@@list("TC12" "MX_C0402_SMALL_T01" list(7961.910000 5127.530000) t "0.10") | 2@@list("TC9" "MX_C0402_SMALL_T01" list(7921.910000 5127.530000) t "0.10") | 2@@list("TP2601" "MX_TPC26T_S4_68" list(8676.650000 3681.350000) t "0.10") | 2@@list("TP2602" "MX_TPC26T_S4_68" list(8633.380000 3812.350000) t "0.10") | 2@@list("TP7201" "MX_TPC26T_S4_68" list(7553.380000 2931.350000) t "0.10") | 2@@list("TUC23" "MX_C0603_SMALL_T01" list(9207.880000 6202.350000) t "0.10") | 2@@list("TUC26" "MX_C0603_SMALL_T01" list(10030.880000 6245.350000) t "0.10") | 2@@list("TUC27" "MX_C0603_SMALL_T01" list(10591.810000 1345.630000) t "0.10") | 2@@list("TUC30" "MX_C0603_SMALL_T01" list(9206.880000 6254.350000) t "0.10") | 2@@list("TUC32" "MX_C0603_SMALL_T01" list(9983.380000 6245.350000) t "0.10") | 2@@list("TUC36" "TX_C0805_T02_H55" list(9226.380000 6140.350000) t "0.10") | 2@@list("TUC37" "TX_C0805_T02_H55" list(9922.380000 6251.850000) t "0.10") | 2@@list("U131" "MX_A_SMB_181X157_COLAY" list(6959.380000 6568.350000) t "0.10") | 2@@list("U7201" "MX_QFN_32P_20_S201_P_4V" list(7320.640000 2979.540000) t "0.10") | 2@@list("UB1" "MX_SOIC_8P_50_197X236" list(8746.930000 5002.630000) t "0.10") | 2@@list("UBC1" "MX_C0402_SMALL_T01" list(8933.380000 5108.350000) t "0.10") | 2@@list("UBR1" "MX_R0402_SMALL_T01" list(8922.380000 5045.350000) t "0.10") | 2@@list("UBR2" "MX_R0402_SMALL_T01" list(8936.380000 4991.350000) t "0.10") | 2@@list("UBR3" "MX_R0402_SMALL_T01" list(8572.950000 5002.630000) t "0.10") | 2@@list("UU19" "MX_SOT23_S5_H57" list(9347.880000 6078.350000) t "0.10") | 2@@list("UU64" "TX_SOT23_S5_2D4_T02X01_H57" list(9766.380000 6221.350000) t "0.10") | 2@@list("UU65" "MX_SOT23_S5_H57" list(10688.810000 1298.630000) t "0.10") | 2@@list("Y4000" "MX_XTAL_4P_126X98_HOSON_H35" list(7864.380000 5738.350000) t "0.10") | 3@@list("PU89001" "MX_QFN_52P_16_S236_PD_4VIA" list(10399.380000 6738.350000) t "0.08") | 3@@list("U104" "MX_QFP_128P_16_S630_H47" list(7419.690000 4287.750000) t "0.08") | 3@@list("U114" "MX_QFN_32P_16_S157_P_H35_8V" list(7539.380000 5773.350000) t "0.08") | 4@@list("CM3301" "TX_CHOKE_4P_35X28_PAN" list(9859.380000 1128.350000) nil "NONE") | 4@@list("CM3302" "TX_CHOKE_4P_35X28_PAN" list(9929.380000 1128.350000) nil "NONE") | 4@@list("CM3605" "TX_CHOKE_4P_35X28_PAN" list(9543.010000 6267.280000) nil "NONE") | 4@@list("CM3606" "TX_CHOKE_4P_35X28_PAN" list(9616.300000 6269.630000) nil "NONE") | 4@@list("CM4004" "TX_CHOKE_4P_35X28_PAN" list(9284.380000 1127.350000) nil "NONE") | 4@@list("CM4005" "TX_CHOKE_4P_35X28_PAN" list(9349.380000 1123.350000) nil "NONE") | 4@@list("D6301" "A_VARISTOR_0603_71X39_TK" list(13356.380000 6624.350000) nil "NONE") | 4@@list("H10" "H_2D_D169ND98X197N_M2_P2_V7" list(9929.530000 3910.630000) nil "NONE") | 4@@list("H2" "HOLE_C275D177N_M2_P2_V8" list(8515.750000 1364.180000) nil "NONE") | 4@@list("H4" "HOLE_C275D177N_M2_P2_V8" list(7295.280000 1597.640000) nil "NONE") | 4@@list("H7" "HOLE_C275D177N_M2_P2_V8" list(7295.280000 3566.150000) nil "NONE") | 4@@list("J303" "MX_HD_2X4P_50_SINYA" list(9551.380000 2666.350000) nil "NONE") | 4@@list("J8" "MX_LAN_JACK_12P_2H_ALL_SMT" list(7813.490000 6808.270000) nil "NONE") | 4@@list("P12" "MX_FPC_12P_39_4HOLD_AC" list(6951.470000 5204.630000) nil "NONE") | 4@@list("PQ5" "MX_SI7850DP_COLAY" list(9851.380000 4572.390000) nil "NONE") | 4@@list("PQ90001" "TX_DFN_8P_201X240_2P_10V_CO" list(11751.380000 6259.510000) nil "NONE") | 4@@list("PQ93008" "TX_DFN_8P_201X240_2P_10V_CO" list(11044.380000 6287.510000) nil "NONE") | 4@@list("PQ93018" "TX_DFN_8P_201X240_2P_10V_CO" list(10554.380000 6287.510000) nil "NONE") | 4@@list("U1" "A_BGA_874P_988X949_N" list(8764.810000 3968.510000) nil "NONE") | 5@@list("CM3601" "TX_CHOKE_4P_35X28_PAN" list(9532.660000 6186.920000) t "NONE") | 5@@list("CM3602" "TX_CHOKE_4P_35X28_PAN" list(9606.810000 6163.630000) t "NONE") | 5@@list("H10" "H_2D_D169ND98X197N_M2_P2_V7" list(9929.530000 3910.630000) nil "NONE") | 5@@list("H2" "HOLE_C275D177N_M2_P2_V8" list(8515.750000 1364.180000) nil "NONE") | 5@@list("H4" "HOLE_C275D177N_M2_P2_V8" list(7295.280000 1597.640000) nil "NONE") | 5@@list("H7" "HOLE_C275D177N_M2_P2_V8" list(7295.280000 3566.150000) nil "NONE") | 5@@list("PQ21" "MX_SC70_6_VISHAY_T01" list(9570.380000 4334.350000) t "NONE") | 5@@list("PU4" "MX_QFN_20P_16_S122_PD_4V" list(11054.810000 1468.630000) t "NONE") | 5@@list("PU9" "MX_QFN_20P_16_S122_P_4V" list(12229.810000 1433.630000) t "NONE") | 5@@list("Q93034" "MX_SC70_6_VISHAY_T01" list(11149.810000 1838.890000) t "NONE") | list("[Package] BOTTOM" "446.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "6431.06 MIL" "-6431.06 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-10054.81 4063.71) (-9894.81 4223.71))" list(-3463.940000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:01" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:50" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "353.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "6431.06 MIL" "-6431.06 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-10054.81 4063.71) (-9894.81 4223.71))" list(-3463.940000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:53" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "484.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "354.02 MIL" "-354.02 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-4192.96 3895.93) (-3817.96 4270.93))" list(-3463.940000 3994.900000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:07" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:15" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "326.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-3470.19 3064.14) (-2851.69 3529.86))" list(-3463.940000 3064.140000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:39" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:36" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "498.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3481.0 2595.0) (-3027.0 3049.0))" list(-3463.940000 2735.660000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:26" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:22" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "318.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-3485.31 470.8) (-3398.69 1195.21))" list(-3463.940000 470.800000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:31" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:32" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "359.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-3519.69 -2236.27) (-3251.97 -1933.12))" list(-3463.940000 -1933.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:05" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "509.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "6299.3 MIL" "-6299.30 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-9891.69 -2917.8) (-9731.69 -2757.8))" list(-3463.940000 -2204.130000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:04" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:38" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "441.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "6299.3 MIL" "-6299.30 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-9891.69 -2917.8) (-9731.69 -2757.8))" list(-3463.940000 -2204.130000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:40" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:48" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "483.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-3423.55 -1941.7) (-3323.59 -1841.73))" "[Shape] Package Keepout/Bottom ((-3558.83 -2236.03) (-3212.83 -1937.42))" list(-3387.830000 -1939.620000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:08" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:15" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "493.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-1.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-3423.55 -1941.7) (-3323.59 -1841.73))" "[Shape] Package Keepout/Bottom ((-3644.82 -2322.03) (-3126.84 -1851.42))" list(-3342.470000 -1852.590000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:06" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:20" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "485.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "199.89 MIL" "-199.89 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3386.44 -2779.02) (-3011.44 -2404.02))" list(-3265.710000 -2204.130000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:05" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:16" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "419.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3233.14 2263.09) (-3154.0 2389.47))" "[Shape] Package Geometry/Place_Bound_Top ((-3236.88 2265.26) (-3150.26 2387.3))" list(-3154.000000 2265.260000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:22" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:37" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "480.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "95 MIL" "-95.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((-3255.14 4188.86) (-3028.86 4415.14))" list(-3142.000000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:04" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:13" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "387.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "96 MIL" "-96.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-3255.14 4189.86) (-3028.86 4416.14))" list(-3142.000000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:36" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:21" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "398.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3145.14 2287.09) (-3066.0 2413.47))" "[Shape] Package Geometry/Place_Bound_Top ((-3148.88 2289.26) (-3062.26 2411.3))" list(-3066.000000 2289.260000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:27" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "263.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "223.36 MIL" "-23.36 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId737<uTiL>.35:<uTiL>cId25<uTiL>.B36 ((-3023.83 1907.58) (-1103.84 770.2))" "[PinPair] <uTiL>cId737<uTiL>.37:<uTiL>cId25<uTiL>.C36 ((-3004.14 1907.58) (-1123.55 770.2))" list(-3004.140000 1907.580000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:11" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:49" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "361.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-3057.14 2287.09) (-2978.0 2413.47))" "[Shape] Package Geometry/Place_Bound_Top ((-3060.88 2289.26) (-2974.26 2411.3))" list(-2978.000000 2289.260000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:06" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "420.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2968.14 2287.09) (-2889.0 2413.47))" "[Shape] Package Geometry/Place_Bound_Top ((-2971.88 2289.26) (-2885.26 2411.3))" list(-2889.000000 2289.260000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:37" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "306.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "401.09 MIL" "-201.09 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.10:<uTiL>cId2150<uTiL>.3 ((-2822.83 2755.63) (-3298.74 3114.65))" "[PinPair] <uTiL>cId23<uTiL>.9:<uTiL>cId2150<uTiL>.2 ((-2824.83 2739.88) (-3338.11 3114.65))" list(-2824.830000 2739.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:55" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:15" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "310.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "382.26 MIL" "-182.26 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.7:<uTiL>cId2150<uTiL>.6 ((-2789.37 2722.17) (-3180.63 3114.65))" "[PinPair] <uTiL>cId23<uTiL>.6:<uTiL>cId2150<uTiL>.5 ((-2773.62 2722.17) (-3220.0 3114.65))" list(-2773.620000 2722.170000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:57" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:27" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "421.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2.01 MIL" "-2.01 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2775.57 1987.76) (-2747.57 2045.76))" list(-2756.700000 1987.760000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:38" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "333.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-3445.4 1559.83) (-2521.62 1958.08))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2756.700000 1958.080000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:41" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:39" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "334.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-3445.4 1559.83) (-2543.2 1958.08))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2756.700000 1958.080000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:41" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:40" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "393.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "167.32 MIL" "-167.32 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-3425.4 1579.83) (-2563.2 1938.08))" list(-2756.700000 1938.080000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:24" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "308.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "254.26 MIL" "-54.26 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.5:<uTiL>cId2150<uTiL>.9 ((-2757.87 2722.17) (-3062.51 3114.65))" "[PinPair] <uTiL>cId23<uTiL>.4:<uTiL>cId2150<uTiL>.8 ((-2742.13 2722.17) (-3101.88 3114.65))" list(-2742.130000 2722.170000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:56" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:26" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "332.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2735.38 1992.78) (-2711.76 2043.78))" list(-2735.380000 2039.930000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:39" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "312.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "258.6 MIL" "-58.60 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.2:<uTiL>cId2150<uTiL>.12 ((-2710.63 2722.17) (-2944.4 3114.65))" "[PinPair] <uTiL>cId23<uTiL>.1:<uTiL>cId2150<uTiL>.11 ((-2694.88 2720.17) (-2983.77 3114.65))" list(-2694.880000 2720.170000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:14" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:28" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "401.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2601.21 2520.86) (-2439.79 2603.54))" list(-2601.210000 2526.770000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:32" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:28" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "391.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "167.32 MIL" "-167.32 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-3445.4 1559.83) (-2521.62 1958.08))" "[Shape] Package Geometry/Place_Bound_Top ((-3425.4 1579.83) (-2563.2 1938.08))" list(-2563.200000 1799.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:23" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "392.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "167.32 MIL" "-167.32 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-3445.4 1559.83) (-2543.2 1958.08))" "[Shape] Package Geometry/Place_Bound_Top ((-3425.4 1579.83) (-2563.2 1938.08))" list(-2563.200000 1579.830000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:24" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "436.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-2753.95 -2427.17) (-2541.35 -2154.1))" list(-2541.350000 -2388.660000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:39" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "358.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-2528.83 -2765.74) (-2132.63 -2171.76))" list(-2528.830000 -2395.930000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "363.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2523.36 1967.81) (-2460.44 2077.99))" list(-2523.360000 1967.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:07" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "335.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2440.94 1905.1) (-2383.86 2001.1))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2440.940000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:42" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:40" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "411.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2440.94 1905.1) (-2383.86 2001.1))" "[Shape] Package Geometry/Place_Bound_Top ((-2439.81 1974.19) (-2384.19 2067.81))" list(-2439.810000 2001.100000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:54" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:33" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "410.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2439.81 1974.19) (-2384.19 2067.81))" list(-2439.810000 1974.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:54" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:32" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "336.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2370.94 1905.1) (-2313.86 2001.1))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2370.940000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:42" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:41" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "360.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2321.86 -517.27) (-2251.0 -391.29))" "[Shape] Package Geometry/Place_Bound_Top ((-2329.74 -515.3) (-2243.12 -393.26))" list(-2321.860000 -515.300000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:05" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "443.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "165.35 MIL" "-165.35 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2503.75 -1950.88) (-1044.19 -176.31))" "[Shape] Package Geometry/Place_Bound_Top ((-2216.73 -634.04) (-1330.51 -251.78))" list(-2216.610000 -256.340000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:46" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:49" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "347.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2207.64 -64.17) (-2097.4 242.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2285.19 50.0) (-2206.45 128.74))" list(-2207.640000 50.000000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:21" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "424.Pkg to Pkg Spacing" "118.11 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-212.60 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2207.64 -64.17) (-2097.4 242.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2283.46 128.74) (-2206.45 143.35))" list(-2206.450000 128.740000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:33" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:39" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "340.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2208.6 2042.56) (-2112.6 2099.64))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2203.910000 2042.560000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:44" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:43" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "337.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2303.72 1897.18) (-2181.68 2026.62))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-2195.310000 2022.920000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:43" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:41" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "329.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2179.81 1849.19) (-2124.19 1942.81))" list(-2179.810000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:35" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:37" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "440.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "21.65 MIL" "-21.65 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2171.41 1969.7) (-2147.79 2020.7))" list(-2171.410000 2016.850000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:48" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "442.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "165.35 MIL" "-165.35 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2236.73 -654.04) (-1310.51 -231.78))" "[Shape] Package Geometry/Place_Bound_Top ((-2216.73 -634.04) (-1330.51 -251.78))" list(-2145.960000 -634.040000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:46" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:48" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "395.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "15.75 MIL" "-15.75 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2135.91 1969.7) (-2112.29 2020.7))" list(-2114.100000 1973.550000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:40" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:25" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "385.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-2109.44 -2765.75) (-1707.86 -2163.38))" list(-2109.440000 -2609.600000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:22" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:20" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "350.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "118.11 MIL" "-118.11 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-2106.1 1783.07) (-1731.9 2066.93))" list(-2106.100000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:37" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:48" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "384.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-2902.01 3327.01) (-2049.77 4198.03))" list(-2103.310000 3832.200000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:20" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "407.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-316.14 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2207.64 -64.17) (-2097.4 242.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2206.45 -66.53) (-2098.58 245.28))" list(-2098.580000 242.910000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:25" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:31" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "426.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2207.64 -64.17) (-2097.4 242.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2098.58 -107.48) (-1901.73 286.22))" list(-2098.580000 -64.170000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:34" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:40" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "406.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2207.64 -64.17) (-2097.4 242.91))" "[Shape] Package Geometry/Place_Bound_Top ((-2098.58 55.09) (-2059.99 286.22))" list(-2097.400000 55.090000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:24" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:30" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "389.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "316.14 MIL" "-316.14 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2098.98 396.07) (-950.16 1584.25))" "[Shape] Package Geometry/Place_Bound_Top ((-2115.11 286.22) (-2008.81 1017.72))" list(-2059.990000 416.840000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:37" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:22" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "283.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "252.85 MIL" "-52.85 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId738<uTiL>.9:<uTiL>cId25<uTiL>.BA3 ((-2059.05 -294.29) (-1862.93 1415.72))" "[PinPair] <uTiL>cId738<uTiL>.11:<uTiL>cId25<uTiL>.BA2 ((-2039.37 -294.29) (-1860.23 1435.66))" list(-2039.370000 -294.290000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:25" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:01" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "372.Pkg to Place Keepout Spacing" "29.61 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-286.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2077.72 1208.66) (-1723.39 1562.99))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-2008.810000 1208.660000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:35" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:14" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "369.Pkg to Place Keepout Spacing" "29.61 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-286.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2077.72 417.33) (-1723.39 771.66))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-2008.810000 771.660000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:33" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "284.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "237.95 MIL" "-37.95 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BB4:<uTiL>cId738<uTiL>.17 ((-1883.88 1416.36) (-1980.31 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BB3:<uTiL>cId738<uTiL>.15 ((-1891.29 1435.75) (-2000.0 -294.29))" list(-2000.000000 -294.290000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:01" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "370.Pkg to Pkg Spacing" "23.62 MIL [PACKAGE_HEIGHT_MIN]" "59.21 MIL" "-35.59 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1998.98 496.07) (-1050.16 1484.25))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-1998.980000 990.160000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:34" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "425.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "251.97 MIL" "-173.23 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1970.75 -172.86) (-1789.25 244.86))" "[Shape] Package Geometry/Place_Bound_Top ((-2098.58 -107.48) (-1901.73 286.22))" list(-1970.750000 -107.480000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:33" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:40" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "285.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "246.32 MIL" "-46.32 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BG6:<uTiL>cId738<uTiL>.59 ((-1970.0 1360.2) (-1566.93 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BF6:<uTiL>cId738<uTiL>.61 ((-1950.2 1360.11) (-1547.24 -294.29))" list(-1950.200000 1360.110000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:02" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "281.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "226.69 MIL" "-26.69 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BE3:<uTiL>cId738<uTiL>.23 ((-1930.53 1417.73) (-1921.26 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BD4:<uTiL>cId738<uTiL>.21 ((-1917.61 1402.52) (-1940.94 -294.29))" list(-1917.610000 1402.520000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:19" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:00" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "280.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "283.06 MIL" "-83.06 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BE6:<uTiL>cId738<uTiL>.65 ((-1932.34 1348.08) (-1507.87 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BD7:<uTiL>cId738<uTiL>.67 ((-1913.25 1341.12) (-1488.19 -294.29))" list(-1913.250000 1341.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:19" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:59" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "364.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1929.72 3357.57) (-1871.72 3447.57))" "[Shape] Package Geometry/Place_Bound_Top ((-1924.34 3367.96) (-1877.1 3437.18))" list(-1877.100000 3375.010000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:07" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "278.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "216.11 MIL" "-16.11 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BC5:<uTiL>cId738<uTiL>.71 ((-1888.9 1369.46) (-1448.82 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BB6:<uTiL>cId738<uTiL>.73 ((-1867.34 1347.96) (-1429.13 -294.29))" list(-1867.340000 1347.960000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:18" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:58" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "282.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "215.73 MIL" "-15.73 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId738<uTiL>.11:<uTiL>cId25<uTiL>.BA2 ((-2039.37 -294.29) (-1860.23 1435.66))" "[PinPair] <uTiL>cId738<uTiL>.9:<uTiL>cId25<uTiL>.BA3 ((-2059.05 -294.29) (-1862.93 1415.72))" list(-1862.930000 1415.720000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:20" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:00" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "386.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1869.72 3357.57) (-1811.72 3447.57))" "[Shape] Package Geometry/Place_Bound_Top ((-1864.34 3367.96) (-1817.1 3437.18))" list(-1817.100000 3375.010000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:21" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "295.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "229.35 MIL" "-29.35 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.C24:<uTiL>cId738<uTiL>.35 ((-1128.54 1017.41) (-1803.15 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.B24:<uTiL>cId738<uTiL>.37 ((-1107.14 1011.11) (-1783.46 -294.29))" list(-1783.460000 -294.290000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:49" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "341.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1723.69 2027.62) (-1684.31 2102.38))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-1684.500000 2029.570000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:44" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:44" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "286.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "221.57 MIL" "-21.57 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BF6:<uTiL>cId738<uTiL>.61 ((-1950.2 1360.11) (-1547.24 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BG6:<uTiL>cId738<uTiL>.59 ((-1970.0 1360.2) (-1566.93 -294.29))" list(-1566.930000 -294.290000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:03" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "374.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "257.87 MIL" "-257.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1508.76 -68.69) (-1055.24 344.69))" "[Shape] Package Geometry/Place_Bound_Top ((-1555.43 -108.06) (-1008.57 384.06))" list(-1508.760000 325.000000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:22" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:15" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "432.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-1501.23 -2649.6) (-876.91 -1999.99))" list(-1480.410000 -2609.600000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:51" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:43" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "316.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "210.73 MIL" "-10.73 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.Y3:<uTiL>cId8<uTiL>.42 ((-1449.72 1415.88) (-658.78 1738.73))" "[PinPair] <uTiL>cId25<uTiL>.Y4:<uTiL>cId8<uTiL>.40 ((-1452.92 1396.18) (-658.78 1758.42))" list(-1452.920000 1396.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:31" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "279.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "229.54 MIL" "-29.54 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.BB6:<uTiL>cId738<uTiL>.73 ((-1867.34 1347.96) (-1429.13 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.BC5:<uTiL>cId738<uTiL>.71 ((-1888.9 1369.46) (-1448.82 -294.29))" list(-1448.820000 -294.290000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:19" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:58" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "273.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "222.1 MIL" "-22.10 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId742<uTiL>.3:<uTiL>cId25<uTiL>.G5 ((-1511.03 3677.11) (-1202.02 1378.18))" "[PinPair] <uTiL>cId742<uTiL>.2:<uTiL>cId25<uTiL>.G4 ((-1432.29 3677.11) (-1191.18 1395.84))" list(-1432.290000 3677.110000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:55" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "274.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "284.71 MIL" "-84.71 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId742<uTiL>.7:<uTiL>cId25<uTiL>.L3 ((-1511.03 3573.96) (-1276.72 1415.88))" "[PinPair] <uTiL>cId742<uTiL>.6:<uTiL>cId25<uTiL>.L4 ((-1432.29 3573.96) (-1279.92 1396.18))" list(-1432.290000 3573.960000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:55" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "487.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-1.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-1428.31 -1925.89) (-1310.31 -1897.89))" "[Shape] Package Keepout/Bottom ((-1670.73 -2408.82) (-707.41 -1856.52))" list(-1420.550000 -1899.360000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:14" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:17" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "430.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "318.5 MIL" "-318.50 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-1707.6 -2652.17) (-1399.92 -2308.51))" "[Shape] Package Geometry/Place_Bound_Top ((-1501.23 -2649.6) (-876.91 -1999.99))" list(-1399.920000 -2649.600000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:50" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:42" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "338.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1676.43 1769.52) (-1392.57 2110.08))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-1392.570000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:43" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:42" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "435.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "363.78 MIL" "-363.78 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2098.98 396.07) (-950.16 1584.25))" "[Shape] Package Geometry/Place_Bound_Top ((-1736.92 -163.18) (-1386.13 439.18))" list(-1386.130000 396.070000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:38" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "365.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "85.04 MIL" "-85.04 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1508.76 -68.69) (-1055.24 344.69))" "[Shape] Package Geometry/Place_Bound_Top ((-1387.3 -27.51) (-1174.7 331.51))" list(-1368.000000 344.690000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "366.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "85.04 MIL" "-85.04 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1555.43 -108.06) (-1008.57 384.06))" "[Shape] Package Geometry/Place_Bound_Top ((-1387.3 -27.51) (-1174.7 331.51))" list(-1368.000000 -27.510000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:31" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "253.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "205.22 MIL" "-5.22 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.N15:<uTiL>cId3077<uTiL>.3 ((-1310.27 1183.86) (-1149.7 -2107.08))" "[PinPair] <uTiL>cId25<uTiL>.N13:<uTiL>cId3077<uTiL>.2 ((-1310.27 1213.86) (-1228.44 -2107.08))" list(-1310.270000 1213.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:06" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:43" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "289.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "248.9 MIL" "-48.90 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.D4:<uTiL>cId3077<uTiL>.9 ((-1131.53 1402.52) (-1346.55 -2048.02))" "[PinPair] <uTiL>cId25<uTiL>.C3:<uTiL>cId3077<uTiL>.8 ((-1118.61 1417.73) (-1267.81 -2048.02))" list(-1267.810000 -2048.020000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "259.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "271.72 MIL" "-71.72 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.11:<uTiL>cId25<uTiL>.K4 ((-664.58 3595.62) (-1262.03 1387.72))" "[PinPair] <uTiL>cId3069<uTiL>.12:<uTiL>cId25<uTiL>.K3 ((-743.32 3595.62) (-1258.41 1408.2))" list(-1258.410000 1408.200000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:09" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "268.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "350.73 MIL" "-150.73 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId739<uTiL>.3:<uTiL>cId25<uTiL>.J2 ((-362.2 -2107.08) (-1244.12 1427.28))" "[PinPair] <uTiL>cId739<uTiL>.2:<uTiL>cId25<uTiL>.J3 ((-440.94 -2107.08) (-1238.07 1405.88))" list(-1238.070000 1405.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:13" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:52" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "265.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "216.98 MIL" "-16.98 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId737<uTiL>.43:<uTiL>cId25<uTiL>.H42 ((-2945.09 1907.58) (-1213.64 654.22))" "[PinPair] <uTiL>cId737<uTiL>.41:<uTiL>cId25<uTiL>.J41 ((-2964.77 1907.58) (-1226.25 682.13))" list(-1226.250000 682.130000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:12" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:50" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "428.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-1270.8 1874.18) (-1215.18 1967.8))" list(-1215.180000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:36" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:41" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "427.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1385.63 1769.42) (-1101.77 2109.98))" "[Shape] Package Geometry/Place_Bound_Top ((-1270.8 1874.18) (-1215.18 1967.8))" list(-1193.690000 1797.770000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:35" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:41" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "287.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "213.95 MIL" "-13.95 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId738<uTiL>.5:<uTiL>cId25<uTiL>.E5 ((-2098.42 -294.29) (-1160.24 1369.46))" "[PinPair] <uTiL>cId738<uTiL>.3:<uTiL>cId25<uTiL>.F6 ((-2118.11 -294.29) (-1181.8 1347.96))" list(-1181.800000 1347.960000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:03" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "402.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-1783.83 3496.4) (-1159.49 4189.31))" list(-1178.350000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:29" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "293.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "299.4 MIL" "-99.40 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.G12:<uTiL>cId3069<uTiL>.18 ((-1204.3 1245.46) (-546.47 3536.56))" "[PinPair] <uTiL>cId25<uTiL>.F11:<uTiL>cId3069<uTiL>.17 ((-1178.3 1260.46) (-625.21 3536.56))" list(-1178.300000 1260.460000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:07" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "348.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "257.87 MIL" "-257.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2098.98 396.07) (-950.16 1584.25))" "[Shape] Package Geometry/Place_Bound_Top ((-1386.13 384.06) (-1177.87 439.18))" list(-1177.870000 396.070000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:34" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "302.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "203.94 MIL" "-3.94 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.F9:<uTiL>cId739<uTiL>.8 ((-1179.12 1306.07) (-480.31 -2048.02))" "[PinPair] <uTiL>cId739<uTiL>.9:<uTiL>cId25<uTiL>.F7 ((-559.05 -2048.02) (-1170.23 1328.32))" list(-1170.230000 1328.320000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:53" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:13" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "264.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "201.78 MIL" "-1.78 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId737<uTiL>.11:<uTiL>cId25<uTiL>.C34 ((-3260.05 1907.58) (-1126.22 810.5))" "[PinPair] <uTiL>cId737<uTiL>.13:<uTiL>cId25<uTiL>.D34 ((-3240.36 1907.58) (-1146.7 814.12))" list(-1146.700000 814.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:12" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:49" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "261.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "246.61 MIL" "-46.61 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.E37:<uTiL>cId737<uTiL>.49 ((-1156.24 754.11) (-2886.03 1907.58))" "[PinPair] <uTiL>cId25<uTiL>.D38:<uTiL>cId737<uTiL>.47 ((-1138.24 745.51) (-2905.72 1907.58))" list(-1138.240000 745.510000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:10" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "288.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "272.72 MIL" "-72.72 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.C3:<uTiL>cId3077<uTiL>.8 ((-1118.61 1417.73) (-1267.81 -2048.02))" "[PinPair] <uTiL>cId25<uTiL>.D4:<uTiL>cId3077<uTiL>.9 ((-1131.53 1402.52) (-1346.55 -2048.02))" list(-1131.530000 1402.520000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "294.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "250.53 MIL" "-50.53 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.B24:<uTiL>cId738<uTiL>.37 ((-1107.14 1011.11) (-1783.46 -294.29))" "[PinPair] <uTiL>cId25<uTiL>.C24:<uTiL>cId738<uTiL>.35 ((-1128.54 1017.41) (-1803.15 -294.29))" list(-1128.540000 1017.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:47" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "262.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "266.37 MIL" "-66.37 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId737<uTiL>.25:<uTiL>cId25<uTiL>.B35 ((-3122.25 1907.58) (-1107.14 796.21))" "[PinPair] <uTiL>cId737<uTiL>.23:<uTiL>cId25<uTiL>.C35 ((-3141.94 1907.58) (-1128.54 789.91))" list(-1128.540000 789.910000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:11" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:48" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "304.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "230.81 MIL" "-30.81 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.D11:<uTiL>cId739<uTiL>.5 ((-1146.7 1252.7) (-244.09 -2048.02))" "[PinPair] <uTiL>cId25<uTiL>.C11:<uTiL>cId739<uTiL>.6 ((-1126.22 1256.32) (-322.83 -2048.02))" list(-1126.220000 1256.320000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:54" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:14" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "290.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "249.7 MIL" "-49.70 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.B9:<uTiL>cId3077<uTiL>.5 ((-1103.84 1296.62) (-1031.59 -2048.02))" "[PinPair] <uTiL>cId25<uTiL>.C9:<uTiL>cId3077<uTiL>.6 ((-1123.55 1296.62) (-1110.33 -2048.02))" list(-1123.550000 1296.620000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:05" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "397.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "112.2 MIL" "-112.20 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-1414.58 2549.63) (-1089.87 3440.37))" "[Shape] Package Geometry/Place_Bound_Top ((-1394.58 2569.63) (-1109.87 3420.37))" list(-1109.870000 2599.330000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:26" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "272.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "256.95 MIL" "-56.95 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.15:<uTiL>cId25<uTiL>.C10 ((-782.69 3536.56) (-1128.54 1276.91))" "[PinPair] <uTiL>cId3069<uTiL>.14:<uTiL>cId25<uTiL>.B10 ((-861.43 3536.56) (-1107.14 1270.61))" list(-1107.140000 1270.610000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:54" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "270.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "305.03 MIL" "-105.03 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.9:<uTiL>cId25<uTiL>.C14 ((-546.47 3662.54) (-1123.55 1210.12))" "[PinPair] <uTiL>cId3069<uTiL>.8:<uTiL>cId25<uTiL>.B14 ((-625.21 3662.54) (-1103.84 1210.12))" list(-1103.840000 1210.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:14" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:53" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "339.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-620.87 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1385.63 1769.42) (-1101.77 2109.98))" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" list(-1101.770000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:44" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:42" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "251.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "216.28 MIL" "-16.28 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId23<uTiL>.13:<uTiL>cId25<uTiL>.A22 ((-2822.83 2802.87) (-1079.14 1056.21))" "[PinPair] <uTiL>cId23<uTiL>.14:<uTiL>cId25<uTiL>.B21 ((-2822.83 2818.62) (-1098.76 1063.82))" list(-1098.760000 1063.820000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:05" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:41" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "317.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "200.98 MIL" "-0.98 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.Y4:<uTiL>cId25<uTiL>.C29 ((716.24 1795.05) (-1118.54 915.31))" "[PinPair] <uTiL>cId5<uTiL>.Y3:<uTiL>cId25<uTiL>.B29 ((680.24 1795.05) (-1098.76 916.5))" list(-1098.760000 916.500000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:16" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:31" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "296.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "223.23 MIL" "-23.23 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId2810<uTiL>.S2:<uTiL>cId25<uTiL>.C38 ((-2422.25 2369.29) (-1118.54 742.31))" "[PinPair] <uTiL>cId2810<uTiL>.S3:<uTiL>cId25<uTiL>.B38 ((-2372.25 2369.29) (-1098.76 743.5))" list(-1098.760000 743.500000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:50" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:09" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "400.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1139.2 3665.64) (-1081.2 3755.64))" "[Shape] Package Geometry/Place_Bound_Top ((-1133.45 3676.0) (-1086.21 3745.22))" list(-1086.210000 3683.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:28" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "322.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "620.87 MIL" "-542.13 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-2756.7 1924.41) (-937.8 2526.77))" "[Shape] Package Geometry/Place_Bound_Top ((-1045.03 1694.1) (-848.18 2087.8))" list(-1045.030000 1924.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:47" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "291.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "261.93 MIL" "-61.93 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.C9:<uTiL>cId3077<uTiL>.6 ((-1123.55 1296.62) (-1110.33 -2048.02))" "[PinPair] <uTiL>cId25<uTiL>.B9:<uTiL>cId3077<uTiL>.5 ((-1103.84 1296.62) (-1031.59 -2048.02))" list(-1031.590000 -2048.020000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:06" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "319.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1078.43 3666.28) (-1020.43 3756.28))" "[Shape] Package Geometry/Place_Bound_Top ((-1072.62 3676.39) (-1025.38 3745.61))" list(-1025.380000 3683.440000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:30" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:32" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "362.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-1022.72 -1868.81) (-987.28 -1833.19))" "[Shape] Package Geometry/Place_Bound_Top ((-1022.81 -1867.82) (-987.19 -1834.18))" list(-1020.840000 -1867.820000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:06" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "373.Pkg to Place Keepout Spacing" "29.61 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-286.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-1325.75 1208.66) (-971.42 1562.99))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-971.420000 1525.590000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:35" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:14" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "371.Pkg to Place Keepout Spacing" "29.61 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-286.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-1325.75 417.33) (-971.42 771.66))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-971.420000 454.730000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:34" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:11" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "324.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "363.78 MIL" "-363.78 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2098.98 396.07) (-950.16 1584.25))" "[Shape] Package Geometry/Place_Bound_Top ((-1177.87 -163.18) (-827.08 439.18))" list(-967.920000 439.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:35" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "368.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "316.14 MIL" "-316.14 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-2098.98 396.07) (-950.16 1584.25))" "[Shape] Package Geometry/Place_Bound_Top ((-2008.81 454.73) (-937.95 1525.59))" list(-959.110000 454.730000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:33" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:09" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "399.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-957.72 -1872.81) (-922.28 -1837.19))" "[Shape] Package Geometry/Place_Bound_Top ((-957.81 -1871.82) (-922.19 -1838.18))" list(-955.840000 -1871.820000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:31" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:27" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "327.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-921.11 -2578.74) (-669.45 -2261.81))" list(-921.110000 -2445.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:48" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:36" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "431.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "318.5 MIL" "-318.50 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-921.11 -2578.74) (-669.45 -2261.81))" "[Shape] Package Geometry/Place_Bound_Top ((-1501.23 -2649.6) (-876.91 -1999.99))" list(-897.730000 -2468.320000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:51" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:43" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "323.Pkg to Pkg Spacing" "63.78 MIL [PACKAGE_HEIGHT_MIN]" "118.11 MIL" "-54.33 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-885.5 202.18) (-601.64 576.38))" "[Shape] Package Geometry/Place_Bound_Top ((-1177.87 -163.18) (-827.08 439.18))" list(-885.500000 439.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:25" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "351.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "236.22 MIL" "-236.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-925.81 -1355.81) (-870.19 -1262.19))" "[Shape] Package Geometry/Place_Bound_Top ((-1040.93 -1526.24) (-757.07 -1143.76))" list(-870.190000 -1262.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:22" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:48" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "320.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-863.72 -1964.43) (-805.72 -1874.43))" "[Shape] Package Geometry/Place_Bound_Top ((-858.34 -1954.04) (-811.1 -1884.82))" list(-858.340000 -1946.990000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:33" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "321.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-849.37 1737.41) (-739.13 2044.49))" "[Shape] Package Geometry/Place_Bound_Top ((-1045.03 1694.1) (-848.18 2087.8))" list(-849.370000 1925.230000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:47" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:33" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "423.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-849.37 1737.41) (-739.13 2044.49))" "[Shape] Package Geometry/Place_Bound_Top ((-886.77 1694.1) (-848.18 1925.23))" list(-849.370000 1925.230000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:33" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:39" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "346.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "316.14 MIL" "-316.14 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-849.37 1737.41) (-739.13 2044.49))" "[Shape] Package Geometry/Place_Bound_Top ((-848.18 1735.04) (-740.31 2046.85))" list(-848.180000 2044.490000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:21" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "344.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "29.53 MIL" "-29.53 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-798.57 -1964.72) (-740.57 -1874.72))" "[Shape] Package Geometry/Place_Bound_Top ((-793.19 -1954.33) (-745.95 -1885.11))" list(-793.190000 -1947.280000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:36" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "267.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "209 MIL" "-9.00 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.5:<uTiL>cId25<uTiL>.K16 ((-861.43 3662.54) (-1260.06 1173.46))" "[PinPair] <uTiL>cId3069<uTiL>.6:<uTiL>cId25<uTiL>.J15 ((-782.69 3662.54) (-1231.2 1182.76))" list(-782.690000 3662.540000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:13" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:51" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "271.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "221.16 MIL" "-21.16 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.14:<uTiL>cId25<uTiL>.B10 ((-861.43 3536.56) (-1107.14 1270.61))" "[PinPair] <uTiL>cId3069<uTiL>.15:<uTiL>cId25<uTiL>.C10 ((-782.69 3536.56) (-1128.54 1276.91))" list(-782.690000 3536.560000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:53" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "345.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-764.18 3272.11) (-728.56 3305.75))" "[Shape] Package Geometry/Place_Bound_Top ((-764.09 3271.12) (-728.65 3306.74))" list(-762.210000 3272.110000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:17" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "490.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-774.81 3191.18) (-739.19 3224.82))" "[Shape] Package Geometry/Place_Bound_Bottom ((-774.44 3190.76) (-739.0 3226.38))" list(-740.880000 3191.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:09" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:18" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "434.Pkg to Pkg Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-251.97 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-849.37 1737.41) (-739.13 2044.49))" "[Shape] Package Geometry/Place_Bound_Top ((-740.31 1851.58) (-661.57 1930.32))" list(-739.130000 1930.320000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:52" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "433.Pkg to Pkg Spacing" "118.11 MIL [PACKAGE_HEIGHT_MIN]" "330.71 MIL" "-212.60 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-849.37 1737.41) (-739.13 2044.49))" "[Shape] Package Geometry/Place_Bound_Top ((-740.31 1836.97) (-663.3 1851.58))" list(-739.130000 1851.580000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:52" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:44" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "474.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-131.14 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-908.75 1676.45) (-679.75 2105.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-703.280000 1882.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:56" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "477.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-131.14 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-908.75 1676.45) (-679.75 2105.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-703.280000 1721.420000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:58" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:12" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "478.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-130.94 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-994.75 1590.45) (-593.75 2191.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-703.280000 1612.280000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:58" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:12" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "479.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-91.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1008.75 1576.45) (-579.75 2205.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-703.280000 1596.700000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:58" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:13" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "394.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-702.96 951.55) (-628.2 990.93))" "[Shape] Package Geometry/Place_Bound_Top ((-717.81 954.19) (-662.19 1047.81))" list(-702.960000 954.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:48" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:25" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "404.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "318.5 MIL" "-318.50 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-921.11 -2578.74) (-669.45 -2261.81))" "[Shape] Package Geometry/Place_Bound_Top ((-713.73 -2649.6) (-89.41 -1999.99))" list(-692.910000 -2313.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:32" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:29" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "405.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-713.73 -2649.6) (-89.41 -1999.99))" list(-692.910000 -2440.310000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:32" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:30" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "403.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-690.89 3274.46) (-655.27 3308.1))" "[Shape] Package Geometry/Place_Bound_Top ((-690.8 3273.47) (-655.36 3309.09))" list(-688.920000 3274.460000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:24" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:29" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "472.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-52.40 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1066.75 1518.45) (-521.75 2263.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-688.500000 2242.100000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:55" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:09" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "476.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-91.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1008.75 1576.45) (-579.75 2205.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-688.500000 2177.570000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:57" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:11" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "475.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-130.94 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-994.75 1590.45) (-593.75 2191.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-688.500000 2161.300000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:57" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:11" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "473.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "131.14 MIL" "-52.40 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((-1066.75 1518.45) (-521.75 2263.45))" "[Shape] Package Geometry/Place_Bound_Bottom ((-703.28 1427.71) (-388.76 2266.29))" list(-688.500000 1539.800000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:56" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "494.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-700.38 3168.46) (-664.76 3202.1))" "[Shape] Package Geometry/Place_Bound_Bottom ((-700.29 3167.47) (-664.85 3203.09))" list(-666.730000 3168.460000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:14" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:20" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "260.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "202.89 MIL" "-2.89 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.12:<uTiL>cId25<uTiL>.K3 ((-743.32 3595.62) (-1258.41 1408.2))" "[PinPair] <uTiL>cId3069<uTiL>.11:<uTiL>cId25<uTiL>.K4 ((-664.58 3595.62) (-1262.03 1387.72))" list(-664.580000 3595.620000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:10" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "269.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "269.77 MIL" "-69.77 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId3069<uTiL>.8:<uTiL>cId25<uTiL>.B14 ((-625.21 3662.54) (-1103.84 1210.12))" "[PinPair] <uTiL>cId3069<uTiL>.9:<uTiL>cId25<uTiL>.C14 ((-546.47 3662.54) (-1123.55 1210.12))" list(-546.470000 3662.540000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:14" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:52" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "301.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "267.89 MIL" "-67.89 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId739<uTiL>.9:<uTiL>cId25<uTiL>.F7 ((-559.05 -2048.02) (-1170.23 1328.32))" "[PinPair] <uTiL>cId25<uTiL>.F9:<uTiL>cId739<uTiL>.8 ((-1179.12 1306.07) (-480.31 -2048.02))" list(-480.310000 -2048.020000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:52" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:12" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "429.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "181.1 MIL" "-181.10 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-504.8 2806.79) (-157.31 3441.21))" "[Shape] Package Geometry/Place_Bound_Top ((-484.8 2826.79) (-177.31 3421.21))" list(-449.360000 2830.500000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:37" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:42" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "367.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((-1016.11 3488.53) (-391.79 4179.87))" list(-418.520000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:31" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:09" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "422.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-447.81 -1866.82) (-412.19 -1833.18))" "[Shape] Package Geometry/Place_Bound_Top ((-447.72 -1867.81) (-412.28 -1832.19))" list(-414.160000 -1833.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:36" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:38" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "408.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "236.22 MIL" "-236.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-497.81 1295.19) (-404.19 1350.81))" "[Shape] Package Geometry/Place_Bound_Top ((-664.28 1164.07) (-281.8 1447.93))" list(-404.190000 1350.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:53" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:31" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "388.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "19.69 MIL" "-19.69 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-377.81 -1866.82) (-342.19 -1833.18))" "[Shape] Package Geometry/Place_Bound_Top ((-377.72 -1867.81) (-342.28 -1832.19))" list(-344.160000 -1833.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:32" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:22" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "383.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "275.59 MIL" "-275.59 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((-596.04 555.37) (-99.07 1157.02))" "[Shape] Package Geometry/Place_Bound_Top ((-261.23 119.24) (2843.5 2794.68))" list(-261.230000 1132.110000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:19" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "390.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-261.23 119.24) (2843.5 2794.68))" "[Shape] Package Geometry/Place_Bound_Top ((-547.35 744.78) (-172.35 1119.78))" list(-261.230000 772.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:37" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:23" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "378.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "324.8 MIL" "-324.80 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-561.64 -1015.19) (-107.64 -561.19))" "[Shape] Package Geometry/Place_Bound_Top ((-138.11 -918.9) (2933.06 113.38))" list(-122.550000 -707.270000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:24" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:17" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "381.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "167.32 MIL" "-167.32 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((22.93 -807.22) (2772.93 167.78))" "[Shape] Package Geometry/Place_Bound_Top ((-137.41 -1391.74) (2933.45 -359.06))" list(77.930000 -359.060000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:40" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:18" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "438.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((112.41 2784.22) (404.15 3150.34))" "[Shape] Package Geometry/Place_Bound_Top ((230.19 2979.19) (285.81 3072.81))" list(177.270000 3128.890000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "448.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((212.63 2629.0) (821.37 3159.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(277.870000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:15" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:51" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "412.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((112.41 2784.22) (404.15 3150.34))" "[Shape] Package Geometry/Place_Bound_Top ((230.19 2860.19) (285.81 2953.81))" list(285.810000 2784.220000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:38" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:33" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "457.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((270.63 2687.0) (763.37 3101.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(365.690000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:19" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:02" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "458.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((284.63 2701.0) (749.37 3087.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(394.380000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:19" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:02" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "382.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "275.59 MIL" "-275.59 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((22.93 -807.22) (2772.93 167.78))" "[Shape] Package Geometry/Place_Bound_Top ((-261.23 119.24) (2843.5 2794.68))" list(581.950000 167.780000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:19" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "328.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "236.22 MIL" "-236.22 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((628.19 -2017.81) (721.81 -1962.19))" "[Shape] Package Geometry/Place_Bound_Top ((508.76 -2131.93) (891.24 -1848.07))" list(628.190000 -2017.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:27" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:37" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "275.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "304.65 MIL" "-104.65 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.B12:<uTiL>cId4741<uTiL>.1 ((1004.24 2443.05) (738.06 4040.02))" "[PinPair] <uTiL>cId5<uTiL>.A12:<uTiL>cId4741<uTiL>.4 ((1004.24 2479.05) (644.38 3988.84))" list(644.380000 3988.840000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:17" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:56" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "413.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((631.13 2783.94) (922.87 3150.06))" "[Shape] Package Geometry/Place_Bound_Top ((752.19 2983.19) (807.81 3076.81))" list(858.010000 3128.610000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:38" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "439.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((631.13 2783.94) (922.87 3150.06))" "[Shape] Package Geometry/Place_Bound_Top ((752.19 2858.19) (807.81 2951.81))" list(858.010000 2805.390000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:38" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "315.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "205.63 MIL" "-5.63 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId25<uTiL>.D7:<uTiL>cId5<uTiL>.K9 ((-1135.89 1341.12) (896.24 2155.05))" "[PinPair] <uTiL>cId25<uTiL>.C6:<uTiL>cId5<uTiL>.J9 ((-1116.8 1348.08) (896.24 2191.05))" list(896.240000 2191.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:30" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "276.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "258.69 MIL" "-58.69 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.A12:<uTiL>cId4741<uTiL>.4 ((1004.24 2479.05) (644.38 3988.84))" "[PinPair] <uTiL>cId5<uTiL>.B12:<uTiL>cId4741<uTiL>.1 ((1004.24 2443.05) (738.06 4040.02))" list(1004.240000 2443.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:17" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:56" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "297.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "207.22 MIL" "-7.22 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.B18:<uTiL>cId4743<uTiL>.1 ((1220.24 2443.05) (1055.5 3694.28))" "[PinPair] <uTiL>cId5<uTiL>.A18:<uTiL>cId4743<uTiL>.3 ((1220.24 2479.05) (1110.61 3694.28))" list(1220.240000 2479.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:50" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "298.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "211.99 MIL" "-11.99 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.E18:<uTiL>cId4743<uTiL>.6 ((1220.24 2335.05) (1181.48 3749.39))" "[PinPair] <uTiL>cId5<uTiL>.D18:<uTiL>cId4743<uTiL>.4 ((1220.24 2371.05) (1126.36 3749.39))" list(1220.240000 2371.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:51" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:10" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "277.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "225.63 MIL" "-25.63 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.D19:<uTiL>cId4743<uTiL>.9 ((1256.24 2371.05) (1268.09 3694.28))" "[PinPair] <uTiL>cId5<uTiL>.C19:<uTiL>cId4743<uTiL>.7 ((1256.24 2407.05) (1212.98 3694.28))" list(1256.240000 2407.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:18" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:57" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "300.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "245.53 MIL" "-45.53 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId5<uTiL>.D20:<uTiL>cId4743<uTiL>.10 ((1292.24 2371.05) (1283.84 3749.39))" "[PinPair] <uTiL>cId5<uTiL>.E20:<uTiL>cId4743<uTiL>.12 ((1292.24 2335.05) (1338.96 3749.39))" list(1292.240000 2335.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:52" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:12" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "255.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "223.03 MIL" "-23.03 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId745<uTiL>.1:<uTiL>cId5<uTiL>.C21 ((1985.82 3744.1) (1328.24 2407.05))" "[PinPair] <uTiL>cId745<uTiL>.3:<uTiL>cId5<uTiL>.D21 ((2044.88 3744.1) (1328.24 2371.05))" list(1328.240000 2371.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:07" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:44" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "257.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "249.48 MIL" "-49.48 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId745<uTiL>.4:<uTiL>cId5<uTiL>.D22 ((2044.88 3862.21) (1364.24 2371.05))" "[PinPair] <uTiL>cId745<uTiL>.6:<uTiL>cId5<uTiL>.E22 ((2103.93 3862.21) (1364.24 2335.05))" list(1364.240000 2335.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:08" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "258.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "226.26 MIL" "-26.26 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId745<uTiL>.12:<uTiL>cId5<uTiL>.D23 ((2222.04 3862.21) (1400.24 2371.05))" "[PinPair] <uTiL>cId745<uTiL>.10:<uTiL>cId5<uTiL>.C23 ((2162.99 3862.21) (1400.24 2407.05))" list(1400.240000 2407.050000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:09" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "331.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1354.13 2783.94) (1645.87 3150.06))" "[Shape] Package Geometry/Place_Bound_Top ((1467.19 2983.19) (1522.81 3076.81))" list(1418.990000 3128.610000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:55" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:38" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "414.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((1354.13 2783.94) (1645.87 3150.06))" "[Shape] Package Geometry/Place_Bound_Top ((1462.19 2853.19) (1517.81 2946.81))" list(1418.990000 2805.390000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:39" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "314.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "250.78 MIL" "-50.78 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId4743<uTiL>.15:<uTiL>cId4740<uTiL>.1 ((1421.64 3694.28) (836.84 3974.41))" "[PinPair] <uTiL>cId4743<uTiL>.17:<uTiL>cId4740<uTiL>.3 ((1476.76 3694.28) (836.84 4025.59))" list(1476.760000 3694.280000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:15" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:30" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "449.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1454.63 2625.0) (2063.37 3155.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1516.450000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:15" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:52" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "459.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1512.63 2683.0) (2005.37 3097.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1601.700000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:20" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:02" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "460.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1526.63 2697.0) (1991.37 3083.0))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1628.490000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:20" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:03" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "450.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1750.0 2584.63) (2280.0 3193.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1773.320000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:16" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:52" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "451.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1808.0 2642.63) (2222.0 3135.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1840.210000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:16" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:56" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "452.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1822.0 2656.63) (2208.0 3121.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1857.620000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:17" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:59" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "506.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" "[Shape] Package Geometry/Place_Bound_Bottom ((1942.19 2534.19) (2035.81 2589.81))" list(1942.190000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:23" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:33" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "491.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" "[Shape] Package Geometry/Place_Bound_Bottom ((1943.19 2484.19) (2036.81 2539.81))" list(1943.190000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:02" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:19" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "507.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((1943.19 2484.19) (2036.81 2539.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((1942.19 2534.19) (2035.81 2589.81))" list(1943.190000 2534.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:24" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "254.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "209.11 MIL" "-9.11 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId745<uTiL>.3:<uTiL>cId5<uTiL>.D21 ((2044.88 3744.1) (1328.24 2371.05))" "[PinPair] <uTiL>cId745<uTiL>.1:<uTiL>cId5<uTiL>.C21 ((1985.82 3744.1) (1328.24 2407.05))" list(1985.820000 3744.100000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:07" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:43" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "453.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((1973.0 2589.63) (2503.0 3198.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(1998.790000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:17" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:59" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Electrical] ALL" "256.Diffpair Max Uncoupled Length" "200 MIL [DIFFP_UNCOUPLED_LENGTH]" "299.92 MIL" "-99.92 MIL" "DRC ERROR CLASS/ALL" "[PinPair] <uTiL>cId745<uTiL>.6:<uTiL>cId5<uTiL>.E22 ((2103.93 3862.21) (1364.24 2335.05))" "[PinPair] <uTiL>cId745<uTiL>.4:<uTiL>cId5<uTiL>.D22 ((2044.88 3862.21) (1364.24 2371.05))" list(2044.880000 3862.210000) nil)@@@list("eric2_tseng" "2019/01/23 17:35:08" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:53:44" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "454.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2031.0 2647.63) (2445.0 3140.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2066.810000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:18" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:00" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "376.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2051.66 3005.56) (2417.78 3297.3))" "[Shape] Package Geometry/Place_Bound_Top ((2120.19 3118.19) (2213.81 3173.81))" list(2073.110000 3070.420000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:16" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "461.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2045.0 2661.63) (2431.0 3126.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2084.720000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:21" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "467.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2141.19 2185.19) (2234.81 2240.81))" "[Shape] Package Geometry/Place_Bound_Bottom ((2141.19 2230.19) (2234.81 2285.81))" list(2141.190000 2230.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:03" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:07" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "455.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2192.5 2603.63) (2722.5 3212.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2226.000000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:18" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:00" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "462.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2250.5 2661.63) (2664.5 3154.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2297.920000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:21" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "466.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" "[Shape] Package Geometry/Place_Bound_Bottom ((2141.19 2230.19) (2234.81 2285.81))" list(2299.340000 2372.840000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:03" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:06" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "489.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" "[Shape] Package Geometry/Place_Bound_Bottom ((2141.19 2185.19) (2234.81 2240.81))" list(2309.330000 2366.180000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:05" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:18" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "463.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2264.5 2675.63) (2650.5 3140.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2317.660000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:22" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:05" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "415.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2051.66 3005.56) (2417.78 3297.3))" "[Shape] Package Geometry/Place_Bound_Top ((2250.19 3118.19) (2343.81 3173.81))" list(2396.330000 3070.420000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:23" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:35" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "456.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-47.24 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2415.5 2613.63) (2945.5 3222.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2455.290000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:19" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:01" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "375.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "374.02 MIL" "-374.02 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2404.62 -2002.53) (2460.24 -1908.91))" "[Shape] Package Geometry/Place_Bound_Top ((2237.06 -2138.89) (2528.8 -1847.15))" list(2460.240000 -1908.910000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:52" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:15" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "464.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-86.62 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2473.5 2671.63) (2887.5 3164.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2530.850000 2719.880000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:22" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:05" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "465.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "125.98 MIL" "-125.78 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2487.5 2685.63) (2873.5 3150.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((-254.93 798.22) (2623.42 2719.88))" list(2592.750000 2697.150000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:23" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:06" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "481.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-119.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((1680.4 3552.1) (2665.26 4252.54))" list(2651.900000 3697.720000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:05" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:14" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "469.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-80.64 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((1666.4 3538.1) (2679.26 4266.54))" list(2667.150000 3698.750000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:09" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "380.Pkg to Place Keepout Spacing" "0 MIL [NONE]" "324.8 MIL" "-324.80 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepout/Top ((22.93 -807.22) (2772.93 167.78))" "[Shape] Package Geometry/Place_Bound_Top ((-138.11 -918.9) (2933.06 113.38))" list(2683.060000 -752.220000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:25" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:18" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "497.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-1.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2630.9 4241.94) (2790.9 4401.94))" "[Shape] Package Keepout/Bottom ((2542.19 3552.22) (3233.31 4254.61))" list(2688.320000 4245.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:00" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:22" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "508.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "148.08 MIL" "-148.08 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((2630.9 4241.94) (2790.9 4401.94))" list(2710.900000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:01" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:34" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "396.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "148.08 MIL" "-148.08 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2630.9 4241.94) (2790.9 4401.94))" list(2710.900000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:26" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:26" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "492.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "328.46 MIL" "-328.46 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((2794.01 -2739.45) (2954.01 -2579.45))" list(2715.900000 -2282.830000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:07" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:19" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "352.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "328.46 MIL" "-328.46 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2794.01 -2739.45) (2954.01 -2579.45))" list(2715.900000 -2282.830000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:49" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "486.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((1608.4 3480.1) (2737.26 4324.54))" list(2726.160000 3692.990000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:59" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:16" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "416.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2711.69 3714.56) (3063.81 4192.91))" list(2742.080000 4093.860000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:49" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:35" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "501.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2635.0 2603.63) (3165.0 3212.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2810.090000 2612.090000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:11" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:24" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "502.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-80.64 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2693.0 2661.63) (3107.0 3154.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2824.710000 2668.230000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:12" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:25" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "445.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((2628.19 3638.22) (3147.31 4168.61))" list(2824.840000 3642.230000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:24" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:50" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "503.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-119.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2707.0 2675.63) (3093.0 3140.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2830.510000 2681.160000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:12" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:25" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "495.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-119.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2765.12 -2195.5) (3219.12 -1741.5))" "[Shape] Package Keepout/Bottom ((2456.1 -2292.76) (2845.1 -1699.04))" list(2841.020000 -2137.910000) nil)@@@list("eric2_tseng" "2019/01/23 17:38:59" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:21" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "356.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-261.23 119.24) (2843.5 2794.68))" "[Shape] Package Geometry/Place_Bound_Top ((2838.5 2398.35) (3213.46 2773.31))" list(2843.500000 2542.820000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:45" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:03" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "354.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-261.23 119.24) (2843.5 2794.68))" "[Shape] Package Geometry/Place_Bound_Top ((2838.48 744.79) (3213.48 1119.79))" list(2843.500000 889.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:49" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:53" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "488.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-80.64 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2765.12 -2195.5) (3219.12 -1741.5))" "[Shape] Package Keepout/Bottom ((2442.1 -2306.76) (2859.1 -1685.04))" list(2853.090000 -2147.940000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:09" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:17" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "343.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2874.19 3057.19) (2929.81 3150.81))" "[Shape] Package Geometry/Place_Bound_Top ((2871.12 3102.99) (3012.88 3275.01))" list(2874.190000 3150.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:45" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "496.Pkg to Place Keepout Spacing" "0.2 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-119.80 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((2542.19 3552.22) (3233.31 4254.61))" list(2887.110000 3552.220000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:00" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:21" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "437.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2890.19 3035.5) (2913.81 3086.5))" "[Shape] Package Geometry/Place_Bound_Top ((2874.19 3057.19) (2929.81 3150.81))" list(2890.190000 3057.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:35" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:46" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "482.Pkg to Place Keepout Spacing" "39.36 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-80.64 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((2528.19 3538.22) (3247.31 4268.61))" list(2891.880000 3538.260000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:10" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:14" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "379.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "324.8 MIL" "-324.80 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((-137.41 -1391.74) (2933.45 -359.06))" "[Shape] Package Geometry/Place_Bound_Top ((-138.11 -918.9) (2933.06 113.38))" list(2900.240000 -918.900000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:25" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:17" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "471.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2447.8 3244.88) (2901.8 3698.88))" "[Shape] Package Keepout/Bottom ((2470.19 3480.22) (3305.31 4326.61))" list(2901.630000 3480.580000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:02" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:09" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "470.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2765.12 -2195.5) (3219.12 -1741.5))" "[Shape] Package Keepout/Bottom ((2384.1 -2364.76) (2917.1 -1627.04))" list(2904.870000 -2178.060000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:14" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:08" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "444.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.48 714.79) (3243.48 1149.79))" "[Shape] Package Keepout/Bottom ((2595.59 118.86) (3125.59 747.28))" list(2926.200000 739.030000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:08" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:49" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "500.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2415.5 2613.63) (2945.5 3222.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2935.580000 2783.630000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:11" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:24" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "499.Pkg to Place Keepout Spacing" "78.74 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-41.26 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2792.8 1796.63) (3322.8 2405.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2949.520000 2382.230000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:10" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:23" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "342.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "39.37 MIL" "-39.37 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2954.2 3057.19) (3009.8 3150.81))" "[Shape] Package Geometry/Place_Bound_Top ((2871.12 3102.99) (3012.88 3275.01))" list(2954.200000 3150.810000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:29" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:44" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "409.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2970.19 3035.5) (2993.81 3086.5))" "[Shape] Package Geometry/Place_Bound_Top ((2954.2 3057.19) (3009.8 3150.81))" list(2970.190000 3057.190000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:53" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:32" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "377.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2856.26 1622.12) (3148.0 1988.24))" "[Shape] Package Geometry/Place_Bound_Top ((2975.32 1826.37) (3030.94 1919.99))" list(2975.320000 1988.240000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:28" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:16" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "504.Pkg to Place Keepout Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "120 MIL" "-120.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepout/Bottom ((2793.0 2761.63) (3007.0 3054.37))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(2996.060000 2801.240000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:13" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:26" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "330.Pkg to Pkg Spacing" "0 MIL [PACKAGE_HEIGHT_MIN]" "2 MIL" "-2.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Geometry/Place_Bound_Top ((2856.26 1622.12) (3148.0 1988.24))" "[Shape] Package Geometry/Place_Bound_Top ((2975.19 1695.19) (3030.81 1788.81))" list(3030.810000 1622.120000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:24" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:38" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "357.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2838.5 2398.35) (3213.46 2773.31))" list(3148.970000 2444.330000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:45" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:04" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "505.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.5 2368.35) (3243.46 2803.31))" list(3148.970000 2406.470000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:13" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:26" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "418.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2949.53 1992.73) (3166.07 2209.27))" list(3148.970000 2042.600000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:55" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:36" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "355.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2838.48 744.79) (3213.48 1119.79))" list(3148.970000 790.760000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:50" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:03" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "447.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((2808.48 714.79) (3243.48 1149.79))" list(3148.970000 752.900000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:06" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:51" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "325.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2991.92 -77.76) (3180.9 313.98))" list(3148.970000 -77.760000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:39" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:35" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "349.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2984.24 -510.83) (3173.22 -119.09))" list(3148.970000 -510.830000) nil)@@@list("eric2_tseng" "2019/01/23 17:36:38" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:54:47" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] BOTTOM" "468.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_BOTTOM" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Bottom ((2765.12 -2195.5) (3219.12 -1741.5))" list(3148.970000 -1804.410000) nil)@@@list("eric2_tseng" "2019/01/23 17:39:02" nil "P143000044-PC" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:56:07" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | list("[Package] TOP" "417.Pkg to Place Keepin Spacing" "0 MIL [NONE]" "0 MIL" "0.00 MIL" "DRC ERROR CLASS/PACKAGE_TOP" "[Shape] Package Keepin/All ((-3463.94 -2609.6) (3148.97 4093.86))" "[Shape] Package Geometry/Place_Bound_Top ((2795.12 -2165.5) (3189.12 -1771.5))" list(3148.970000 -2087.690000) nil)@@@list("eric2_tseng" "2019/01/23 17:37:36" nil "p143000044-pc" "5s-ipcfl-cg.a00r")@@@list("doris_chen" "2019/01/24 12:55:36" nil "p16c000356-pc" "5s-ipcfl-cg.a00r-chk") | FIGURE | SIZE | 10.0 | 12.0 | 18.0 | 28.0 | 29.0 | 31.0 | 33.0 | 34.0 | 36.0 | 37.0 | 38.0 | 39.0 | 41.0 | 43.0 | 46.0 | 47.0 | 91.0 | 45.0 | 49.0 | 63.0 | 69.0 | 73.0 | 150.0 | 157.0 | 160.0 | 169.0 | 177.0 | 181.0 | 42.0x18.0 | 44.0x18.0 | 44.0x20.0 | 46.0x20.0 | 48.0x22.0 | 50.0x26.0 | 67.0x24.0 | 67.0x30.0 | 83.0x35.0 | 87.0x24.0 | 87.0x39.0 | 110.0x31.0 | 118.0x28.0 | 135.0x98.0 | 197.0x98.0 | DRILL CHART: TOP to BOTTOM (1 to 6) | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | ROTATION | - | 90.000 | 0.000 | QTY | 4972 | 176 | 545 | 82 | 19 | 18 | 10 | 6 | 8 | 4 | 1 | 14 | 2 | 3 | 5 | 9 | 5981 | TOTAL HOLES:
