# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WT_CLK_DP: length 77.9
  TOP w0.127: U1.BB6 41.45,101.66 41.45,101.95 v1(41.58,102.07)
  IN2 w0.127: v1(41.58,102.07) 41.31,102.34 41.18,102.34 40.66,101.82 40.44,101.82 37.52,98.9 36.71,98.9 35.3,97.5 35.3,92.02 35.75,91.57 35.75,89.44 35.45,89.14 35.45,88.32 34.71,87.58 34.71,85.98 33.34,84.61 33.34,83.09 33.78,82.65 33.78,82.41 33.78,82.39 33.78,82.26 34.2,81.84 34.2,77.17 33.83,76.8 33.83,75.66 34.38,75.11 34.38,73.92 32.98,72.52 32.98,71.46 33.75,70.69 36.21,70.69 36.73,70.17 36.73,68.68 37.31,68.09 37.31,65.35 37.55,65.11 37.55,63.78 39.85,61.48 41.76,61.48 42.45,60.79 42.45,60.37 42.33,60.24 v1(42.11,60.24)
  BOTTOM w0.127: 57.28,62.73 57.28,62.12 57.17,62.02 R3124.2 ; 57.28,62.73 v2(57.55,62.73) ; 57.28,62.73 57.28,63.11 56.77,63.62 56.77,63.98 56.16,64.58 53.58,64.58 52.74,65.42 51.46,65.42 47.37,61.33 46.79,61.33 46.61,61.51 46.61,62.33 46.33,62.6 45.46,62.6 45.19,62.33 45.19,61.3 44.43,60.54 43.07,60.54 42.77,60.24 42.49,60.24 v1(42.11,60.24)
CNV_WT_R_0_DN: length 11.9
  TOP w0.127: J218.65 50.7,57.67 52.04,56.33 55.26,56.33 v1(55.68,56.74)
  BOTTOM w0.127: 55.26,57.66 54.61,58.31 54.61,59.72 R3121.1 ; 55.26,57.66 55.52,57.4 55.52,56.89 v1(55.68,56.74) ; 55.26,57.66 v2(55.45,57.85)
CNV_WT_R_0_DP: length 12
  TOP w0.127: J218.67 51.2,59.01 50.95,58.77 50.95,57.77 52.14,56.58 54.86,56.58 v1(55.04,56.76)
  BOTTOM w0.127: 54.35,58.94 54.35,59.43 54.23,59.55 53.95,59.55 53.85,59.45 53.65,59.45 53.52,59.58 53.52,59.87 53.65,60 R3122.1 ; 54.35,58.94 54.35,58.21 55.27,57.29 55.27,56.99 v1(55.04,56.76) ; 54.35,58.94 v2(54.09,58.94)
CNV_WT_R_1_DN: length 7
  TOP w0.127: v1(49.17,58.58) 49.38,58.79 49.38,58.96 49.2,59.13 J218.59
  BOTTOM w0.127: 48.65,57.64 v2(48.46,57.83) ; 48.65,57.64 48.29,57.28 45.39,57.28 R3119.1 ; 48.65,57.64 48.98,57.97 48.98,58.15 48.74,58.38 48.74,58.57 48.87,58.69 49.05,58.69 v1(49.17,58.58)
CNV_WT_R_1_DP: length 7.1
  TOP w0.127: J218.61 49.7,58.49 v1(49.78,58.41)
  BOTTOM w0.127: 46.38,57.02 45.66,57.02 R3120.1 ; 46.38,57.02 48.39,57.02 v1(49.78,58.41) ; 46.38,57.02 v2(46.38,56.76)
CNV_WT_R_CLK_DN: length 10.9
  TOP w0.127: v1(56.24,57.12) 56.24,57.39 56.08,57.55 55.85,57.55 55.55,57.24 53.16,57.24 52.2,58.2 J218.71
  BOTTOM w0.127: 56.56,59.98 56.56,60.51 R3123.1 ; 56.56,59.98 56.56,58.51 56.03,57.97 56.03,57.65 56.24,57.44 v1(56.24,57.12) ; 56.56,59.98 v2(56.3,59.98)
CNV_WT_R_CLK_DP: length 11
  TOP w0.127: J218.73 52.7,58.94 52.45,58.69 52.45,58.31 53.27,57.5 55.44,57.5 55.75,57.8 56.18,57.8 56.43,57.56 56.74,57.56 56.79,57.61 v1(56.79,57.63)
  BOTTOM w0.127: R3124.1 56.82,60.45 56.82,58.41 ; 56.82,58.41 56.28,57.87 56.28,57.75 56.59,57.44 56.68,57.44 56.79,57.56 v1(56.79,57.63) ; 56.82,58.41 v2(57.1,58.41)
CNV_WT_RCOMP: length 10.8
  TOP w0.102: R99516.1 34.19,108.33 35.44,108.33 35.69,108.09 35.69,107.88 37.32,106.24 38.17,106.24 38.25,106.16 39.81,106.16 40.19,105.78 41.38,105.78 42.14,105.03 42.14,104.44 U1.BA1
CNVI_DET: length 58.1
  TOP w0.102: J218.19 39.2,58.91 40.03,58.08 40.03,57.91 v1(40.24,57.7)
  IN1 w0.102: v1(79.35,59.73) 77.42,57.8 77.42,56.52 76.98,56.09 75.83,56.09 v1(75.63,56.28)
  BOTTOM w0.102: v1(40.24,57.7) 40.04,57.9 R3107.1 40.04,60.03 41.87,61.86 43.79,61.86 45.12,63.2 48.54,63.2 51.31,65.97 53.5,65.97 53.82,65.65 63.12,65.65 63.33,65.86 67.9,65.86 72.84,60.92 76.45,60.92 77.37,60.01 v2(78.43,60.01) 79.07,60.01 v1(79.35,59.73) ; v1(75.63,56.28) 74.73,56.28 74.34,56.67 SR7966.1
COM_1: length 26.6
  TOP w0.102: PQ93012.1 47.68,144.27 46.29,142.89 44.78,142.89 v1(44.04,143.63)
  IN1 w0.102: v1(41.43,148.05) 40.61,148.86 34.38,148.86 v1(34.15,148.63)
  BOTTOM w0.102: v1(44.04,143.63) 43.31,144.36 43.31,145.49 43.06,145.73 43.06,146.58 42.95,146.7 42.95,147.45 41.57,148.83 41.12,148.83 40.8,148.52 ; v1(34.15,148.63) 33.89,148.37 PD8.1 ; PU93003.1 41.69,146.76 41.83,146.9 41.83,147.64 v1(41.43,148.05) 41.18,148.05 PR93061.2 40.8,148.52 ; 40.8,148.52 40.8,149.91 v2(41.3,150.41)
COM_2: length 25.5
  IN2 w0.102: v1(43.55,141.2) 43.21,141.2 40.05,138.04 39.45,138.04 38.92,137.51 v1(38.62,137.51)
  BOTTOM w0.102: v1(43.55,141.2) 43.55,142.55 42.9,143.2 42.9,145.32 42.44,145.78 PR93055.2 41.79,146.08 41.21,145.49 PU93003.2 ; PR93046.2 PC6307.1 31.63,139.4 31.76,139.52 PR93163.2 PR93162.2 33.07,139.13 32.75,138.81 32.75,138.06 v2(33.03,137.77) 34.05,137.77 34.47,138.19 35.86,138.19 37.39,136.67 38.15,136.67 38.62,137.14 v1(38.62,137.51)
COM_3: length 6.5
  BOTTOM w0.102: PR93038.2 42.7,139.78 PC6305.1 v2(42.7,142.57) 42.7,143.28 42.44,143.53 PC6306.1 41.81,144.22 41.81,144.22 PU93003.3
COM_5: length 14.2
  BOTTOM w0.102: PU93003.5 34.26,142.94 34.09,142.76 34.09,142.48 34.24,142.33 35.7,142.33 PC6308.1 37.2,141.23 37.32,141.35 PC6302.1 38.57,141.35 38.66,141.26 PC6303.1 39.9,141.26 40.45,140.72 40.45,139.97 PR93039.2 40.85,139.53 39.44,138.12 38.35,138.12 37.72,137.48 v2(37.72,137.18)
COM_6: length 18
  BOTTOM w0.102: v2(31.38,138.32) 30.66,138.32 29.09,139.89 PR93052.2 29.36,140.77 29.36,140.95 29.5,141.09 PR93051.2 30.17,141.38 30.17,141.87 30.45,142.15 31.77,142.15 32.74,141.19 33.34,141.19 PR93164.2 PR93165.2 35.26,140.9 35.54,140.9 PC6304.1 35.86,141.59 35.38,142.08 34.14,142.08 33.81,142.41 33.81,143.83 34.19,144.21 PU93003.6
COM_7: length 14.3
  BOTTOM w0.102: PC941502.1 33.77,145.48 PU93003.7 ; PC941502.1 PR93054.2 31.9,145.42 31.33,145.42 31.04,145.13 31.04,143.47 30.85,143.28 28.81,143.28 28,144.09 PQ93010.1 ; PC941502.1 33.37,146.4 33.19,146.57 PD8.2 31.98,148.29 v2(31.98,149.8)
CONFIG_0: length 15.9
  TOP w0.089: v1(56.59,83.44) 56.27,83.12 U1.M45
  IN2 w0.102: v1(56.59,83.44) 56.44,83.29 56.44,82.64 56.69,82.39 57.2,82.39 57.63,82.82 59.33,82.82 59.98,83.46 60.3,83.46 61.06,82.7 61.06,80.47 62.37,79.16 63.27,79.16 63.35,79.24 v1(64.22,79.24)
  BOTTOM w0.102: v1(64.22,79.24) 64.58,78.88 64.58,78.65 SR7849.2 65.14,77.7 v2(65.66,77.18)
CONFIG_1: length 82.5
  TOP w0.102: U1.AC48 50.57,81.11 50.57,79.29 49.71,78.43 v1(49.71,76.8) ; SR7802.1 19.4,119.4 v1(19.4,119.71)
  IN1 w0.102: v1(49.71,76.8) 47.7,76.8 46.99,76.09 46.99,75.71 46.41,75.14 44.87,75.14 43.83,76.18 40.36,76.18 40.04,75.86 37.93,75.86 36.89,74.82 36.19,74.82 35.43,75.58 32.04,75.58 31.52,75.06 30.9,75.06 30.16,75.8 28.83,75.8 27.67,76.96 24.9,76.96 21.95,79.9 21.95,86.29 21.44,86.81 21.44,88.07 21.07,88.44 21.07,90.03 19.44,91.65 19.44,93.47 18.81,94.11 18.81,98.28 18.58,98.51 18.58,99.66 18.45,99.78 18.45,101.24 18.53,101.32 18.53,107.41 16.96,108.99 16.96,112.89 17.75,113.68 17.75,115.21 18.47,115.92 18.47,116.22 18.88,116.63 18.88,117.75 18.88,117.75 18.88,118.74 19.4,119.27 v1(19.4,119.71)
  BOTTOM w0.102: v2(19.38,120.94) 19.11,120.68 19.11,120 v1(19.4,119.71)
CONFIG_3: length 98.3
  TOP w0.102: SR416.1 29.06,66.75 29.06,68.34 28.83,68.57 26.64,68.57 26.05,69.16 26.05,69.91 26.43,70.29 26.43,70.3 27.16,70.3 27.16,70.3 28.71,70.3 29.27,70.86 29.27,71.27 29.26,71.29 29.26,72.71 30.27,73.72 30.27,74.18 31.24,75.15 v1(31.24,75.48) ; v1(49.32,84.98) 49.32,84.98 U1.AE41
  IN1 w0.102: v1(19.15,100.7) 19.14,100.7 18.65,100.21 18.65,99.87 18.78,99.74 18.78,98.6 19.09,98.29 19.09,95.03 19.65,94.47 19.65,91.73 21.27,90.11 21.27,88.52 21.64,88.15 21.64,86.89 22.16,86.37 22.16,79.99 24.98,77.16 27.75,77.16 28.92,76 30.72,76 v1(31.24,75.48) 31.42,75.48 31.72,75.78 35.51,75.78 36.18,75.12 36.91,75.12 37.85,76.06 39.96,76.06 40.48,76.58 44.66,76.58 45,76.93 45.27,76.93 45.58,77.24 45.58,78.71 47.73,80.86 47.73,83.83 48.32,84.42 48.86,84.42 49.32,84.87 v1(49.32,84.98)
  BOTTOM w0.102: v1(19.15,100.7) 18.32,101.53 16.81,101.53 16.55,101.78 13.7,101.78 13.03,101.11 12.65,101.11 12.28,101.48 12.28,103.14 12.84,103.7 12.84,104.05 12.57,104.32 12.25,104.32 11.05,105.52 11.05,105.78 9.6,107.22 9.6,109.16 8.99,109.78 7.42,109.78 7.31,109.88 7.31,110.99 v2(6.87,111.43) 6.53,111.78 6.53,112.59 6.63,112.69 APR117.2
CORE_PWM1_BOOT:
  vias: v2(116.48,146.98)
CORE_PWM1_BOOT_R_C:
  vias: v2(118.64,145.38)
CORE_PWM1_EN: length 1
  BOTTOM w0.254: v2(114.7,147.36) 114.92,147.58 PR90005.2
CORE_PWM1_HG_D: length 14.7
  TOP w0.635: PR90001.1 123.59,155.97 123.1,155.97 121.4,154.27 118.87,154.27 v2(116.36,151.75) 116.36,149.83 117.18,149.01 117.35,149.01 118.14,148.22 v3(118.14,147.59)
CORE_PWM1_HG_D_R: length 3.4
  TOP w0.254: PC90006.1 v2(128.67,155.44)
  TOP w0.635: PR90001.2 127.66,156.45 128.12,156
CORE_PWM1_LG_D: length 14.6
  IN1 w0.635: v3(119.35,151.42) 120.45,151.42 121.16,150.71 121.16,148.94 122.5,147.59 127.4,147.59 129.01,149.19 129.89,149.19 130.4,148.68 v3(130.48,148.68)
  vias: v2(118.49,150.97)
CORE_PWM1_LG_D_R: length 1.2
  TOP w0.508: v2(131.16,150.89) 130.72,150.45 PC90010.1
CORE_PWM1_SW_D: length 9.6
  TOP w0.635: v3(119.35,150.1) 120.12,150.1 121.56,151.55 v2(121.56,152.31) 121.56,152.82 123.55,154.8 126.3,154.8
CORE_PWM1_SW_S:
  vias: v2(123.62,147.61) v3(124.79,146.34)
CORE_PWM1_VCC:
  vias: v2(114.86,150.18)
CORE_PWM2_BOOT:
  vias: v2(100.3,146.24)
CORE_PWM2_BOOT_R_C:
  vias: v2(103.12,147.11)
CORE_PWM2_EN: length 4.6
  BOTTOM w0.203: PR90013.2 99.16,149.84 98.86,150.14 98.86,152.68 v2(98.97,152.8)
  BOTTOM w0.279: PR90013.2 99.87,149.84 100.07,150.04 PU90002.3
CORE_PWM2_HG_D: length 16.7
  TOP w0.635: v3(112.39,152.88) 112.39,153.64 112.11,153.91 PR90011.1
  IN2 w0.635: v3(103.17,148.66) 104.18,149.66 104.18,152.46 105.77,154.06 111.22,154.06 v3(112.39,152.88)
  BOTTOM w0.508: v3(112.39,152.88) 112.71,152.88 v2(113.66,151.93)
CORE_PWM2_HG_D_R: length 1.9
  TOP w0.254: PR90011.2 113.04,155 v2(113.66,155)
CORE_PWM2_LG_D: length 20.9
  TOP w0.635: v3(112.29,151.62) 112.29,151.62 112.33,151.62 113.51,150.43 v2(113.51,150.33) 113.51,149.24 112.98,148.71 PR90015.1
  IN2 w0.635: v3(112.29,151.62) 112.84,151.62 113.61,152.39 113.61,153.46 111.87,155.2 105.3,155.2 102.97,152.87 v3(102.97,151.07)
CORE_PWM2_LG_D_R: length 4.1
  TOP w0.254: v2(114.1,147.67) 113.54,147.11 111.61,147.11 111.25,147.46 PR90015.2
CORE_PWM2_SW_D: length 8.3
  BOTTOM w0.635: v3(107.94,156.42) 106.6,155.08 106.35,155.08 v2(105.48,154.22) 104.34,153.08 104.34,150.1 104.09,149.85
CORE_PWM2_SW_S:
  vias: v1(108.28,147.39) v1(108.94,147.39) v2(108.89,146.12)
CORE_PWM2_VCC: length 1.7
  BOTTOM w0.508: 101.67,152.01 102.11,152.45 v2(102.11,153.48)
CORE_PWM3_BOOT:
  vias: v2(86.21,140.15)
CORE_PWM3_BOOT_R_C: length 1.2
  TOP w0.508: v2(86.31,147.11) 86.53,146.89 PC941588.2
CORE_PWM3_EN: length 3.8
  TOP w0.254: PU93004.3 88.35,140.28 88.07,140.01 PR93071.2 88.07,139.27 88.33,139.02 v1(88.63,139.02)
  BOTTOM w0.254: v1(88.63,139.02) 88.26,139.39 v2(87.53,139.39)
CORE_PWM3_HG_D: length 25.5
  IN2 w0.635: v3(101.5,155.08) 99.96,153.55 98.59,153.55 98.08,154.06 96.94,154.06 96.34,153.46 95.02,153.46 94.42,154.06 92.67,154.06 90.55,151.94 90.55,147.87 v3(87.12,144.44)
  BOTTOM w0.508: v3(101.5,155.08) 100.86,155.08 100,155.95 PR93070.1 ; v2(87.12,145.56) v3(87.12,144.44)
CORE_PWM3_HG_D_R:
  vias: v2(97.43,154.42) v3(97.48,155.29)
CORE_PWM3_LG_D: length 12.9
  TOP w0.635: PR93067.1 98.17,147.31 v3(98.07,147.41)
  IN2 w0.635: v3(98.07,147.41) 98.07,147.79 97.09,148.77 93.23,148.77 90.4,145.94 v3(90.4,144.9)
  BOTTOM w0.508: v2(97.71,148.22) 97.71,147.77 v3(98.07,147.41)
CORE_PWM3_LG_D_R: length 1.1
  TOP w0.254: PR93099.1 100.37,150.19 v2(100.71,149.85)
CORE_PWM3_SW_D: length 20
  TOP w0.279: 88.11,144.19 88.11,143.73 87.85,143.46 PU93004.7
  TOP w0.635: v3(87.03,149.06) v2(87.71,148.38) 87.87,148.23 PC941588.1 87.87,145.83 88.11,145.58 88.11,144.19
  IN2 w0.635: v3(87.03,149.06) 88.44,149.06 89.41,150.03 89.41,152.41 92.19,155.2 94.91,155.2 94.95,155.16 v3(96.26,155.16)
CORE_PWM3_SW_S:
  vias: v1(94.77,147.67) v1(96.59,147.41) v2(95.1,146.01)
CORE_PWM3_VCC:
  vias: v2(89.13,139.69)
CPU_CFG0: length 55
  TOP w0.102: v1(83.29,120.01) 83.73,119.57 83.73,118.65 82.73,117.64 79.14,117.64 HR364.2 ; XU1.H15 116.8,123.41 v1(116.8,123.4)
  IN1 w0.102: v1(91.21,118.77) 86.9,118.77 85.29,120.39 83.67,120.39 v1(83.29,120.01)
  IN2 w0.102: v1(91.21,118.77) 91.46,119.03 91.46,121.28 91.46,121.45 92.38,122.37 93.79,122.37 94.28,122.85 98.8,122.85 100.45,124.5 104.78,124.5 105.56,123.72 110.42,123.72 110.88,124.17 110.88,124.51 111.12,124.76 115.07,124.76 115.45,124.37 115.45,124.17 115.7,123.92 116.28,123.92 v1(116.8,123.4)
  BOTTOM w0.102: XDP1.9 79.33,119.46 79.44,119.36 80.85,119.36 HR36.1 81.66,119.8 81.71,119.75 v2(82.14,119.75) 82.14,120.46 AR41.2 82.76,120.46 82.85,120.46 v1(83.29,120.01)
CPU_CFG1: length 59.6
  TOP w0.102: XU1.F15 116.83,125.27 v1(116.77,125.27)
  IN1 w0.102: v1(116.77,125.27) 116.34,125.71 116.34,126.27 116.04,126.57 115.76,126.57 115.41,126.92 115.41,127.16 115.1,127.47 114.05,127.47 111.76,129.75 110.1,129.75 109.2,128.86 109.2,128.65 108.84,128.29 104.12,128.29 103.61,127.78 101.78,127.78 100.43,126.43 97.97,126.43 96.45,124.92 95.71,124.92 91.74,120.95 88.86,120.95 88.17,121.63 87.93,121.63 v1(87.25,122.32)
  BOTTOM w0.102: v2(69.49,123.46) 69.84,123.11 73.33,123.11 76.6,119.84 76.6,119.09 76.73,118.96 XDP1.11 79.3,118.96 79.49,119.15 80.87,119.15 HR37.1 81.63,118.39 84.47,118.39 87.25,121.16 v1(87.25,122.32)
CPU_CFG2: length 57.3
  TOP w0.102: v2(82.59,120.09) 82.92,120.43 83.47,120.43 84.14,119.76 84.14,118.34 v1(83.74,117.95) ; XU1.F16 118.63,125.23 v1(118.63,125.23)
  IN1 w0.102: v1(88.54,122.65) 88.54,122.42 89.4,121.56 91.13,121.56 92.44,122.86 92.44,123.99 94.3,125.85 95.03,125.85 96.73,127.55 99.52,127.55 102.29,130.33 108.84,130.33 109.39,130.88 112.52,130.88 113.31,130.08 115.9,130.08 117.62,128.36 117.62,127.47 118.46,126.64 118.73,126.64 119.05,126.32 119.05,125.65 v1(118.63,125.23)
  BOTTOM w0.102: XDP1.15 79.51,117.96 79.65,117.82 HR38.1 80.8,117.82 80.9,117.72 80.9,117.5 81.06,117.34 83.13,117.34 v1(83.74,117.95) 84.32,117.95 88.54,122.17 v1(88.54,122.65)
CPU_CFG3: length 78.2
  TOP w0.102: XU1.H16 117.7,123.4 v1(117.69,123.4) ; v1(98.67,123.31) 99.1,123.75 99.1,125.31 97.6,126.82 96.79,126.82 96.48,126.51 94.79,126.51 92.68,128.62 89.28,128.62 88.95,128.29 86.31,128.29 v1(85.93,127.9)
  IN2 w0.102: v1(87.78,120.56) 88.95,121.73 91.46,121.73 92.29,122.57 93.71,122.57 94.19,123.05 98.41,123.05 v1(98.67,123.31) 100.16,124.81 105.03,124.81 105.91,123.92 109.65,123.92 109.99,124.26 109.99,124.47 110.3,124.78 110.67,124.78 111.53,125.65 115.15,125.65 116.29,124.51 116.29,124.26 116.72,123.82 117.27,123.82 v1(117.69,123.4)
  BOTTOM w0.102: XDP1.17 80.09,117.46 80.31,117.25 80.75,117.25 80.87,117.13 80.87,116.93 80.97,116.83 HR39.1 83.49,116.83 87.22,120.56 v1(87.78,120.56) ; v1(85.93,127.9) 85.16,127.9 84,126.74 81.25,126.74 80.61,126.09 HR385.2 79.38,124.45 78.59,125.24 75.87,125.24 PT264.1
CPU_CFG3_R: length 7.3
  BOTTOM w0.102: v2(82.29,124.17) 82.02,124.45 HR385.1 HR346.2 81.44,122.7 81.58,122.56 81.58,122.19 81.37,121.97 81.12,121.97 80.42,121.27 79.96,121.27 79.77,121.46 XDP1.1
CPU_CFG4: length 62.1
  TOP w0.102: v1(89.74,125.01) 89.51,125.01 88.9,125.62 85.95,125.62 85.7,125.36 v2(85.7,125.06) ; v1(121.37,126.14) 121.35,126.14 121.06,125.84 121,125.79 XU1.F19
  IN1 w0.102: v1(121.37,126.14) 121.37,126.61 120.25,127.73 120.25,129.15 116.59,132.81 106.78,132.81 106.21,132.23 100.89,132.23 98.09,129.43 94.85,129.43 90.43,125.01 v1(89.74,125.01)
  BOTTOM w0.102: v1(89.74,125.01) 89.74,123.35 88.95,122.56 88.95,121.14 87.47,119.66 86.9,119.66 82.25,115.01 81.71,115.01 HR40.1 80.87,115.01 79.57,115.01 79.52,114.96 XDP1.27
CPU_CFG5: length 69.5
  TOP w0.102: v1(120.46,123.4) 119.99,123.87 XU1.H18 ; v2(83.97,127.29) 85.91,127.29 86.62,128 88.45,128 88.94,127.51 v1(89.84,127.51)
  IN2 w0.102: v1(89.37,122.18) 89.37,123.26 89.11,123.51 89.11,126.54 89.84,127.26 v1(89.84,127.51) 91.43,127.51 92.43,126.51 95.49,126.51 97.92,128.94 98.19,128.94 99.85,130.6 105.97,130.6 106.45,130.11 110.98,130.11 111.65,129.45 116.82,129.45 117.83,128.43 118.81,128.43 119.05,128.19 119.05,127.92 119.49,127.47 120.63,127.47 121.82,126.29 121.82,125.1 122.11,124.81 122.42,124.81 122.71,124.51 122.71,124.17 122.42,123.87 120.93,123.87 v1(120.46,123.4)
  BOTTOM w0.102: v1(89.37,122.18) 89.37,121.27 87.56,119.46 86.98,119.46 81.91,114.39 HR41.1 80.87,114.81 80.1,114.81 79.75,114.46 XDP1.29
CPU_CFG6: length 67.5
  TOP w0.102: v2(86.51,127.2) 87.12,127.8 88.37,127.8 89.08,127.09 90.45,127.09 v1(90.68,126.86) ; v1(123.18,125.23) 122.86,124.9 XU1.G21
  IN1 w0.102: v1(90.68,126.86) 91.42,126.86 94.6,130.04 97.79,130.04 100.59,132.84 105.9,132.84 106.47,133.42 117.82,133.42 121,130.23 121,128.91 122.75,127.16 122.75,126.89 123.06,126.58 123.33,126.58 123.6,126.31 123.6,125.91 123.18,125.49 v1(123.18,125.23)
  BOTTOM w0.102: v1(90.68,126.86) 90.18,126.37 90.18,123.5 89.79,123.11 89.79,121.4 87.64,119.26 87.06,119.26 81.64,113.83 81.64,113.81 HR42.1 80.86,113.03 80.15,113.03 79.72,113.46 XDP1.33
CPU_CFG7: length 62.4
  TOP w0.102: v1(122.29,124.34) 122.29,124.33 XU1.H20 ; v2(80.67,112.23) 81.13,112.23 v1(81.81,112.91)
  IN2 w0.102: v1(122.29,124.34) 120.91,125.72 120.29,125.72 120.04,125.96 120.04,126.18 119.59,126.63 119.37,126.63 119.13,126.88 119.13,127.16 118.81,127.48 118.5,127.48 116.73,129.24 111.56,129.24 110.9,129.91 106.24,129.91 105.75,130.39 99.94,130.39 98.28,128.73 98,128.73 95.57,126.3 92.35,126.3 91.37,127.28 90.5,127.28 89.9,126.69 89.56,126.69 89.32,126.44 89.32,124.21 90.24,123.28 v1(90.24,122.38)
  BOTTOM w0.102: v1(90.24,122.38) 90.24,121.57 87.72,119.05 87.15,119.05 81.86,113.77 81.86,112.97 v1(81.81,112.91) 81.31,112.41 HR43.1 80.87,112.83 80.05,112.83 79.82,113.06 79.39,113.06 79.29,112.96 XDP1.35
CPU_CFG8: length 75.2
  TOP w0.102: v1(117.69,124.34) 117.72,124.34 XU1.G16 ; HR44.1 73.52,118.8 v2(74.33,119.61) 75.37,118.56 v1(76.01,118.56)
  IN1 w0.102: v1(76.01,118.56) 76.63,119.18 76.63,120.55 77.49,121.42 77.49,123.28 80.46,126.25 85.7,126.25 85.71,126.24 88.86,126.24 89.3,126.69 90.09,126.69 90.33,126.44 91.29,126.44 94.68,129.84 97.92,129.84 100.72,132.64 105.98,132.64 106.56,133.21 117.74,133.21 120.66,130.29 120.66,128.38 122.72,126.33 122.72,125.98 122.47,125.73 122.2,125.73 121.87,125.4 121.87,124.24 121.47,123.84 121.22,123.84 120.88,123.5 120.88,123.23 120.63,122.98 118.48,122.98 118.16,123.3 118.16,123.87 v1(117.69,124.34)
  BOTTOM w0.102: v1(76.01,118.56) 75.64,118.56 74.73,119.46 XDP1.10
CPU_CFG9: length 60
  TOP w0.102: HR45.1 74.15,117.83 74.22,117.9 v2(74.65,117.9) 75.21,117.34 AR43.1 75.93,117.74 v1(75.93,117.93) ; XU1.E16 118.63,126.14 v1(118.63,126.14)
  IN1 w0.102: v1(89.74,126.27) 89.28,125.81 87.62,125.81 87.13,125.32 82.51,125.32 81.85,125.99 81.41,125.99 77.72,122.3 77.72,121.36 76.83,120.47 76.83,118.79 75.97,117.93 v1(75.93,117.93)
  IN2 w0.102: v1(89.74,126.27) 89.9,126.1 95.66,126.1 98.08,128.53 98.36,128.53 100.02,130.19 105.67,130.19 106.15,129.71 110.81,129.71 111.48,129.04 116.65,129.04 117.92,127.77 117.92,126.85 v1(118.63,126.14)
  BOTTOM w0.102: XDP1.12 74.47,118.96 75.51,117.93 v1(75.93,117.93)
CPU_CFG10: length 75.3
  TOP w0.102: HR46.1 73.77,117.15 74.47,117.15 74.99,116.63 75.91,116.63 76.63,115.91 v2(76.63,115.48) 76.63,114.98 76.26,114.61 v1(76.26,113.38) ; XU1.F17 v1(119.55,125.23)
  IN1 w0.102: v1(119.55,125.23) 119.13,124.81 118.46,124.81 118.21,125.05 118.21,126.6 117.42,127.39 117.42,128.27 115.81,129.88 113.18,129.88 112.4,130.67 109.47,130.67 108.93,130.12 102.38,130.12 99.6,127.35 96.82,127.35 95.09,125.62 94.36,125.62 92.64,123.9 92.64,122.78 91.22,121.35 89.09,121.35 87.28,123.17 84.29,123.17 83.96,122.84 83.25,122.84 82.46,123.62 81.19,123.62 79.58,122.02 79.58,120.87 78.62,119.92 78.62,117.88 77.15,116.4 77.15,114.27 v1(76.26,113.38)
  BOTTOM w0.102: v1(76.26,113.38) 76.47,113.59 76.47,116.23 74.73,117.96 XDP1.16
CPU_CFG11: length 70.2
  TOP w0.102: v1(75.74,116.21) 74.84,116.21 74.65,116.4 v2(74.34,116.4) 73.93,115.99 HR47.1 ; XU1.H17 v1(118.63,123.42)
  IN1 w0.102: v1(75.74,116.21) 75.74,116.84 77.3,118.4 77.3,120.35 78.18,121.22 78.18,122.18 80.88,124.88 87.27,124.88 87.76,125.38 88.76,125.38 89.55,124.59 90.3,124.59 94.94,129.23 98.17,129.23 100.97,132.03 106.29,132.03 106.86,132.6 116.51,132.6 119.98,129.13 119.98,127.6 120.9,126.68 120.9,124.16 120.56,123.82 119.03,123.82 v1(118.63,123.42)
  BOTTOM w0.102: XDP1.18 74.48,117.46 v1(75.74,116.21)
CPU_CFG12: length 74.3
  TOP w0.102: v1(75.61,113.36) 75.24,112.98 74.36,112.98 v2(72.82,111.45) 72.31,111.95 72.31,112.46 HR48.1 ; XU1.G20 121.82,125.09 121.96,125.22 v1(122.29,125.22)
  IN1 w0.102: v1(75.61,113.36) 76.95,114.69 76.95,116.49 78.42,117.96 78.42,120 79.31,120.89 79.31,122.03 81.1,123.82 82.55,123.82 83.33,123.04 83.87,123.04 84.2,123.37 87.41,123.37 87.86,123.81 88.33,123.81 89.81,122.33 89.81,122.22 90.28,121.76 91.05,121.76 92.24,122.95 92.24,124.12 v1(95.05,126.93)
  IN2 w0.102: v1(122.29,125.22) 122.72,125.66 122.72,126.33 122.47,126.57 121.87,126.57 119.91,128.53 119.38,128.53 119.27,128.64 117.92,128.64 116.9,129.65 111.73,129.65 111.06,130.32 106.53,130.32 106.05,130.8 99.77,130.8 98.11,129.14 96.61,129.14 95.05,127.57 v1(95.05,126.93)
  BOTTOM w0.102: v1(75.61,113.36) 75.61,113.36 75.61,113.78 74.43,114.96 XDP1.28
CPU_CFG13: length 67.5
  TOP w0.102: XU1.F20 121.36,125.24 v1(120.47,125.24) ; HR49.1 72.5,113.2 v2(72.77,113.2) 74.78,113.2 v1(74.98,113.4)
  IN1 w0.102: v1(90.87,122.18) 90.66,122.39 90.66,122.56 90.42,122.8 89.63,122.8 88.39,124.04 81.03,124.04 79.11,122.12 79.11,120.97 78.22,120.08 78.22,118.05 76.74,116.57 76.74,114.84 75.68,113.77 75.35,113.77 v1(74.98,113.4)
  IN2 w0.102: v1(90.87,122.18) 91.15,122.18 94.44,125.47 95.6,125.47 98.14,128.01 103.91,128.01 104.3,127.62 105.99,127.62 106.5,127.12 114.47,127.12 114.82,127.47 116.04,127.47 116.33,127.18 116.33,126.93 116.65,126.61 116.92,126.61 117.24,126.29 117.24,126 118.43,124.81 118.75,124.81 119.05,124.51 119.05,124.24 119.37,123.92 119.72,123.92 119.99,124.19 119.99,124.75 v1(120.47,125.24)
  BOTTOM w0.102: v1(74.98,113.4) 73.92,114.46 XDP1.30
CPU_CFG14: length 71.8
  TOP w0.102: HR54.1 72.31,111.55 72.31,111.25 72.62,110.95 73.11,110.95 74.03,111.86 v2(74.5,111.86) 74.65,112.02 v1(74.65,112.56) ; XU1.F21 122.4,126.03 122.4,126.05 v1(122.3,126.15)
  IN1 w0.102: v1(122.3,126.15) 120.46,127.99 120.46,130.21 117.65,133.01 106.7,133.01 106.12,132.44 100.8,132.44 98,129.63 94.77,129.63 90.72,125.58 87.68,125.58 87.18,125.08 80.8,125.08 77.93,122.21 77.93,121.27 77.1,120.45 77.1,118.49 75.32,116.71 75.32,114.4 74.56,113.63 74.56,112.65 v1(74.65,112.56)
  BOTTOM w0.102: XDP1.34 73.75,113.46 v1(74.65,112.56)
CPU_CFG15: length 75.2
  TOP w0.102: v2(76.99,113.76) 76.99,113.38 76.55,112.94 75.69,112.94 v1(75.31,112.56) 75.06,112.31 75.06,111.72 74.7,111.37 73.91,111.37 73.2,110.66 72.28,110.66 HR55.1 ; XU1.H19 v1(120.46,124.31)
  IN1 w0.102: v1(75.31,112.56) 75.69,112.94 76.42,112.94 77.35,113.88 77.35,116.32 78.83,117.79 78.83,119.82 79.79,120.78 79.79,121.93 81.27,123.42 82.34,123.42 83.12,122.63 84.14,122.63 84.47,122.96 87.19,122.96 89.01,121.15 91.46,121.15 93.6,123.3 93.6,124.57 94.42,125.39 95.15,125.39 96.9,127.14 99.68,127.14 102.37,129.83 108.93,129.83 109.56,130.46 112.31,130.46 113.1,129.68 115.73,129.68 117.22,128.19 117.22,125.76 118.11,124.87 118.11,124.27 118.46,123.92 118.81,123.92 119.13,124.24 119.13,124.51 119.37,124.76 120.02,124.76 v1(120.46,124.31)
  BOTTOM w0.102: XDP1.36 73.61,112.96 74.43,112.14 74.89,112.14 v1(75.31,112.56)
CPU_DDR_VTT_CNTL: length 51.4
  TOP w0.102: XU1.AC36 139.19,109.77 140.64,109.77 140.99,110.13 140.99,110.31 142.43,111.75 143.99,111.75 144.32,112.08 148.93,112.08 155.29,105.73 155.29,86.01 152.68,83.4 152.68,79.09 v2(151.88,78.29) 152.42,77.74 153,77.74 HR4.1
CPU_FAN_CTL: length 15.1
  TOP w0.089: 54.33,79.31 54.64,79.63 54.64,80.27 54.41,80.5 54.41,80.77 54.34,80.84 U1.T48
  TOP w0.102: 54.33,79.31 54.33,79.11 54.99,78.45 55.79,78.45 56.51,77.73 59.04,77.73 59.84,78.53 62.58,78.53 63.61,79.56 63.61,80.29 v1(64.04,80.72)
  BOTTOM w0.102: v1(64.04,80.72) 64.61,80.72 ST31.1
CPU_FAN_CTRL_SIO: length 289.5
  TOP w0.127: FR2.2 167.76,77.82 FR1.2 166.31,79.26 163.17,79.26 162.63,78.73 v1(160.7,78.73) ; v1(17.57,94.56) 18.16,93.97 18.16,92.98 19.02,92.12 19.02,90.87 19.58,90.31 19.58,89.47 18.77,88.66 18.75,88.66 17.47,87.38 16.12,87.38 16,87.5 10.77,87.5 7.68,84.41 7.68,77.14 8.99,75.83 8.99,73.24 8.41,72.66 7.17,72.66 6.25,71.74 6.25,71.52 v1(5.61,70.88)
  IN1 w0.127: v1(160.7,78.73) 160.02,78.04 160.02,74.73 161.8,72.95 161.8,57.06 160.3,55.57 160.3,51.27 148.77,39.74 142.59,39.74 141.81,38.96 120.99,38.96 119.61,37.58 103.29,37.58 103.06,37.35 100.74,37.35 100.48,37.61 96.06,37.61 91.92,33.47 v1(91.92,32.63) ; v1(5.61,70.88) 6.22,70.27 6.22,66.46 7.8,64.89 7.8,61.05 7.22,60.48 7.22,58.56 5.76,57.11 5.76,55.41 6.32,54.85 6.32,52.24 14.66,43.91 17.73,43.91 22.57,39.07 25.73,39.07 26.17,38.64 33.66,38.64 34.03,39.02 34.2,39.02 34.21,39.02 37,39.02 38.29,37.72 44.18,37.72 45.31,38.85 47.7,38.85 49.27,40.43 54.63,40.43 56.23,42.03 61.19,42.03 62.58,43.42 65.89,43.42 66.27,43.04 66.27,42.37 64.49,40.59 64.49,37.15 64.74,36.9 64.74,36.3 v1(64.62,36.17)
  BOTTOM w0.127: v1(91.92,32.63) 92.3,32.25 92.3,31.23 91.67,30.6 91.67,28.76 90.07,27.17 88.9,27.17 87.91,26.18 v2(82.15,26.18) 81.61,25.64 75.66,25.64 75.37,25.94 75.37,29.85 71.35,33.87 68.02,33.87 65.72,36.17 v1(64.62,36.17) ; v1(17.57,94.56) 16.71,93.7 U104.47
CPU_FAN_TACH_SIO: length 306
  TOP w0.127: v1(157.17,37.3) 156.91,37.56 129.82,37.56 128.66,36.4 118.04,36.4 116.94,37.51 112.98,37.51 110.47,40.02 99.59,40.02 v1(96.52,36.95) ; v1(20.44,89.42) 20.44,89.34 19.58,88.48 19.58,87.95 18.53,86.9 18.53,80.65 14.73,76.85 11.83,76.85 9.88,74.89 9.88,73.49 11.24,72.13 11.24,71.7 10.7,71.17 10.7,69.9 10.82,69.79 10.82,67.39 v1(10.33,66.9)
  IN1 w0.127: v1(10.33,66.9) 8.57,65.13 8.57,59.08 6.37,56.89 6.37,55.68 8.96,53.09 8.96,51.56 8.58,51.19 8.58,50.43 14.8,44.21 17.78,44.21 21.13,40.86 25.69,40.86 26.4,40.15 27.2,39.35 33.36,39.35 33.74,39.73 37.29,39.73 38.59,38.43 43.89,38.43 45.02,39.56 47.34,39.56 48.92,41.14 52.83,41.14 54.2,42.51 60.55,42.51 63.88,45.84 64.36,45.84 64.57,45.63 66.24,45.63 66.88,46.27 66.88,49.02 67.38,49.52 68.05,49.52 68.22,49.7 68.22,58.23 68.9,58.91 v1(68.9,59.25) ; v1(96.52,36.95) 93.19,33.62 93.19,32.25 92.64,31.7 92.64,28.19 v1(90.81,26.35) ; v1(74.09,54.09) 74.17,54.02 74.17,45.23 69.49,40.55 69.49,29.28 72.62,26.15 73.02,26.15 v1(73.46,26.58)
  IN2 w0.127: v1(73.46,26.58) 73.53,26.66 90.5,26.66 v1(90.81,26.35)
  BOTTOM w0.127: U104.37 20.71,90.32 20.44,90.06 v1(20.44,89.42) ; FD1.2 FD1.1 160.73,66.05 R62.1 160.72,66.04 160.25,65.57 160.25,63.44 161.36,62.32 161.36,52.42 158.51,49.57 158.51,45.23 157.43,44.15 157.43,37.55 v1(157.17,37.3) ; v1(74.09,54.09) 74.52,54.09 v2(76.08,55.65) 76.08,56.86 74.76,58.18 69.96,58.18 v1(68.9,59.25)
CPU_TRST#: length 12.2
  TOP w0.089: 45.21,106.03 45.84,105.41 45.84,104.65 45.72,104.54 45.72,103.82 45.77,103.77 45.77,103.49 45.88,103.31 45.95,103.16 45.99,103.03 U1.AM4
  TOP w0.102: 45.21,106.03 45.12,106.12 45.12,106.63 44.61,107.14 44.6,107.14 44.42,107.33 43.37,107.33 43.16,107.53 42.77,107.53 42.52,107.77 42.35,107.77 42.11,108.02 42.11,109.6 41.9,109.81 41.9,110.11 41.39,110.62 41.39,110.9 v2(41.3,110.99) 41.02,111.27 HR366.1
CPU_VCCIO_PWR_GATEB: length 61
  TOP w0.102: U1.AY3 42.49,102.63 v1(42.52,102.61) ; R99518.1 52.83,138.92 52.83,138.62 53.69,137.76 53.69,135.95 54.03,135.61 v1(54.44,135.61)
  IN2 w0.102: v1(54.44,135.61) 55.23,136.4 59.21,136.4 v1(59.62,135.98)
  BOTTOM w0.102: v1(42.52,102.61) 42.47,102.66 42.47,105.2 41.34,106.32 40.9,106.32 40.45,106.77 40.45,107.55 40.74,107.84 40.74,108.66 SR75.1 40.74,109.53 40.74,111.57 43.37,114.21 43.37,114.52 46.24,117.39 50.62,117.39 52.04,118.81 53.64,118.81 53.77,118.94 55.11,118.94 56.23,120.06 57.52,120.06 61.24,123.77 61.24,125.4 61.76,125.92 61.76,132.92 v2(61.14,133.54) 60.74,133.94 60.74,135.41 60.17,135.98 v1(59.62,135.98)
CPU_VIDALERT#_L500MIL: length 17.3
  TOP w0.127: XU1.E39 141.83,125.26 142.62,125.26 143.02,125.66 v1(143.34,125.66)
  BOTTOM w0.127: v1(143.34,125.66) 137.36,119.68 137.36,118.86 137.69,118.53 137.69,117.54 137.45,117.3 137.45,116.6 136.79,115.94 v2(136.47,115.94) 135.33,115.94 HR23.2
CPU_XDP_BPM0: length 49
  TOP w0.127: v1(90.75,123.38) 90.25,122.88 90.13,122.88 89.8,122.55 89.8,121.26 82.94,114.4 HR426.1 81,113.48 v2(81,113.46) ; XU1.D16 v1(118.63,127.06)
  IN1 w0.127: v1(90.75,123.38) 91.4,123.38 91.82,123.8 91.82,124.32 95.47,127.97 99.34,127.97 102.14,130.76 106.92,130.76 107.47,131.31 114.35,131.31 114.9,130.76 115.82,130.76 118.17,128.4 118.17,127.52 v1(118.63,127.06)
CPU_XDP_BPM0_R: length 7.9
  TOP w0.127: HR426.2 80.21,115.27 v2(80.21,115.99) 80.31,116.09 v1(81.99,116.09)
  BOTTOM w0.127: v1(81.99,116.09) 81.69,116.4 79.6,116.4 79.54,116.46 XDP1.21
CPU_XDP_BPM1: length 53.2
  TOP w0.102: v1(119.55,128.01) 119.55,127.99 119.4,127.84 119.23,127.67 XU1.D17
  TOP w0.127: HR427.1 81.52,114.87 82.7,114.87 85.2,117.37 85.2,117.9 ; v1(90.98,124.22) 90.24,123.48 90.07,123.48 86.92,120.34 86.92,119.61 85.2,117.9 ; v2(84.07,121.2) 84.07,120.42 84.56,119.93 84.56,118.54 85.2,117.9
  IN1 w0.127: v1(119.55,128.01) 119.55,128.28 116.9,130.93 116.9,131.07 115.78,132.18 107.07,132.18 106.5,131.61 101.15,131.61 98.34,128.81 95.12,128.81 90.98,124.67 v1(90.98,124.22)
CPU_XDP_BPM1_R: length 8.5
  TOP w0.127: v2(81,117.03) 81.79,117.03 v1(82.73,116.09) 82.73,115.74 82.31,115.32 HR427.2
  BOTTOM w0.127: XDP1.23 81.49,115.96 81.8,115.66 82.29,115.66 v1(82.73,116.09)
CPU_XDP_HOOK1: length 6.1
  TOP w0.127: HR379.2 78.47,113.97 78.47,113.79 HR96.1 78.44,112.94 78.44,112.84 HCB6.2 77.58,111.98 v2(77.21,111.98) 76.62,111.98 v1(76.47,111.83)
  BOTTOM w0.127: v1(76.47,111.83) 76.84,111.46 XDP1.41
CPU_XDP_HOOK2: length 28.6
  TOP w0.102: HR364.1 79.01,115.73 HR365.2 79.01,115.09 79.21,114.89 79.85,114.89 80.52,114.22 80.52,113.58 80.5,113.57 80.5,113.26 80.79,112.97 81.25,112.97 81.62,113.33 81.98,113.33 83.44,111.88 v1(83.44,111.62)
  BOTTOM w0.102: v2(84.36,101.32) 84.94,101.89 84.94,110.12 v1(83.44,111.62) 83.44,110.45 81.25,108.27 80.44,108.27 80.03,108.68 80.03,109.68 79.25,110.46 XDP1.45
CPU_XDP_HOOK3: length 12.5
  BOTTOM w0.127: SR774.2 81.06,105.34 81.86,106.14 82.22,106.14 82.5,106.41 82.5,106.82 81.33,107.99 80.31,107.99 79.73,108.57 79.73,109.46 79.23,109.96 XDP1.47 ; SR774.2 HCB5.2 ; SR774.2 HR381.1 81.43,103.93 81.46,103.9 HR98.1 81.85,103.1 v2(81.94,103.01)
CPU_XDP_HOOK6: length 38.9
  IN1 w0.127: v1(74.19,110.91) 74.22,110.94 74.22,112.08 74.14,112.16 74.14,113.81 74.9,114.57 74.9,117.28 75.5,117.88 75.5,120.66 76.55,121.7 76.55,123.22 80.34,127.02 86.7,127.02 88.01,128.33 88.01,128.79 v1(88.03,128.82)
  BOTTOM w0.127: v2(85.79,123.28) 86.01,123.06 HR378.2 HR377.1 86.61,124 SR773.2 87.84,124.6 87.84,124.58 88.1,124.32 88.45,124.32 88.87,124.74 88.87,127.77 88.03,128.6 v1(88.03,128.82) ; v1(74.19,110.91) 73.74,110.46 XDP1.46
CPU_XDP_HOOK7: length 7.6
  TOP w0.127: HR380.1 HR399.2 HCB3.2 73.48,109.86 73.74,110.12 v2(74.42,110.12) 74.88,110.58 v1(74.88,110.91)
  BOTTOM w0.127: v1(74.88,110.91) 73.93,109.96 XDP1.48
CPUFAN_PWM_CON: length 3.8
  TOP w0.127: P70.4 FCB1.1 166.42,76.19 FR2.1
CPUFAN_TACH_C: length 9.4
  BOTTOM w0.127: P70.1 163.35,70.64 FCB2.1 160.09,70.01 160.08,69.99 FD1.3
CPUPWRGD: length 88.4
  TOP w0.127: v1(48.31,111.9) 47.76,111.9 47.67,111.81 SC85.1 48.06,111.33 48.14,111.41 48.61,111.41 SR275.2 ; v1(85.62,131.95) 85.75,132.09 86.46,132.09 86.71,132.34 86.71,132.71 86.64,132.78 86.64,133.04 HR24.2
  IN1 w0.127: v1(88.9,128.99) 88.9,129.13 87.67,130.35 87.21,130.35 v1(85.62,131.95)
  IN2 w0.127: v1(48.31,111.9) 48.64,112.23 48.64,115.43 51.03,117.82 51.79,117.82 52.47,118.51 55.07,118.51 56.11,117.46 58.97,117.46 63.23,121.72 66.53,121.72 67.71,122.9 69.62,122.9 69.8,122.72 70.77,122.72 71.25,122.24 73.05,122.24 73.58,122.77 74.3,122.77 74.83,122.24 77.21,122.24 78.19,121.26 80.1,121.26 80.24,121.12 81.48,121.12 82.27,121.91 82.27,122.16 82.75,122.65 83.3,122.65 84.85,124.19 84.85,126.26 85.04,126.45 85.04,129.41 86.04,130.42 86.04,131.52 v1(85.62,131.95)
  BOTTOM w0.127: HR392.1 82.32,112.52 82.32,113.63 87.32,118.63 87.94,118.63 91.44,122.13 91.44,127.04 89.48,128.99 v1(88.9,128.99) ; v2(48.81,112.41) v1(48.31,111.9)
CPUPWRGD_R: length 33.2
  TOP w0.102: XU1.F8 110.39,125.24 v1(110.39,125.23)
  TOP w0.127: HR24.1 87.76,133.17 88.22,133.63 v1(91.26,133.63) 97.62,133.63 98.07,133.18 98.07,133.16 98.07,132.81 98.07,132.09 100.89,129.27 100.89,127.6 v1(101.84,126.65)
  IN2 w0.127: v1(101.84,126.65) 102.82,125.67 105.33,125.67 106.21,124.79 109.71,124.79 110.15,125.23 v1(110.39,125.23)
  BOTTOM w0.127: v2(88.95,136.46) 89.03,136.46 91.27,134.23 91.27,133.64 v1(91.26,133.63)
CPVEE: length 3
  TOP w0.203: U6.34 19.29,18.63 20,17.92 v2(20.32,17.92)
  TOP w0.254: AC24.1 21.03,17.24 20.34,17.92 v2(20.32,17.92)
D3_1: length 5.1
  TOP w0.102: v2(22.02,149.27) 22.53,149.27 23.29,148.5 D3.1 22.62,147.62 SR817.2 21.78,147.72 21.7,147.72 SR818.1
D3_2: length 4.4
  TOP w0.508: D3.2 25.32,148.34 v1(25.32,148.5) 25.12,148.71 25.12,149.42 25.56,149.86 R70.2 25.91,150.1 25.75,150.26 25.75,150.49 D525.1
D9_D9.5_ID: length 25.8
  TOP w0.102: U1.AV46 43.61,82.75 43.71,82.86 v1(43.71,82.86)
  IN2 w0.102: v1(43.71,82.86) 43.71,81.4 44.98,80.13 45.32,80.13 45.94,80.75 46.66,80.75 47.14,80.27 47.14,79.29 48.46,77.97 49.94,77.97 50.87,77.04 50.87,76.98 51.08,76.77 v1(51.97,76.77)
  BOTTOM w0.102: R38.1 60.42,71.94 59.61,71.94 SR57.1 58.93,71.78 58.93,72.35 v2(59.16,72.58) 59.16,73.15 58.4,73.9 58.29,73.9 57.73,74.46 55.52,74.46 55,74.98 54.2,74.98 53.25,75.94 53.11,75.94 52.27,76.77 v1(51.97,76.77)
D521_2: length 4.4
  BOTTOM w0.254: v2(105.13,40.66) 105.42,40.36 R99532.2
  BOTTOM w0.457: 107.37,38.92 106.74,39.55 R99531.2 R99532.2
  BOTTOM w0.508: 107.37,38.92 D521.2
DC_DET: length 8.4
  TOP w0.127: v1(19.52,25.78) 18.89,25.15 U6.4 ; v1(22.43,28.67) 22.43,29.02 22.75,29.35 AR40.1
  IN1 w0.127: v1(19.52,25.78) 19.52,27.49 20.35,28.32 22.07,28.32 v1(22.43,28.67)
  BOTTOM w0.127: v1(19.52,25.78) 18.98,25.78 v2(18.68,26.08)
DC_IN_ID_ADAP: length 189.4
  TOP w0.254: v1(156.34,102.12) 158.45,100.01 158.45,72.81 161.25,70 161.25,57.55 164.61,54.19 164.61,46.07 162.38,43.84 162.38,39.85 160.46,37.93 128.21,37.93 v1(127.75,37.46) ; PR8.2 159.5,160.66 159.33,160.49 158.34,160.49 158.19,160.64 154.84,160.64 v1(154.48,161)
  IN2 w0.254: v1(127.75,37.46) 124.78,40.43 118.13,40.43 v1(117.83,40.12) ; v1(156.34,102.12) 153.06,105.4 153.06,125.25 154.25,126.44 154.25,127.69 154.49,127.94 154.49,150.8 152.7,152.59 152.7,156.9 154.48,158.68 v1(154.48,161)
  BOTTOM w0.254: v1(117.83,40.12) 115.24,42.71 v2(114.35,42.71) C94.1 112.26,43.09 L93006.1
DCPRTC: length 9.3
  TOP w0.102: U1.BF47 39.21,81.74 U1.BG47 38.64,81.17 38.64,80.37 38.43,80.16 38.43,79.82 36.45,77.84 35.05,77.84 34.62,77.41 34.62,75.59 SCB27.1
DDR_VTT_CNTL: length 72.2
  TOP w0.254: HQ1.3 154.41,74.27 154.76,74.61 HR1.2 156.1,73.98 160.52,69.55 160.52,50.79 163.13,48.18 163.13,45.59 161.67,44.13 161.67,40.15 160.16,38.64 145.52,38.64 143.6,40.56 v1(139.48,40.56)
  BOTTOM w0.102: v2(139.1,41.3) 139.1,40.94 v1(139.48,40.56)
  BOTTOM w0.254: v1(139.48,40.56) 139.73,40.32 139.73,37.97 137.78,36.02 PR128.1
DDR_VTT_CNTL_R: length 6.3
  TOP w0.254: HQ2.1 154.37,81.34 154.66,81.62 155.02,81.62 v1(155.27,81.37) 155.22,81.37 154.53,80.68 154.53,79.06 154.33,78.85 HR4.2
  BOTTOM w0.102: v2(154.48,81.37) v1(155.27,81.37)
DDRA_VREF_CA_R: length 4.2
  BOTTOM w0.305: D4C34.1 114.06,60.57 PR93064.1 114.58,61.13 114.58,61.13 v2(115.04,61.13) 115.3,61.13 115.69,61.53 D4R9.1 D4R8.2
DDRA_VREF_CA_R_W10S12: length 41.6
  TOP w0.305: XU1.AB40 142.75,110.15 143.46,110.86 148.54,110.86 150.14,109.26 150.14,107.2 153.33,104.01 153.33,87.59 150.59,84.85 HC1.1 150.59,80.93 v2(149.87,80.21) 149.62,79.96 HR5.1
DDRA_VREF_CA_W10S12: length 64.1
  TOP w0.305: HR5.2 146.96,79.96 146.04,80.88 126.68,80.88 120.67,74.88 120.67,63.48 120.25,63.06 120.25,60.29 119.16,59.2 v1(113.61,59.2) ; DIMM2.164 115.12,63.73 114.08,64.78 v1(113.23,64.78)
  BOTTOM w0.305: v2(113.51,65.52) 113.51,65.27 113.23,64.98 v1(113.23,64.78) 113.23,64.78 113.23,64.78 113.24,64.78 113.5,64.78 D4C23.2 114.1,64.18 114.1,63.6 D4C11.1 D4C10.1 113.22,61.61 PR93064.2 113.22,60.25 113.61,59.86 v1(113.61,59.2)
DDRB_VREF_CA_R: length 3.8
  BOTTOM w0.305: PR93065.1 119.57,48.47 119.8,48.7 D4R19.2 D4C33.1 D4R20.1 v2(119.25,46.75)
DDRB_VREF_CA_R_W10S12: length 44.9
  TOP w0.305: v1(149.41,108.84) 148.22,110.02 143.76,110.02 143.43,109.69 142.09,109.69 141.63,109.24 XU1.AC39 ; v2(148.99,77.62) HR6.1 HC2.1 149.81,78.93 151.41,80.53 151.41,84.27 154.14,87 154.14,104.59 v1(150.73,108)
  IN1 w0.305: v1(149.41,108.84) 149.89,108.84 v1(150.73,108)
DDRB_VREF_CA_W10S12: length 63.5
  TOP w0.305: v1(115.24,50.46) 115.13,50.36 DIMM1.164 ; v1(118.96,53.54) 120.25,53.54 121.07,54.35 121.07,62.72 121.49,63.14 121.49,74.54 127.02,80.07 145.7,80.07 147.03,78.74 HR6.2
  BOTTOM w0.305: PR93065.2 D4C25.1 ; D4C25.1 118.21,50.49 118.21,50.49 118.21,52.78 v1(118.96,53.54) 118.96,53.95 v2(118.69,54.22) ; D4C25.1 D4C22.1 D4C24.2 115.98,49.66 D4C21.1 115.19,50.41 v1(115.24,50.46)
DEBUG_CLK: length 68.1
  TOP w0.127: v1(6.32,121.1) P12.12
  IN1 w0.127: v1(6.32,121.1) 6.83,121.61 6.83,122.71 7.24,123.12 7.24,124.02 6.97,124.28 6.97,124.78 8.09,125.9 15.34,125.9 15.82,126.38 16.57,126.38 17.78,125.17 17.78,123.77 19.86,121.68 20.53,121.68 21.69,120.52 21.69,111.88 21.07,111.26 21.07,109.55 22.27,108.34 22.27,98.29 22.83,97.73 22.83,97.12 23.15,96.8 23.15,95.91 23.29,95.77 23.29,93.05 25.18,91.16 25.18,89.26 25.48,88.97 v1(25.53,88.97)
  BOTTOM w0.127: v1(25.53,88.97) 26.11,88.97 26.24,88.84 27.61,88.84 29.03,87.42 29.03,87 29.03,86.02 v2(29.59,85.46) 30.12,85.46 30.25,85.59 30.25,86.32 30.48,86.55 31.12,86.55 31.42,86.25 SCB121.2 31.85,86.68 31.81,86.72 R637.2
DEBUG_SPI_IO0: length 204.7
  TOP w0.127: F3R23.1 66.05,73.1 66.09,73.07 66.09,72.25 67.08,71.26 v1(67.08,71.07) ; v1(59.82,51.7) 59.82,50.85 59.93,50.74 59.93,48.47 59.03,47.56 58.61,47.56 58.43,47.39 58.43,45.8 58.55,45.68 58.84,45.68 59.29,45.22 59.29,44.89 59.84,44.35 59.84,43.8 59.39,43.35 56.41,43.35 v1(56.23,43.17)
  IN1 w0.127: v1(24.09,43.15) 24.37,42.87 25.62,42.87 27.77,40.72 32.79,40.72 32.8,40.73 32.99,40.91 33.17,41.1 36.8,41.1 38,42.31 43.43,42.31 44.22,43.1 44.85,43.1 45.39,42.56 45.75,42.56 46.1,42.91 47.43,42.91 47.48,42.85 53.86,42.85 54.18,43.17 v1(56.23,43.17) ; v1(80.36,106.1) 80.8,106.53 80.8,112.78 83.29,115.27 83.29,116.32 82.78,116.83 82.78,118.91 83.14,119.28 84.9,119.28 86.59,117.59 92.1,117.59 v1(94.45,119.95)
  IN2 w0.127: v1(59.82,51.7) 60.86,52.75 60.86,54.78 61.89,55.81 63.76,55.81 64.97,57.02 64.97,58.22 65.42,58.66 65.42,62.97 66.88,64.43 66.88,66.91 67.54,67.57 67.54,70.58 67.08,71.03 v1(67.08,71.07)
  BOTTOM w0.127: v1(24.09,43.15) 23.79,42.84 19.86,42.84 19.2,43.5 6.88,43.5 6.5,43.88 6.5,44.85 6.8,45.15 7.27,45.15 7.53,44.89 SR166.2 ; v1(94.45,119.95) 94.45,119.79 92.44,117.78 92.44,110.59 85.81,103.96 85.81,96.45 87.96,94.31 87.96,90.72 88.83,89.84 88.83,79.98 85.57,76.72 84.03,76.72 83.71,77.04 82.84,77.04 80.59,74.79 v2(80.59,74.01) 80.41,73.83 80.41,69.23 80.14,68.95 79.81,68.62 79.25,68.62 78.92,68.95 78.92,70.02 78.61,70.32 78.18,70.32 76.99,69.13 70.51,69.13 70.19,69.45 68.97,69.45 67.35,71.07 v1(67.08,71.07) ; v1(80.36,106.1) 80.36,105.98 79.82,105.44 79.82,104.33 HR381.2
DEBUG_SPI_IO2: length 227.5
  TOP w0.127: v1(88.74,132.5) 88.59,132.65 87.54,132.65 v1(87.38,132.5) ; F3R22.1 65.61,67.6 v1(65.81,67.4)
  IN1 w0.127: v1(9.09,61.61) 8.8,61.31 8.8,58.99 6.6,56.79 6.6,55.77 9.19,53.18 9.19,51.47 8.81,51.09 8.81,50.52 14.9,44.44 17.95,44.44 21.3,41.09 25.79,41.09 26.63,40.24 27.3,39.58 33.27,39.58 33.51,39.82 33.65,39.96 37.27,39.96 37.81,40.49 37.81,40.49 38.22,40.91 42.09,40.91 42.42,40.58 46.62,40.58 47.4,41.37 52.73,41.37 54.11,42.74 59.54,42.74 65.69,48.88 65.69,49.24 65.3,49.62 63.17,49.62 v1(62.99,49.44)
  IN2 w0.127: v1(62.99,49.44) 63.42,49.88 63.42,51.6 65.81,53.99 65.81,54.19 66.38,54.76 66.99,54.76 71.91,59.68 77.67,59.68 81.63,63.64 81.63,69.16 81.49,69.3 81.49,71.24 v1(81.54,71.29)
  BOTTOM w0.127: v1(65.81,67.4) 66.17,67.77 66.17,68.46 65.91,68.72 65.91,69.18 66.16,69.43 66.52,69.43 68.02,67.93 69.37,67.93 69.7,68.27 79.81,68.27 80.39,68.84 80.39,68.85 80.67,69.12 80.67,70.42 81.53,71.29 v1(81.54,71.29) 81.84,71.59 81.84,73.8 81.59,74.05 81.59,75.43 82.95,76.79 83.6,76.79 83.92,76.47 85.68,76.47 89.2,79.99 89.2,93.42 86.07,96.56 86.07,103.86 92.7,110.49 92.7,117.58 94.89,119.77 94.89,120.75 92.63,123 92.63,127.32 89.64,130.31 89.52,130.31 89.27,130.56 89.27,131.98 v1(88.74,132.5) ; HR367.2 87.9,126.75 88.35,127.2 88.35,127.68 87.6,128.43 87.6,129.4 86.97,130.04 86.97,132.08 v1(87.38,132.5) ; v1(9.09,61.61) 8.76,61.95 5.94,61.95 v2(5.43,62.46) 5.09,62.46 4.7,62.07 4.7,60.68 SR760.2
DEVSLP_N: length 74.7
  TOP w0.102: APR17.1 11.92,105.23 v1(12.42,104.74)
  IN1 w0.102: v1(54.57,72.79) 53.4,71.62 51.58,71.62 50.57,70.61 48.72,70.61 48.53,70.42 46.87,70.42 42.75,74.55 41.32,74.55 41.17,74.4 38.57,74.4 38.25,74.08 38.25,73.17 36.2,71.12 33.8,71.12 33.32,71.59 31.22,71.59 30.25,72.56 28.74,72.56 27.44,73.85 26.01,73.85 24.54,75.33 24.23,75.33 20.33,79.23 20.33,85.04 19.73,85.63 19.73,85.88 16.1,89.51 15.84,89.51 14.74,90.61 14.74,97.82 13.64,98.92 13.64,99.65 13.31,99.98 13.31,102.99 12.89,103.41 12.89,104.27 v1(12.42,104.74)
  BOTTOM w0.102: SR7915.2 54.79,72.35 54.79,72.57 v1(54.57,72.79) 54.9,73.12 v2(55.22,73.12)
DEVSLP_SSD_SLEEP_MODE: length 4.5
  TOP w0.102: J219.38 12.94,107.23 12.84,107.13 11.3,107.13 11.09,106.91 APR17.2 11.09,105.79 v2(11.38,105.5)
DISCH_PSON_EN: length 109.2
  TOP w0.102: Q7.1 79.9,78.56 80.77,77.69 Q5.1 81.59,76.48 80.65,75.54 v2(80.65,74.79) Q6.1 80.51,73.52 79.98,72.99 79.98,71.2 81.47,69.7 81.5,69.7 81.75,69.46 81.76,69.46 83.21,68.01 83.21,61.37 85.32,59.26 85.32,53.92 89.05,50.19 89.05,47.9 90.95,46 94.8,46 95.2,45.6 117.82,45.6 120.8,42.61 v1(120.8,42.18)
  BOTTOM w0.102: Q8.1 122.31,22.12 122.6,22.41 Q9541.1 122.6,24.17 122.2,24.58 121.23,24.58 120.58,25.22 120.58,26.91 120.83,27.16 121.18,27.16 121.75,26.58 125.12,26.58 125.22,26.69 Q9542.1 ; Q9542.1 124.53,27.17 123.59,28.11 122.26,28.11 121.93,28.44 121.93,34.32 122.8,35.18 Q9537.1 122.8,36.32 122.81,36.34 M1C43.2 122.81,37.3 122.81,37.3 SR7890.2 122.81,38.14 122.34,38.61 121.83,38.61 120.8,39.64 v1(120.8,42.18) ; Q9542.1 125.22,27.87 124.39,28.7 124.39,30.35 124.49,30.45 Q9540.1
DISCH_S4_EN: length 4.8
  BOTTOM w0.127: v2(130.12,42.79) 130.86,42.79 131.5,42.15 SR7889.2 131.5,41.21 131.04,40.76 130.5,40.76 129.87,40.12 Q9544.1
DISCH_SSD_EN: length 2.7
  BOTTOM w0.102: SR79.2 27.23,32.01 v2(27.23,32.43) 27.58,32.78 Q941.1
DISCH_SSD_EN_D: length 5.7
  BOTTOM w0.102: R933.2 33.63,33.77 33.44,33.96 Q942.1 32.07,33.96 31.42,33.31 v2(30.99,33.31) 30.38,33.31 30.18,33.51 Q941.3
DISCH_WLAN_EN: length 5.3
  BOTTOM w0.102: v2(57.96,52.31) 57.96,51.51 SR78.2 58.67,49.89 58.67,48.78 59.35,48.11 Q93.1
DISCH_WLAN_EN_D: length 4.1
  BOTTOM w0.102: R931.2 56.93,46.57 56.92,46.59 Q93.3 56.92,48.05 v2(56.86,48.11) 56.59,48.38 55.93,48.38 55.69,48.13 Q940.1
DISPA_BCLK_L200MIL: length 7.4
  TOP w0.089: 45.55,106.03 46.03,105.56 46.03,104.57 45.91,104.46 45.91,103.96 45.95,103.93 45.95,103.62 46.18,103.39 U1.AM3
  TOP w0.127: SR137.2 43.05,107.8 43.24,107.8 43.47,107.57 44.52,107.57 45.34,106.75 45.34,106.25 45.55,106.03
DISPA_SDO_L200MIL: length 6.2
  TOP w0.102: 45.88,106.03 46.24,105.67 46.24,104.5 46.13,104.4 46.13,104.13 46.21,104.05 U1.AM2
  TOP w0.127: 45.88,106.03 45.57,106.34 45.57,106.87 v4(44.35,108.09) 43.69,108.09 SR136.2
DMI_RXN0: length 72.4
  TOP w0.102: XU1.Y4 107.08,112.89 106.51,113.47 105.7,113.47 105.43,113.2 104.89,113.2 104.56,112.87 104.54,112.87 ; U1.C29 61.03,90.99 61.1,90.99 61.41,91.3 62.15,91.3 62.21,91.24
  TOP w0.127: 62.21,91.24 62.56,90.9 62.87,90.9 63.41,90.36 v1(63.42,90.36) ; 104.54,112.87 102.33,112.87 102.13,112.66 99.3,112.66 93.62,106.99 93.62,103.34 94.31,102.65 94.31,95.64 89.68,91 89.25,91 86.92,88.68 86.92,88.66 85.73,87.47 84.35,87.47 82.98,86.1 82.98,84.29 v1(83.06,84.21)
  BOTTOM w0.127: v1(63.42,90.36) 64.69,89.09 68,89.09 69.1,87.99 69.1,86.82 69.29,86.63 70.41,86.63 ; 70.41,86.63 74.15,86.63 76.92,83.86 81.61,83.86 81.68,83.78 82.63,83.78 v1(83.06,84.21) ; 70.41,86.63 v2(70.41,86.9)
DMI_RXN1: length 71.8
  TOP w0.102: U1.C31 60.34,89.59 60.74,89.99 61.09,89.99 61.21,89.87 64.25,89.87 v1(64.69,90.31) ; 104.59,112.22 104.65,112.22 105.04,112.6 105.91,112.6 105.99,112.53 107.21,112.53 107.42,112.31 107.61,112.13 107.7,112.03 107.76,111.98 XU1.AA5
  TOP w0.127: 104.59,112.22 102.7,112.22 102.61,112.13 102.38,111.89 99.63,111.89 94.44,106.7 94.44,103.64 95.08,103 95.08,95.33 89.99,90.24 89.57,90.24 87.68,88.36 87.68,88.35 86.04,86.71 85.47,86.71 84.99,86.23 84.99,85.63 v1(84.8,85.44)
  BOTTOM w0.127: 69.44,89.09 68.93,89.6 65.4,89.6 v1(64.69,90.31) ; 69.44,89.09 v2(69.24,88.89) ; 69.44,89.09 71.18,87.36 71.18,87.36 71.22,87.32 74.18,87.32 77.13,84.37 81.89,84.37 82.25,84.72 83.06,84.72 83.18,84.85 84.17,85.84 84.25,85.92 84.91,85.92 85.01,85.81 85.01,85.65 v1(84.8,85.44)
DMI_RXN2: length 71
  TOP w0.102: U1.C32 60.46,89.23 60.58,89.35 60.97,89.35 61.09,89.46 63.95,89.46 64.13,89.28 64.15,89.28 64.18,89.26 64.23,89.26 64.24,89.25 ; XU1.AB3 106.41,111.07 106.51,111.17 106.51,111.31 106.4,111.42 105.87,111.42 105.87,111.42 105.85,111.42 105.75,111.32 105.71,111.32 105.68,111.28 105.66,111.28
  TOP w0.127: 105.66,111.28 103.14,111.28 102.71,110.85 100.04,110.85 96.82,107.64 96.82,95.5 85.57,84.25 85.57,84.01 v1(85.79,83.8) ; v1(65.32,88.1) 65.1,88.32 65.1,88.39 64.24,89.25
  BOTTOM w0.127: 66.52,87.9 66.47,87.95 65.47,87.95 v1(65.32,88.1) ; 66.52,87.9 67.16,87.26 67.16,86.17 67.46,85.87 73.84,85.87 76.6,83.1 81.3,83.1 81.38,83.02 83.74,83.02 84.24,83.52 84.24,84.18 84.66,84.6 85.22,84.6 85.49,84.32 85.49,84.09 v1(85.79,83.8) ; 66.52,87.9 v2(66.72,88.1)
DMI_RXN3: length 71.3
  TOP w0.102: 105.3,110.97 105.37,110.97 105.39,110.96 105.62,110.96 105.85,110.72 107.54,110.72 XU1.AC5 ; U1.C33 61,88.76 61.07,88.76 61.36,89.05 63.3,89.05 63.53,88.83 63.53,88.61 63.53,88.61 63.53,88.59 63.56,88.57 63.56,88.53 v1(63.73,88.36)
  TOP w0.127: v1(80.67,81.84) 81.72,81.84 82.6,82.72 85.44,82.72 97.33,94.61 97.33,107.41 100.27,110.34 102.85,110.34 103.48,110.97 105.3,110.97
  BOTTOM w0.127: 71.22,84.6 v2(71.22,84.86) ; 71.22,84.6 71.55,84.6 73.94,82.21 78.56,82.21 78.61,82.16 80.01,82.16 80.32,81.84 v1(80.67,81.84) ; 71.22,84.6 70.56,84.6 70.18,84.98 66.84,84.98 64.1,87.72 64.06,87.72 63.73,88.05 v1(63.73,88.36)
DMI_RXP0: length 72.4
  TOP w0.102: XU1.Y3 106.48,112.89 106.55,112.97 106.55,113.14 106.43,113.26 105.78,113.26 105.52,113 104.98,113 104.63,112.65 104.59,112.65 104.55,112.61 104.54,112.61 ; U1.B29 61.09,90.71 61.17,90.79 61.18,90.79 61.5,91.1 62.03,91.1 62.09,91.04
  TOP w0.127: v1(83.69,84.21) 83.87,84.39 83.87,84.55 83.72,84.7 83.36,84.7 83.23,84.83 83.23,85.99 84.46,87.21 85.83,87.21 87.18,88.56 87.18,88.57 89.36,90.75 89.78,90.75 94.57,95.53 94.57,102.75 93.88,103.44 93.88,106.88 99.41,112.41 102.23,112.41 102.44,112.61 104.54,112.61 ; 62.09,91.04 62.76,90.36 v1(62.78,90.36)
  BOTTOM w0.127: 68.85,87.06 v2(68.58,87.06) ; 68.85,87.06 68.85,87.89 67.89,88.84 64.59,88.84 63.52,89.91 63.24,89.91 v1(62.78,90.36) ; 68.85,87.06 68.85,86.72 69.19,86.38 74.05,86.38 76.81,83.61 81.5,83.61 81.58,83.53 82.73,83.53 82.96,83.76 83.24,83.76 v1(83.69,84.21)
DMI_RXP1: length 71.7
  TOP w0.102: 104.59,111.96 104.68,111.96 105.12,112.4 105.83,112.4 105.9,112.32 106.66,112.32 106.77,112.21 106.77,111.76 107.03,111.5 107.55,111.5 107.62,111.57 107.62,111.79 107.43,111.98 XU1.AA4 ; U1.B31 61.07,89.72 61.12,89.66 64.68,89.66 64.9,89.88
  TOP w0.127: v1(85.44,85.47) 85.24,85.68 85.24,86.12 85.57,86.45 86.15,86.45 87.94,88.24 87.94,88.26 89.67,89.99 90.1,89.99 95.33,95.22 95.33,103.11 94.69,103.75 94.69,106.6 99.73,111.64 102.48,111.64 102.59,111.75 102.8,111.96 104.59,111.96 ; v1(65.33,90.31) 64.9,89.88
  BOTTOM w0.127: 66.85,89.86 69.04,89.86 71.33,87.57 74.29,87.57 77.24,84.62 81.79,84.62 82.14,84.98 82.95,84.98 83.18,85.21 84.15,86.17 85.01,86.17 85.26,85.92 85.26,85.65 v1(85.44,85.47) ; 66.85,89.86 v2(66.85,90.13) ; 66.85,89.86 65.51,89.86 65.33,90.04 65.33,90.11 65.33,90.11 v1(65.33,90.31)
DMI_RXP2: length 71.1
  TOP w0.102: XU1.AB4 106.99,111.27 106.84,111.27 106.48,111.62 105.78,111.62 105.75,111.62 105.66,111.54 ; 64.06,89.07 63.87,89.26 61.24,89.26 61.04,89.06 U1.B32
  TOP w0.127: 64.06,89.07 64.82,88.31 64.82,87.98 v1(65.33,87.47) ; 105.66,111.54 103.03,111.54 102.6,111.11 99.94,111.11 96.57,107.74 96.57,95.61 85.32,84.35 85.32,83.99 85.13,83.8 v1(85.13,83.8)
  BOTTOM w0.127: v2(66.62,86.32) 66.9,86.32 ; 66.9,86.32 66.9,87.16 66.36,87.7 65.56,87.7 v1(65.33,87.47) ; 66.9,86.32 66.9,86.07 67.36,85.61 73.73,85.61 76.5,82.84 81.2,82.84 81.27,82.77 83.85,82.77 84.49,83.41 84.49,84.07 84.76,84.34 85.11,84.34 85.24,84.22 85.24,83.91 v1(85.13,83.8)
DMI_RXP3: length 71.2
  TOP w0.102: v1(63.09,88.38) 63.32,88.61 63.32,88.74 63.22,88.85 61.45,88.85 61.09,88.49 U1.B33 ; 105.3,110.72 105.31,110.72 105.35,110.75 105.53,110.75 105.77,110.52 107.45,110.52 107.58,110.4 107.58,110.25 107.47,110.15 XU1.AC4
  TOP w0.127: 105.3,110.72 103.59,110.72 102.96,110.09 100.37,110.09 97.59,107.3 97.59,94.5 85.55,82.46 82.7,82.46 81.82,81.59 81.04,81.59 80.82,81.37 80.22,81.37 v1(80.19,81.41)
  BOTTOM w0.127: 69.19,84.72 70.08,84.72 70.46,84.34 71.45,84.34 73.84,81.96 78.46,81.96 78.51,81.9 79.9,81.9 80.19,81.62 v1(80.19,81.41) ; 69.19,84.72 v2(69.19,84.46) ; 69.19,84.72 66.74,84.72 63.99,87.47 63.95,87.47 63.4,88.02 63.4,88.08 v1(63.09,88.38)
DMI_TXN0: length 75.8
  TOP w0.102: XU1.AC1 104.31,110.29 104.03,110.29 103.21,109.46 102.91,109.46 102.79,109.34 102.68,109.34 102.61,109.34 102.59,109.33 102.58,109.33
  TOP w0.127: 102.58,109.33 100.71,109.33 98.35,106.96 98.35,93.92 85.8,81.37 85.8,81.12 v1(86.21,80.71) ; v1(58.43,90.61) U1.G30
  BOTTOM w0.127: 83.13,82.01 85.42,82.01 85.8,81.63 85.8,81.12 v1(86.21,80.71) ; 83.13,82.01 v2(83.13,82.26) ; 83.13,82.01 82.39,82.01 81.27,80.89 74.17,80.89 71.42,83.63 69.16,83.63 68.58,84.22 66.04,84.22 65.45,83.63 64.87,83.63 63.75,84.75 63.75,85.77 62.43,87.09 62.43,87.72 62,88.15 62,88.98 59.92,91.06 59.18,91.06 59,91.24 58.57,91.24 58.43,91.1 v1(58.43,90.61)
