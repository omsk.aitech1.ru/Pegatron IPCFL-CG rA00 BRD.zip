# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP9_M.2_SSD_C: length 3.4
  TOP w0.127: TC2.2 8.16,117.55 8.16,117.55 7.85,117.24 7.01,117.24 6.69,116.93 J219.13
PCIE_TXP10_M.2_SSD: length 147.1
  TOP w0.089: 62.48,87.43 62.46,87.43 62.42,87.39 61.01,87.39 U1.B35
  TOP w0.127: v1(64.24,85.66) 63.78,86.12 63.78,86.33 62.68,87.43 62.48,87.43 ; TC6.1 11.01,118.95 11.07,119.02 11.07,121.09 11.07,121.09 11.07,121.43 10.29,122.21 9.27,122.21 8.67,122.81 8.24,122.81 v1(8.08,122.98)
  IN1 w0.127: v1(8.08,122.98) 7.91,122.81 7.65,122.81 7.34,122.5 7.34,120.31 6.21,119.18 6.21,116.28 5.76,115.84 5.76,113.32 5.4,112.96 5.4,107.8 3.73,106.14 3.73,99.53 4.14,99.13 4.47,99.13 5.15,98.44 5.15,97.99 5.85,97.3 5.85,90.08 3.07,87.3 3.07,79.64 9.09,73.62 15.75,73.62 16.27,73.1 16.27,72.31 16.27,72.31 16.27,72.01 17.15,71.13 17.15,70.04 20.7,66.49 22.74,66.49 25.51,63.73 26.74,63.73 28.37,62.09 37.52,62.09 38.09,61.52 43.5,61.52 44.17,62.2 49.56,62.2 50.19,62.82 50.61,62.82 51.03,62.82 51.48,63.27 54.24,63.27 55.07,64.11 56.01,64.11 57.61,65.71 58.35,65.71 61.51,68.87 61.51,69.14 63.07,70.7 63.07,70.96 63.94,71.83 63.94,76.59 64.92,77.57 64.92,81.24 64.79,81.37 64.79,85.11 v1(64.24,85.66)
PCIE_TXP10_M.2_SSD_C: length 2.7
  TOP w0.127: J219.25 9.69,116.71 9.82,116.84 10.11,116.84 10.49,117.22 TC6.2
PCIE_TXP11_M.2_SSD: length 143
  TOP w0.127: U1.C36 60.72,86.6 61.41,86.6 61.48,86.67 62.16,86.67 62.76,86.07 62.76,85.84 v1(62.53,85.61) ; TC4.1 13.29,118.44 13.14,118.44 13.05,118.53 13.05,119.09 13.27,119.3 13.27,122.15 11.68,123.74 10.67,123.74 v1(10.41,123.99)
  IN1 w0.127: v1(10.41,123.99) 9.83,123.41 9.47,123.41 9.13,123.07 9.13,121.65 8.51,121.02 8.51,120.58 9.37,119.71 9.37,118.81 8.05,117.49 8.05,115.48 7.58,115.01 7.58,112.52 7.77,112.33 7.77,110.25 7.22,109.71 7.22,106.79 6.42,105.99 6.42,100.22 8.2,98.44 8.2,89.57 4.89,86.26 4.89,80.43 9.73,75.59 16.35,75.59 18.09,73.85 18.09,73.48 18.09,73.48 18.09,72.93 19.79,71.23 19.79,70.82 22.19,68.42 23.49,68.42 26.27,65.64 30.89,65.64 32.51,64.02 35.52,64.02 36.59,65.09 37.93,65.09 39.69,63.34 42.65,63.34 43.32,64.02 48.81,64.02 49.77,64.98 50.59,64.98 51.07,65.45 52.73,65.45 53.07,65.1 53.5,65.1 54.47,66.08 55.41,66.08 58.97,69.65 59.44,69.65 61,71.21 61,74.32 61.7,75.02 61.7,76.36 61.99,76.66 61.99,84.53 62.53,85.08 v1(62.53,85.61)
PCIE_TXP11_M.2_SSD_C: length 2.4
  TOP w0.127: J219.37 12.69,116.75 13.05,117.11 13.05,117.37 TC4.2
PCIE_TXP12_M.2_SSD: length 142.2
  TOP w0.127: v1(59.36,87.29) 59.52,87.13 59.52,86.57 U1.E37 ; v1(12.67,123.36) 12.88,123.57 12.88,123.84 13.16,124.12 14.02,124.12 15.39,122.75 15.39,119.59 15.72,119.26 15.72,118.91 TC8.1
  IN1 w0.127: v1(12.67,123.36) 11.89,123.36 10.64,122.11 10.64,119.34 8.56,117.26 8.56,112.59 8.28,112.31 8.28,110.04 7.73,109.5 7.73,99.65 8.71,98.67 8.71,88.02 5.4,84.71 5.4,80.64 9.94,76.1 16.56,76.1 18.6,74.06 18.6,73.14 20.37,71.37 20.37,70.96 22.29,69.04 24.02,69.04 25.47,67.59 26.71,67.59 27.93,66.37 31.89,66.37 33.64,64.62 35.39,64.62 36.1,65.33 36.1,65.56 36.5,65.95 40.23,65.95 41.11,65.08 44.54,65.08 45.06,65.6 45.97,65.6 46.43,65.14 48.49,65.14 48.83,65.48 50.38,65.48 50.86,65.96 52.38,65.96 53.02,66.59 55.2,66.59 58.72,70.12 58.72,70.25 60.49,72.01 60.49,75.88 61.48,76.87 61.48,79.38 61.63,79.53 61.63,87.48 60.83,88.28 59.82,88.28 59.53,88 59.53,87.47 v1(59.36,87.29)
PCIE_TXP12_M.2_SSD_C: length 2.3
  TOP w0.127: TC8.2 15.66,117.55 15.66,116.94 15.53,116.81 15.53,116.63 15.69,116.47 J219.49
PCIRST1#: length 157.5
  TOP w0.102: v1(55.17,41.8) 55.17,42.7 56.06,43.59 59.29,43.59 59.6,43.9 59.6,44.25 59.05,44.79 59.05,45.12 58.74,45.44 58.45,45.44 58.18,45.71 58.18,47.17 57.86,47.49 APR123.1 ; v1(19.59,74.08) 19.51,73.99 19.51,72.58 19.99,72.1 21.39,72.1 22.26,71.22 22.59,71.22 22.78,71.03 ; 22.78,71.03 22.78,70.74 23.7,69.83 23.7,68.37 23.48,68.15 23.48,64.01 22.59,63.12 22.59,61.07 23.28,60.39 23.28,59.51 23.07,59.3 23.07,57.52 22.9,57.35 22.9,54.9 22.67,54.67 22.67,52.61 23.1,52.18 23.1,50.11 22.62,49.63 22.62,45.52 23.07,45.06 23.07,43.75 22.9,43.58 22.9,40.34 v1(23.72,39.51) ; 22.78,71.03 22.97,71.22 23.05,71.22 24.69,72.86 26.28,72.86 26.88,73.46 26.88,75.4 27.34,75.87 27.34,78.24 26.64,78.94 PQ93028.1 ; v1(14.55,104.08) 14.96,104.49 14.96,104.83 APR126.1
  IN1 w0.102: v1(14.55,104.08) 14.58,104.05 14.58,100.62 v1(14.63,100.57) ; v1(23.72,39.51) 23.72,40.2 24.17,40.64 25.6,40.64 26.18,40.06 27.11,39.13 33.45,39.13 33.83,39.51 34,39.51 34,39.51 37.2,39.51 38.5,38.22 43.97,38.22 45.11,39.35 47.43,39.35 49.01,40.92 52.92,40.92 54.21,42.22 54.75,42.22 v1(55.17,41.8)
  BOTTOM w0.102: OR154.1 20.25,74.74 v1(19.59,74.08) 18.44,74.08 v2(17.85,74.67) 17.35,75.17 8.25,75.17 7,73.92 6.11,73.92 4.91,75.11 4.91,86.19 7.51,88.79 8.23,88.79 9.22,89.78 13.18,89.78 13.76,90.37 13.76,91.04 14.51,91.78 14.87,91.78 15.11,92.02 U104.51 15.11,95.16 16.27,96.32 17.52,96.32 17.77,96.56 17.77,97.92 17.01,98.67 16.09,98.67 14.63,100.13 v1(14.63,100.57)
PCIRST2#: length 7.5
  TOP w0.102: OR150.2 17.12,96.97 v1(17.35,96.74) 17.78,96.31 v2(17.94,96.31)
  BOTTOM w0.102: v1(17.35,96.74) 16.23,96.74 14.71,95.22 U104.52
PD_INT: length 6.3
  TOP w0.102: U1.AU26 43.23,91.42 v1(42.52,91.42)
  BOTTOM w0.102: SR226.2 41.68,95.05 v2(41.8,94.93) 41.8,92.92 42.12,92.59 42.12,91.81 v1(42.52,91.42)
PDB: length 11.9
  TOP w0.127: v1(21.39,24.63) 21.23,24.48 21.23,23.79 21.08,23.64 U6.47
  BOTTOM w0.127: R113.1 21.61,24.42 21.4,24.63 v1(21.39,24.63) ; R113.1 20.96,22.84 v2(20.96,22.45) ; R113.1 22.13,23.49 23.08,22.55 23.57,22.55 24.26,21.86 25.99,21.86 26.51,21.34 AR36.2 AR38.2
PECI_PCH: length 64
  TOP w0.127: v1(48.52,106.8) 49.45,105.86 49.45,105.21 49.1,104.85 49.1,104.03 49.08,104.02 U1.AF2 ; v1(85.61,131.31) 85.84,131.31 86.03,131.5 HR32.1
  IN2 w0.127: v1(85.61,131.31) 85.61,130.6 84.61,129.59 84.61,126.63 84.41,126.44 84.41,124.98 82.68,123.25 82.33,123.25 82.32,123.25 81.07,123.25 79.9,122.09 77.98,122.09 77.39,122.67 75.01,122.67 74.48,123.21 73.4,123.21 72.87,122.67 71.43,122.67 70.95,123.15 69.98,123.15 69.8,123.33 67.53,123.33 66.35,122.15 63.05,122.15 61.46,120.56 61.46,120.56 61.36,120.46 55.79,120.46 55.59,120.26 53.62,120.26 51.61,118.25 50.85,118.25 48.21,115.61 48.21,112.41 47.88,112.08 47.88,111.41 v1(48.31,110.98)
  BOTTOM w0.127: v1(48.31,110.98) v2(49.17,110.12) 49.47,109.81 49.47,108.61 SR93.1 49.04,108.18 SC12.1 48.11,107.67 48.09,107.65 48.09,107.22 v1(48.52,106.8)
PECI_READY: length 6.8
  BOTTOM w0.102: U104.31 24.84,94.76 25.01,94.59 25.01,94.17 OR3.2 26.11,93.07 26.55,93.07 27.02,92.6 v2(29.64,92.6)
PECI_SIO: length 174.3
  TOP w0.102: XU1.G7 109.49,124.34 v1(109.48,124.34)
  TOP w0.127: v1(95.47,132.58) 95,133.05 89.9,133.05 88.92,132.07 87.94,132.07 HR32.2
  IN1 w0.127: v1(98.69,123.95) 101.68,123.95 102.36,124.63 105.46,124.63 106.27,123.81 108.95,123.81 v1(109.48,124.34) ; v1(95.47,132.58) 95.04,133.01 91.05,133.01 88.94,135.12 88.03,135.12 87.53,135.62 87.05,135.62 86.62,136.05 86.62,136.53 85.93,137.22 85.03,137.22 82.62,139.63 79.7,139.63 78.83,140.5 75.75,140.5 74.83,141.42 72.39,141.42 v1(71.94,140.97) ; v1(28.84,94.64) 28.3,94.64 27.01,95.92 27.01,97.74 26.41,98.34 26.41,101.77 26.15,102.03 26.15,103.71 25.63,104.23 25.63,105.35 25.91,105.63 25.91,107.81 25.04,108.68 25.04,111.62 24.36,112.31 24.36,117.21 23.79,117.78 23.79,123.07 23.04,123.81 23.04,129.32 26.7,132.98 28.05,132.98 31.29,136.23 31.29,140.26 36.51,145.48 v1(37.44,145.48)
  IN2 w0.127: v1(37.44,145.48) 38.66,145.48 39.97,146.79 40.78,146.79 42.89,148.9 46.4,148.9 47.6,147.7 47.6,147.12 47.75,146.96 51.49,146.96 51.76,147.23 53.36,147.23 54.56,148.43 56.8,148.43 57.78,149.42 64.51,149.42 66,150.9 66,152.07 67.16,153.23 71.93,153.23 v1(72.72,152.44)
  BOTTOM w0.127: v1(28.84,94.64) 28.98,94.77 O2R1.1 ; v1(71.94,140.97) 72.44,141.47 72.44,146.9 72.72,147.18 v2(72.72,148.88) 72.72,149.11 72.54,149.29 72.54,149.98 72.72,150.15 v1(72.72,152.44) ; v1(95.47,132.58) 95.47,130.32 98.55,127.23 98.55,125.34 98.69,125.2 v1(98.69,123.95)
PEDET: length 210.8
  TOP w0.102: PQ45.3 17.42,119.8 17.8,119.8 v1(17.96,119.65) 17.96,119.44 17.92,119.4 ECR141.2 APR19.2
  IN2 w0.102: v1(17.96,119.65) 18.13,119.65 19.61,121.12 20.14,121.12 21.36,122.34 21.36,122.74 22.92,124.3 22.92,126.61 23,126.69 23,128.81 25.78,131.59 27.98,131.59 28.51,132.12 28.51,133.09 29.31,133.89 30.28,133.89 31.21,134.81 32.27,134.81 33.61,136.15 35.81,136.15 38.02,138.37 38.02,138.82 38.51,139.31 40.17,139.31 43.4,142.55 44.56,142.55 45.28,143.26 45.96,143.26 46.62,143.92 52.34,143.92 52.6,143.65 53.01,143.65 53.47,144.11 54,144.11 54.29,143.82 58.71,143.82 59.32,144.43 61.47,144.43 62,144.96 67.79,144.96 68.95,146.11 71.17,146.11 72.69,147.64 77.15,147.64 78.56,146.23 82.03,146.23 v1(82.14,146.12)
  BOTTOM w0.102: v1(82.14,146.12) 81.37,146.12 80.01,144.76 80.01,144.58 79.58,144.15 79.58,143.09 79.45,142.97 79.45,142.76 78.73,142.04 78.73,141.24 80.6,139.37 82.51,139.37 84.87,137.01 87.4,137.01 88.69,135.72 88.69,135.31 91.95,132.04 91.95,130.46 94.42,127.99 94.42,125.74 95.28,124.89 95.28,124.07 97.39,121.95 97.39,118.85 95.25,116.7 95.25,109.16 88.73,102.64 88.73,96.34 90.98,94.09 90.98,78.29 87.7,75.02 87.7,72.86 86.28,71.44 86.28,63.31 v2(85.7,62.73) 85.08,62.11 85.08,59.79 85.14,59.73 85.25,59.62 85.25,59.08 83.78,57.61 77.25,57.61 75.63,59.24 71.65,59.24 67.6,63.28 67.6,63.76 SR7917.2
PEDET_R: length 9.7
  TOP w0.102: APR19.1 19.41,118.11 19.45,118.15 SR7802.2 ; SR7802.2 19.28,118.69 19.28,119.24 19.18,119.34 19.05,119.34 18.38,120.02 18.38,120.75 18.17,120.96 PQ45.1 ; SR7802.2 20.3,117.67 20.3,117.18 v1(20.53,116.94) 20.69,116.78 J219.69
  BOTTOM w0.102: v2(19.8,116.94) v1(20.53,116.94)
PEG_RCOMP_W5S15L600MIL: length 2.9
  TOP w0.127: v1(109.48,120.68) 109.5,120.68 XU1.L7
  BOTTOM w0.127: HR9.2 110.79,120.49 v2(110.41,120.49) 110.21,120.68 v1(109.48,120.68)
PIRQA_N: length 158.7
  TOP w0.102: v1(50.21,37.02) 49.44,37.8 49.44,43.28 49.27,43.44 49.27,45 v1(49.55,45.27) ; v1(53.23,83.54) 53.37,83.68 53.74,83.68 54,83.43 54,82.87 54.07,82.79 U1.T45 ; R7219.2 6.04,70.68 v1(5.61,70.25)
  IN1 w0.102: v1(50.21,37.02) 49.17,38.06 45.58,38.06 44.49,36.97 37.98,36.97 36.68,38.27 34.52,38.27 34.52,38.27 34.35,38.27 33.92,37.84 25.91,37.84 25.42,38.32 22.26,38.32 17.42,43.16 14.35,43.16 5.57,51.93 5.57,53.77 3.88,55.46 3.88,57.06 6.65,59.83 6.65,60.71 7.22,61.29 7.22,64.65 5.24,66.63 5.24,69.88 v1(5.61,70.25)
  IN2 w0.102: v1(49.55,45.27) 49.55,45.23 50,44.78 51.23,44.78 52.21,45.76 52.21,46.11 51.98,46.34 51.98,49.34 52.26,49.62 52.76,49.62 53.88,50.74 53.88,51.2 53.48,51.61 53.48,52.35 55.1,53.98 55.1,54.75 55.51,55.16 55.51,55.51 55.15,55.87 54.68,55.87 53.94,56.62 53.94,59.57 53.02,60.49 53.02,64.27 49.49,67.81 48.72,67.81 45.69,70.83 45.69,71.18 44.32,72.55 44.32,73.29 41.63,75.98 41.63,77.32 40.66,78.29 40.66,78.75 40.26,79.16 40.26,80.51 39.65,81.12 39.65,85.08 41.71,87.14 42.75,87.14 43.78,88.17 43.78,88.81 44.05,89.08 46.34,89.08 46.65,88.78 46.65,88.39 46.96,88.08 46.96,86.33 47.28,86.01 47.94,86.01 48.21,85.74 48.21,84.62 48.41,84.42 49.14,84.42 49.77,83.79 52.97,83.79 v1(53.23,83.54)
  BOTTOM w0.102: v2(50.73,36.5) v1(50.21,37.02) ; v1(53.23,83.54) 53.34,83.54 SR7955.2
PIRQA_N_R: length 10
  TOP w0.102: v1(7.35,72.23) 6.93,71.82 6.93,71.39 7.35,70.97 R7219.1
  BOTTOM w0.102: U7201.18 12.34,69.89 11.88,70.36 11.2,70.36 10.67,70.9 v2(10.67,71.82) 10.34,72.15 10.34,72.97 10.03,73.28 9.14,73.28 8.52,72.66 7.78,72.66 v1(7.35,72.23)
PJP89001: length 107.7
  TOP w0.254: v1(80.47,163.37) 80.47,163.77 82.22,165.52 82.22,165.81 PR89020.1
  IN2 w0.203: v1(80.47,163.37) 82.4,161.43 89.25,161.43 89.46,161.64 94.96,161.64 96.64,159.96 103.27,159.96 104.52,158.71 120.99,158.71 121.5,158.21 125.86,158.21 126.72,159.07 129.89,159.07 130.12,159.3 134.85,159.3 135.06,159.08 142.69,159.08 143.07,158.7 145.78,158.7 146.08,159.01 147.53,159.01 148,158.54 148,155.97 145.64,153.61 145.64,150.64 146.91,149.37 146.91,138.95 146.25,138.29 145.34,138.29 143.58,136.54 143.58,134.81 v1(141.04,132.27)
  BOTTOM w0.102: v1(80.47,163.37) 80.56,163.37 v2(81.43,162.5)
  BOTTOM w0.254: PJP89001.1 140.94,132.37 v1(141.04,132.27)
PJP89002: length 111
  TOP w0.254: PR89032.1 81.61,167.5 v2(81.07,166.96) 80.71,166.6 80.71,165.68 v1(80.07,165.05)
  IN2 w0.203: v1(80.07,165.05) 80.07,164.43 82.76,161.74 89.13,161.74 89.33,161.94 95.16,161.94 96.78,160.31 103.42,160.31 104.72,159.02 121.12,159.02 121.62,158.51 125.73,158.51 126.6,159.37 129.77,159.37 130.02,159.63 134.97,159.63 135.22,159.39 142.81,159.39 143.19,159.01 145.65,159.01 145.98,159.34 147.7,159.34 148.36,158.67 148.36,155.82 146,153.46 146,150.76 147.29,149.47 147.29,138.78 146.43,137.91 145.39,137.91 144.09,136.62 144.09,134.36 141.32,131.59 v1(141.04,131.59)
  BOTTOM w0.254: PJP89002.1 140.56,131.1 v1(141.04,131.59)
PJP89003: length 104.8
  TOP w0.203: v1(100.29,168.93) 100.29,168.06 PR89048.1
  IN1 w0.203: v1(135.18,163.69) 135.04,163.83 v1(135.04,167.14)
  IN2 w0.203: v1(100.29,168.93) 100.29,169.5 100.74,169.95 132.26,169.95 135.04,167.17 v1(135.04,167.14) ; v1(146.45,126.71) 146.83,127.09 150.32,127.09 152.33,129.1 152.33,131.88 151.46,132.76 150.34,132.76 149.86,133.24 149.86,149.22 150.67,150.03 150.67,155.34 150.19,155.82 150.19,159.56 148.55,161.2 145.26,161.2 144.89,160.84 144.09,160.84 143.66,161.26 138.21,161.26 137.55,161.91 136.07,161.91 135.18,162.8 v1(135.18,163.69)
  BOTTOM w0.102: v1(135.18,163.69) 134.36,162.88 v2(133.37,162.88)
  BOTTOM w0.254: PJP89003.1 146.45,124.87 v1(146.45,126.71)
PJP89004: length 100
  TOP w0.203: v1(100.89,169.43) 100.72,169.6 PR89056.1
  IN1 w0.203: v1(134.4,167.14) 134.49,167.05 v1(134.49,163.69)
  IN2 w0.203: v1(134.49,163.69) 134.49,163.06 135.94,161.61 137.43,161.61 138.08,160.95 143.54,160.95 143.96,160.53 145.02,160.53 145.39,160.9 148.42,160.9 149.88,159.43 149.88,155.69 150.37,155.21 150.37,150.16 149.55,149.35 149.55,133.06 150.16,132.45 151.33,132.45 152.03,131.75 152.03,129.23 150.19,127.39 146.27,127.39 145.82,126.94 v1(145.82,126.71) ; v1(100.89,169.43) 101.1,169.64 131.9,169.64 v1(134.4,167.14)
  BOTTOM w0.254: v1(145.82,126.71) 145.82,125.08 145.39,124.65 PJP89004.1 ; v2(101.7,169.28) 101.04,169.28 v1(100.89,169.43)
PLT_RST#: length 291.8
  TOP w0.127: R206.1 81.51,157.12 79.35,157.12 76.99,154.75 v1(76.78,154.75) ; v1(57.76,46.01) 57.76,46.03 APR124.1 ; R7203.2 7.94,71.87 7.67,71.87 v1(7.38,71.58) ; v1(15.31,103.83) 15.43,103.94 APR125.1 ; v1(26.59,102.28) 25.87,101.56 22.55,101.56 21.77,100.78 21.77,100.57 21.07,99.86 21.07,98.72 19.87,97.52 18.98,97.52 17.47,99.02 15.91,99.02 15.2,98.31 13.07,98.31 12.73,98.66 v1(12.43,98.66) 12.24,98.85 10.79,98.85 10.57,99.07 8.62,99.07 5.32,95.78 5.32,92.49 4.47,91.63 4.47,74.6 v1(4.82,74.25)
  IN1 w0.127: v1(15.31,103.83) 15.31,104.31 15.72,104.71 15.72,107.13 14.17,108.68 14.17,113.2 15.19,114.21 15.19,115.9 v1(16.22,116.93) ; v1(76.78,154.75) 75.92,154.75 74.8,153.63 68.15,153.63 65.42,150.9 64.58,150.9 64.46,151.02 63.76,151.02 63.31,150.57 56.25,150.57 55.78,151.04 55.01,151.04 54.53,150.56 52.54,150.56 51.45,149.47 46.43,149.47 45.97,149.01 43.2,149.01 42.8,148.61 42.01,148.61 41.32,149.29 34.19,149.29 32.07,147.17 29.68,147.17 28.78,146.27 24.51,146.27 22.73,144.49 18.55,144.49 v1(17.76,145.28) ; v1(24.71,43.32) 24.44,43.59 23.56,43.59 23.04,43.07 21.19,43.07 18.49,45.76 15.76,45.76 11.63,49.89 11.63,52.68 8.08,56.24 8.08,57.3 9.48,58.7 9.48,59.71 9.96,60.19 9.96,65.05 10.64,65.73 10.64,66.59 10.76,66.72 10.76,67.08 10.29,67.55 9.04,67.55 7.38,69.22 v1(7.38,71.58) 7.38,71.59 4.82,74.15 v1(4.82,74.25) ; v1(28.08,95.47) 28.08,95.47 27.44,96.1 27.44,97.92 26.85,98.51 26.85,102.02 v1(26.59,102.28)
  IN2 w0.127: v1(12.43,98.66) 12.11,98.98 12.11,99.94 12.24,100.07 12.24,102.99 13.76,104.51 14.88,104.51 15.31,104.08 v1(15.31,103.83) ; v1(57.76,46.01) 57.76,45.94 57.24,45.42 57.24,43.56 56.36,42.69 54.18,42.69 53.79,42.31 52.27,42.31 51.92,42.66 48.26,42.66 47.55,43.37 46.48,43.37 45.99,43.86 45.39,43.86 44.56,44.68 42.77,44.68 40.95,46.5 38.18,46.5 37.8,46.88 36.78,46.88 34.6,49.06 32.57,49.06 31.96,49.66 28.73,49.66 v1(27.85,50.54)
  BOTTOM w0.127: v1(27.85,50.54) 27.85,50.45 25.35,47.95 25.35,47.31 24.81,46.78 v2(24.81,45.48) 24.81,43.42 v1(24.71,43.32) ; Q7201.3 6.53,71.23 6.65,71.1 6.9,71.1 v1(7.38,71.58) ; v1(16.22,116.93) 16.22,117.4 16,117.62 16,118.56 16.26,118.81 16.27,118.81 16.84,119.38 16.84,121.33 16.96,121.44 16.96,128.64 14.41,131.18 14.41,141.45 13.85,142.01 13.85,142.77 13.59,143.04 13.59,144.13 14.73,145.27 15.81,145.27 15.96,145.42 17.63,145.42 v1(17.76,145.28) C4024.1 19.05,143.6 18.55,143.1 U114.19 ; v1(28.08,95.47) 28.17,95.38 29.29,95.38 SR271.1 ; U104.14 24.67,101.56 25.14,102.04 25.14,102.53 25.58,102.96 SCB119.2 26.27,102.59 v1(26.59,102.28)
PLT_RST_J68_N: length 5.7
  TOP w0.102: v2(81.02,156.3) 82.05,155.27 R206.2 82.52,152.52 82.89,152.15 J68.23
PLTRST_CPU#: length 108.1
  TOP w0.102: v1(109.46,125.22) 109.46,126.13 XU1.E7
  TOP w0.127: v1(49.07,101.97) 49.01,101.97 U1.AG5 ; v1(102.47,126.65) 102.47,127.54 101.75,128.26 101.75,129.63 98.93,132.45 98.93,133.54 97.98,134.5 92.8,134.5 92.19,135.1 91.16,135.1 90.57,134.52 87.64,134.52 HC3.1 HR343.1 85.65,134.31 v1(85.65,132.58)
  IN2 w0.127: v1(109.46,125.22) 106.39,125.22 105.51,126.1 103.02,126.1 v1(102.47,126.65) ; v1(49.07,101.97) 49.63,102.53 49.63,102.86 49.83,103.06 50.44,103.06 50.72,102.78 50.72,101.13 51.23,100.62 51.99,100.62 52.6,101.23 52.6,103.47 51.84,104.23 50.98,104.23 49.51,105.69 49.51,113.68 52.43,116.6 59.33,116.6 59.84,117.11 63.45,120.72 66.75,120.72 67.41,121.38 69.57,121.38 69.8,121.6 70.05,121.86 70.41,121.86 70.89,121.38 76.85,121.38 77.83,120.4 79.75,120.4 79.88,120.26 82.27,120.26 82.88,120.87 83.66,120.87 86.61,123.82 86.61,131.56 85.65,132.53 v1(85.65,132.58)
  BOTTOM w0.127: v1(49.07,101.97) 49.67,102.57 v2(49.67,103.02)
PLTRST_N: length 17.4
  TOP w0.127: U1.AV29 43.25,90.79 v1(43.25,90.98)
  BOTTOM w0.127: SR271.2 30.36,95.29 SR219.1 31.38,94.74 31.75,95.11 v2(32.1,95.11) 33.93,95.11 34.32,94.73 34.6,94.73 34.74,94.59 35.7,94.59 36.75,93.54 37.1,93.54 37.44,93.2 37.44,92.57 37.79,92.22 39.68,92.22 40.31,91.59 40.31,91.31 40.78,90.84 41.33,90.84 41.6,90.57 41.6,90.41 41.86,90.16 42.24,90.16 42.42,90.34 42.81,90.34 43.25,90.77 v1(43.25,90.98)
PM_DOWN: length 69.8
  TOP w0.102: 50.3,105.65 50.28,105.63 50.28,105.04 49.81,104.57 49.81,103.82 49.74,103.76 U1.AE2
  TOP w0.127: 50.3,105.65 50.3,105.67 v1(50.9,106.26) 50.9,106.92 50.11,107.71 50.11,109.04 SR552.1 ; HR34.1 86.1,133.68 86.1,132.69 v1(86.28,132.52)
  IN2 w0.127: v1(86.28,132.52) 87.06,131.74 87.06,123.66 86.18,122.78 86.18,121.79 85.74,121.35 85.09,121.35 84.18,120.44 83.06,120.44 82.33,119.71 80.81,119.71 80.62,119.52 78.1,119.52 76.67,120.94 68.66,120.94 67.98,120.26 63.6,120.26 60.02,116.68 59.51,116.17 52.61,116.17 49.95,113.5 49.95,107.14 50.82,106.26 v1(50.9,106.26)
  BOTTOM w0.127: v1(50.9,106.26) 51.06,106.42 51.06,107.03 v2(51.23,107.2)
PM_DOWN_L200MIL: length 32.6
  TOP w0.102: XU1.D8 111.3,127.08 v1(111.3,126.21)
  TOP w0.127: v1(101.91,127.28) 101.32,127.87 101.32,129.45 98.5,132.27 98.5,132.63 98.5,132.63 98.5,132.98 98.5,133.36 97.8,134.06 92.62,134.06 92.01,134.67 91.39,134.67 v1(90.8,134.08) HR34.2
  IN2 w0.127: v1(101.91,127.28) 102.45,127.28 103.2,126.53 105.68,126.53 106.52,125.7 110.79,125.7 v1(111.3,126.21)
  BOTTOM w0.127: v2(89.78,134.93) 89.95,134.93 v1(90.8,134.08)
PM_SYNC: length 97.3
  TOP w0.127: SR87.2 48.77,108.38 48.77,107.71 v1(48.53,107.47) ; XU1.E8 110.42,127.04 104.31,127.04 104,127.35 104,129.66 v1(100.42,133.24)
  IN2 w0.127: v1(48.53,107.47) 47.88,108.12 47.88,110.8 47.45,111.23 47.45,112.26 47.78,112.59 47.78,116.53 51.94,120.69 55.41,120.69 55.61,120.89 61.18,120.89 62.87,122.58 66.17,122.58 67.35,123.76 69.98,123.76 70.16,123.58 71.13,123.58 71.61,123.1 72.69,123.1 73.22,123.64 74.65,123.64 75.19,123.1 77.57,123.1 78.15,122.52 79.73,122.52 80.89,123.68 82.5,123.68 83.98,125.16 83.98,126.62 84.17,126.81 84.17,129.77 85.18,130.77 85.18,132.73 85.47,133.02 87.48,133.02 87.82,132.68 87.82,132.08 87.49,131.75 87.49,130.92 88.06,130.35 88.86,130.35 89.55,129.66 90.52,129.66 91.93,128.25 94.34,128.25 96.08,129.99 97.76,129.99 100.42,132.65 v1(100.42,133.24)
  BOTTOM w0.127: v1(48.53,107.47) 48.84,107.47 49,107.3 v2(49.33,107.3)
PM_SYNC_R: length 5.3
  TOP w0.089: 49.32,103.91 49.32,103.38 U1.AF3
  TOP w0.127: 49.32,103.91 49.32,104.76 49.68,105.11 49.68,106.26 49.6,106.34 v2(49.6,106.57) 49.25,106.92 SR87.1
POWER_SHARE: length 3.5
  TOP w0.102: v1(51.33,84.24) 51.32,84.23 51.32,83.25 51.67,82.89 51.67,82.8 U1.AA45
  BOTTOM w0.102: v1(51.33,84.24) 51.87,84.24 v2(52.03,84.41) 51.95,84.48 SR112.2
PQ1_G: length 1.5
  TOP w0.254: PC1.2 163.8,152.42 163.98,152.24 163.98,151.68 v2(164.16,151.5)
PQ21_D:
  vias: v2(72.41,97.68)
PQ21_G: length 4.7
  BOTTOM w0.102: v2(67.49,102.76) 67.49,101.73 PR111.2 PR113.1 68.77,101.73 68.58,101.92 PC108.1 69.2,102.29 69.3,102.39 PQ21.3
PQ22_B: length 5.4
  BOTTOM w0.127: PQ22.2 67.84,95.95 67.43,95.54 67.43,94.42 PR114.2 PR115.2 PR123.2 69.62,94.73 v2(69.9,95.01)
PQ22_C: length 4.4
  BOTTOM w0.102: v2(65.84,98.85) 65.99,98.69 PQ22.4 67.19,99.14 66.75,99.58 66.75,100.29 67.03,100.57 PR111.1
PQ22_E: length 7.7
  BOTTOM w0.102: PQ22.3 67.19,92.79 v2(67.58,92.41) 68.85,91.14 70.13,91.14 PR112.2
PQ24_G: length 9
  BOTTOM w0.102: PR132.2 136.27,35.53 PQ25.3 136.27,39.97 136.63,40.33 v2(137.6,40.33) 138.17,39.76 138.17,39.64 138.88,38.94 PQ24.1
PQ101_1: length 1.5
  TOP w0.102: SR698.2 34.45,109.01 PQ101.1
PQ102_1: length 10.8
  TOP w0.102: v2(30.35,112.08) 29.58,112.85 SR699.1 ; v2(30.35,112.08) 30.18,111.91 30.18,111.05 29.87,110.73 PQ102.1 ; v2(30.35,112.08) 30.71,112.08 30.94,111.85 30.94,111.6 31.11,111.42 32.24,111.42 SR702.2 33.61,111.27 34.36,111.27 34.71,111.61 PQ101.3
PQ6301_G: length 6
  BOTTOM w0.102: PR93062.1 31.25,146.19 PD8.3 31.25,148.51 30.76,149.01 v2(29.64,149.01) 29.28,149.01 28.96,148.69 PQ6301.1
PQ93010_D: length 17
  IN1 w0.102: v1(33.28,142.92) 32.48,142.92 31.71,142.14 29.96,142.14 v1(29.74,141.93)
  BOTTOM w0.102: v1(29.74,141.93) 29.46,141.64 PQ93010.3 28.36,141.64 28.26,141.54 PR93052.1 ; v1(33.28,142.92) 33.28,143.7 34.41,144.82 35.79,144.82 36.06,145.1 36.06,145.49 36.52,145.94 36.66,145.94 37.92,147.2 37.92,149.82 v2(38.4,150.31)
PQ93012_D: length 13.4
  TOP w0.102: v2(52.42,143.25) 52.35,143.32 PQ93012.3 47.01,143.32 46.38,142.69 44.35,142.69 v1(43.41,143.63)
  BOTTOM w0.102: PR93055.1 42.86,146.5 42.86,145.65 43.1,145.41 43.1,143.93 v1(43.41,143.63)
PRIM_XDP_JTAG_TCK_R: length 6.6
  BOTTOM w0.102: HR370.1 79.35,105.4 79.93,105.98 79.93,106.29 80.16,106.52 80.85,106.52 v2(81.05,106.72) 81.05,107 80.69,107.36 80.01,107.36 79.4,107.96 XDP1.55
PROC_AUDIO_CLK: length 97.3
  TOP w0.102: 103.32,115.59 103.61,115.29 104.83,115.29 105.06,115.07 105.94,115.07 XU1.V3
  TOP w0.127: v1(42.1,111.93) 42.1,111.47 41.88,111.25 41.88,110.54 AC70.1 42.53,109.9 SR137.1 ; v1(81.76,127.52) 82.16,127.92 82.6,127.92 82.78,127.75 83.26,127.75 84.4,128.89 v2(84.78,128.89) 84.95,129.06 87.19,129.06 87.32,129.19 87.32,129.24 87.84,129.76 89.8,129.76 91.64,131.6 93.98,131.6 96.94,128.64 98.09,128.64 100.74,125.99 100.74,119.65 101.91,118.48 101.91,116.99 103.32,115.59
  IN2 w0.127: v1(81.76,127.52) 81.76,127.73 81.15,128.35 80.27,128.35 80.14,128.22 80.14,127.73 80.01,127.6 79.73,127.6 79.5,127.83 79.5,128.22 79.38,128.35 73.92,128.35 73.57,128.01 71.37,128.01 69.64,126.28 68.89,126.28 68.76,126.41 68.76,126.71 68.63,126.84 68.25,126.84 68.13,126.71 68.13,126.41 68,126.28 67.62,126.28 67.49,126.41 67.49,126.71 67.36,126.84 66.98,126.84 66.86,126.71 66.86,126.41 66.73,126.28 66.35,126.28 66.22,126.41 66.22,126.71 66.09,126.84 65.71,126.84 65.59,126.71 65.59,126.41 65.46,126.28 65.17,126.28 64.53,126.92 62.49,126.92 60.88,125.32 60.42,125.32 59.82,124.72 59.82,123.45 59.82,123.45 59.82,123.24 58.85,122.27 56.36,122.27 55.95,122.27 55.29,122.93 51.7,122.93 45.85,117.07 45.85,111.66 45.44,111.26 43.42,111.26 43.18,111.5 42.54,111.5 v1(42.1,111.93)
PROC_AUDIO_SDI: length 91.6
  TOP w0.102: XU1.V2 105.08,114.72 104.74,115.07 103.48,115.07 103.27,115.28 103.17,115.28
  TOP w0.127: SR136.1 43,109.62 43,110.1 43.38,110.47 43.38,110.83 43.37,110.83 v1(43.37,111.93) ; 103.17,115.28 101.66,116.8 101.66,118.38 100.49,119.55 100.49,125.88 97.98,128.39 96.83,128.39 93.87,131.35 91.75,131.35 89.83,129.43 87.92,129.43 87.21,128.72 85.32,128.72 84.99,128.39 84.26,128.39 83.37,127.5 82.9,127.5 82.9,127.49 v1(82.4,127.49)
  IN2 w0.127: v1(43.37,111.93) 43.79,111.51 45.34,111.51 45.59,111.76 45.59,117.18 51.6,123.18 55.4,123.18 56.05,122.52 56.25,122.52 56.25,122.52 58.74,122.52 59.57,123.35 59.57,124.82 60.4,125.65 60.84,125.65 62.36,127.17 70.18,127.17 71.26,128.26 73.47,128.26 74.12,128.92 81.19,128.92 82.4,127.71 v1(82.4,127.49)
  BOTTOM w0.127: v2(43.37,112.64) v1(43.37,111.93)
PROC_AUDIO_SDO: length 112.1
  TOP w0.089: U1.AN3 45.59,103.19 45.59,103.7 45.53,103.76 45.53,104.61 45.65,104.73 45.65,105.29 45.01,105.93
  TOP w0.127: 45.01,105.93 44.91,106.03 44.91,106.5 44.32,107.09 43.35,107.09 43.27,107.09 43.06,107.29 42.67,107.29 42.42,107.53 42.25,107.53 41.87,107.92 41.87,109.5 41.65,109.71 41.65,109.91 40.75,110.81 39.3,110.81 39.18,110.94 39.18,111.71 39.34,111.88 39.66,111.88 v1(40.12,112.34) ; v1(83.08,128.18) 85.63,130.73 86.08,130.73 86.27,130.92 87.61,130.92 88.13,131.43 89.11,131.43 90.14,132.46 94.34,132.46 97.3,129.5 99.66,129.5 100.25,128.91 100.25,126.84 101,126.09 101,124.53 102.42,123.11 103.13,123.11 v1(103.77,122.47)
  IN2 w0.127: v1(83.08,128.18) 82.83,127.93 82.83,127.13 82.69,126.99 79.73,126.99 78.62,128.09 74.02,128.09 73.68,127.75 71.47,127.75 69.62,125.9 65.07,125.9 64.3,126.67 62.64,126.67 61.64,125.67 61.64,124.28 59.38,122.02 55.84,122.02 55.18,122.67 51.81,122.67 46.1,116.96 46.1,111.55 45.55,111 43.32,111 43.15,111.17 41.29,111.17 v1(40.12,112.34)
  BOTTOM w0.127: v1(83.08,128.18) 83.23,128.34 86.51,128.34 v2(86.66,128.18) ; HR35.1 109.94,119.16 107.26,121.83 104.4,121.83 v1(103.77,122.47)
PROC_AUDIO_SDO_L200MIL: length 10.4
  TOP w0.102: v1(107.68,117.9) 107.68,116.38 107.38,116.07 106.97,116.07 106.74,115.85 106.74,115.52 106.51,115.29 105.14,115.29 104.79,115.64 XU1.U1
  BOTTOM w0.127: v2(110.64,116.45) 110.64,118.1 HR35.2 109.59,118.32 109.58,118.33 108.12,118.33 v1(107.68,117.9)
PROC_SEL#_R: length 7.2
  TOP w0.102: XU1.AB36 138.2,109.69 v1(138.2,109.66)
  BOTTOM w0.102: v1(138.2,109.66) 137.75,109.22 137.75,106.77 137.42,106.43 135.88,106.43 v2(135.65,106.19) 135.4,105.95 HR12.2
PROCHOT#: length 106.1
  TOP w0.127: PR89066.2 96.1,166.83 95.98,166.72 v1(95.98,166.72)
  IN1 w0.127: v1(82.23,159.4) 81.6,160.04 81.6,160.79 85.53,164.72 88.4,164.72 89.23,163.9 94.29,163.9 95.27,164.88 95.27,165.22 95.98,165.92 95.98,166.71 v1(95.98,166.72)
  IN2 w0.127: v1(27.5,143.14) 27.91,143.55 31.85,143.55 33.38,142.03 35.97,142.03 36.37,141.62 36.96,141.62 40.88,145.54 41.24,145.54 42.42,146.72 45.58,146.72 46.69,145.61 51.61,145.61 52.02,146.03 53.7,146.03 54.14,146.47 57.22,146.47 57.38,146.31 60.2,146.31 61.58,147.69 63.24,147.69 63.27,147.67 69.26,147.67 70,148.4 77.4,148.4 78.67,147.13 v1(79.27,147.13) 79.86,147.72 79.86,157.03 v1(82.23,159.4)
  BOTTOM w0.102: v2(21.89,147.64) 22.37,147.16 23.35,147.16 23.83,146.69 PR93063.2
  BOTTOM w0.127: v1(79.27,147.13) 78.16,146.02 MQ28.2 77.38,144.45 77.44,144.39 SR7995.2 ; PQ6301.3 25.61,147.03 PR93063.2 25.61,146.34 26.24,146.34 27.01,145.58 27.01,143.63 v1(27.5,143.14)
PROCHOT#_R: length 35.2
  TOP w0.127: XU1.C39 141.59,127.52 142.14,128.08 v1(142.14,129.17)
  BOTTOM w0.127: v2(149.53,144.62) 149.53,142.92 147.39,140.78 147.39,137.76 146.89,137.25 146.89,136.46 146.45,136.03 146.45,133.11 142.52,129.17 v1(142.14,129.17) 141.35,128.39 140.69,128.39 139.57,127.27 139.57,126.95 138.39,125.77 138.36,125.77 136.96,124.36 136.96,124.23 135.9,123.18 135.2,123.18 134.09,122.06 134.09,120.35 HC30.1 HR33.2
PS_ON_N: length 235.9
  TOP w0.102: OR151.2 17.08,98.01 v1(17.09,98) ; v2(14.07,96) 13.4,96 v1(13.27,96.13)
  IN1 w0.102: v1(17.74,116.97) 17.52,116.75 17.52,116.12 16.91,115.52 16.91,114.04 16.06,113.19 16.06,112.17 15.47,111.57 15.47,109.16 17.72,106.9 17.72,101.66 17.52,101.46 17.52,101.08 16.52,100.07 16.52,99.73 16.77,99.48 16.77,99.45 17.05,99.16 17.05,98.03 v1(17.09,98)
  IN2 w0.102: v1(121.36,37.61) 119.75,35.99 113.96,35.99 112.58,37.37 108.28,37.37 101.09,44.55 94.85,44.55 89.38,50.02 89.38,51.04 87.86,52.57 87.86,54.38 84.64,57.6 81.34,57.6 79.09,55.35 74.55,55.35 73.18,56.72 71.93,56.72 69.67,54.46 68.61,54.46 67.14,52.99 67.14,50 65.02,47.88 64.34,47.88 57.59,41.13 44.46,41.13 42.77,42.81 42.77,43.37 40.85,45.29 34.04,45.29 33.68,45.64 33.68,45.89 33.3,46.27 32.11,46.27 31.81,46.56 31.81,47.34 31.05,48.1 29.79,48.1 29.59,47.89 29.59,47.06 29.44,46.92 28.67,46.92 27.95,47.64 26.14,47.64 25.2,48.58 19.38,48.58 17.07,50.89 17.07,53.66 16.41,54.32 16.41,56.91 14.59,58.73 14.59,59.93 12.28,62.24 12.28,64.12 12.84,64.68 12.84,69.47 11.96,70.35 11.96,71.57 11.26,72.27 11.26,72.65 10.59,73.31 10.59,77.14 10.27,77.47 7.69,80.05 7.69,84.49 11.49,88.29 11.49,91.85 12.96,93.33 12.96,93.47 12.96,95.82 v1(13.27,96.13)
  BOTTOM w0.102: PQ93030.1 30.06,111.3 PQ93031.1 30.38,111.83 29.68,112.54 29.57,112.54 27.84,114.27 27.84,115.16 26.77,116.23 26.77,117.08 24.53,119.32 19.65,119.32 17.74,117.41 v1(17.74,116.97) ; v1(121.36,37.61) 121.52,37.77 SR7890.1 ; U104.53 14.31,95.09 v1(13.27,96.13) 13.79,96.13 14.12,95.8 14.9,95.8 v1(17.09,98)
PU10_SS1: length 5
  BOTTOM w0.102: v2(71.81,46.9) 71.6,46.7 71.6,44.93 71.39,44.72 70.7,44.72 PC941580.1 69.75,45.15 69.72,45.18 PU10.12
PU10_SS2: length 4.6
  BOTTOM w0.102: v2(71.73,48.66) 71.73,48.07 70.27,46.61 PC941579.1 69.77,46.09 69.66,45.98 PU10.10
PU10_VIN1:
  vias: v2(66.8,43.17)
PU10_VIN2:
  vias: v2(66.75,49.24)
PU30_OUT: length 142
  TOP w0.102: PU30.6 155.3,165.99 155.6,165.7 156.16,165.7 v1(156.26,165.6)
  IN2 w0.102: v1(42.59,149.67) 47.52,149.67 47.68,149.52 51.84,149.52 52.25,149.93 53.67,149.93 54.86,151.12 55.62,151.12 56.16,150.59 57.69,150.59 58.11,150.17 64.39,150.17 65.38,151.16 65.38,152.47 67.85,154.94 73.96,154.94 75.89,156.88 75.89,164.48 77.93,166.51 80.6,166.51 81.71,165.41 86.41,165.41 87.12,166.12 89.41,166.12 90.09,165.45 95.1,165.45 95.34,165.69 97.2,165.69 98.86,164.04 100.18,164.04 100.78,164.63 101.58,164.63 101.96,164.25 103.63,164.25 103.78,164.1 109.7,164.1 110.37,163.43 111.64,163.43 112.32,164.1 119.84,164.1 121.07,165.33 122.11,165.33 122.89,166.12 127.92,166.12 129.06,164.98 131.47,164.98 131.79,164.66 132.76,164.66 133.25,164.18 134.14,164.18 134.49,164.53 135.48,164.53 136.37,165.42 139.17,165.42 140.08,166.32 145.19,166.32 145.8,166.93 147.19,166.93 v1(147.61,166.51)
  BOTTOM w0.102: v1(42.59,149.67) 42.05,149.13 42.05,148.64 43.28,147.41 43.28,146.16 44.8,144.64 PR6301.1 ; v1(147.61,166.51) 148.5,166.51 149.5,165.51 154.68,165.51 v2(154.77,165.6) v1(156.26,165.6)
PU30_OUT_R: length 5.8
  BOTTOM w0.102: PR6301.2 PR93060.1 44.19,141.38 44.19,140.83 v2(43.92,140.55) 43.92,140.16 PR93038.1 42.9,139.14 42.11,139.14 PR93039.1
PU30_V+: length 2.4
  BOTTOM w0.102: v1(157.91,163.95) v2(155.55,163.95)
PU8401_SS1: length 3.4
  BOTTOM w0.178: PU8401.12 40.53,43.78 39.75,43 v2(39.51,43) 38.62,42.1 PC941609.1
PU8401_SS2: length 6.1
  BOTTOM w0.178: PU8401.10 40.55,42.98 40.48,42.91 40.31,42.91 39.75,42.34 39.07,41.66 39.07,41.26 PC941604.1 38.43,40.62 38.43,39.86 38.11,39.54 37.39,39.54 v2(37.06,39.87)
PU8401_VIN1:
  vias: v2(45.31,44.95)
PU8401_VIN2:
  vias: v2(45.34,40.12)
PU8402_SS1: length 3.5
  BOTTOM w0.102: PU8402.12 94.74,11.41 PC941619.1 93.62,10.29 v2(93.62,9.46)
PU8402_SS2: length 9.4
  TOP w0.102: v2(88.44,9.39) 89.87,7.96 92.04,7.96 93.38,9.3 PC941613.1 94.21,9.86 v1(94.29,9.94)
  BOTTOM w0.102: v1(94.29,9.94) 94.61,9.94 95.27,10.61 PU8402.10
PU8402_VIN1:
  vias: v2(97.36,14.49)
PU8402_VIN2: length 19.3
  IN1 w0.102: v1(92.1,24.93) 92.1,19.26 98.03,13.33 v1(98.03,9.17)
  BOTTOM w0.102: v1(92.1,24.93) 92,24.83 v2(92,23.89)
PU_PCH_CPU_GP1: length 104.2
  TOP w0.102: v1(46.71,83.2) 46.48,82.97 U1.AM45
  IN1 w0.102: v1(47.81,71.67) 48.33,71.67 49.29,72.62 50.57,72.62 51.89,73.95 51.89,74.85 52.86,75.81 52.86,78.37 51.99,79.23 v1(51.99,79.47) ; v1(52.4,49.16) 52.29,49.16 52.02,48.9 51.27,48.9 50.81,48.44 42.49,48.44 42.43,48.38 39.39,48.38 37.14,50.62 34.32,50.62 33.76,51.18 30.54,51.18 29.98,51.74 27.16,51.74 26.55,51.13 24.57,51.13 v1(24.48,51.22)
  IN2 w0.102: v1(52.4,49.16) 52.59,49.16 54.09,50.66 54.09,51.29 53.68,51.69 53.68,52.27 55.3,53.89 55.3,54.67 55.71,55.08 55.71,55.59 55.23,56.07 54.79,56.07 54.69,56.17 54.68,56.17 54.41,56.45 54.41,57.47 54.96,58.03 55.47,58.03 55.77,58.33 55.77,59.14 54.04,60.87 54.04,65.46 51.84,67.66 51.84,68.82 49.86,70.81 48.67,70.81 v1(47.81,71.67) ; v1(51.99,79.47) 51.79,79.27 51.2,79.27 50.79,79.68 50.79,80.14 49.61,81.32 48.24,81.32 47.52,82.04 47.52,82.35 46.71,83.16 v1(46.71,83.2)
  BOTTOM w0.102: v1(24.48,51.22) 22.63,49.37 v2(22.63,45.1) 22.48,44.95 21.72,44.95 20.83,44.06 19.63,44.06 19.49,44.2 18.02,44.2 17.23,44.99 15.4,44.99 15.23,44.81 14.62,44.81 14.53,44.89 SR624.1 ; v1(51.99,79.47) 51.99,78.93 53.08,77.84 53.39,77.84 53.71,77.52 53.71,77.19 54.02,76.88 54.58,76.88 55.32,76.14 55.32,75.58 55.83,75.07 57.19,75.07 SR346.2
PULSAR_38D4M_REFCLK: length 7.3
  TOP w0.102: 54.51,101.74 U1.R6
  TOP w0.127: v1(55.24,101.34) 54.91,101.34 54.51,101.74
  BOTTOM w0.127: v1(55.24,101.34) 55.12,101.22 R3112.1 54.16,101.93 54.25,102.02 54.25,103.11 56.18,105.04 v2(56.18,105.63)
PULSAR_38D4M_REFCLK_R: length 93.4
  TOP w0.127: J218.64 50.45,53.29 51.38,54.22 52.64,54.22 53.47,53.39 54.43,53.39 56.23,55.18 v1(57.43,55.18)
  IN1 w0.127: v1(52.97,98.26) 54.53,96.7 54.53,93.94 55.57,92.9 56.28,92.9 56.58,93.21 58.98,93.21 59.61,93.84 59.61,94.07 61.86,96.32 65.11,96.32 68.18,93.25 69.38,93.25 69.72,92.9 69.72,92.17 69.39,91.84 69.39,85.64 73.84,81.19 73.84,72.3 69.19,67.66 69.19,64.3 69.9,63.59 69.9,61.97 68.27,60.34 67.38,60.34 67.03,60.7 65.71,60.7 65.35,60.34 65.35,59.53 66.85,58.03 66.85,56.76 66.5,56.4 64.18,56.4 63.65,55.87 60.58,55.87 59.84,55.13 57.48,55.13 v1(57.43,55.18)
  BOTTOM w0.127: v1(52.97,98.26) 52.97,98.73 53.39,99.15 53.39,100.02 53.32,100.08 R3112.2 53.33,101.22 R3110.1 ; v1(57.43,55.18) 57.94,55.69 v2(58.22,55.69)
PW_CLEAR: length 147.1
  TOP w0.102: JMP1.3 48.55,149.48 47.46,148.39 47.46,147.23 45.76,145.53 v1(45.76,143.74) ; v1(52.67,80.88) 52.73,80.94 52.73,81.07 U1.V48
  IN1 w0.102: v1(17.96,120.28) 18.38,119.87 18.38,119.48 18.06,119.16 18.06,118.28 17.08,117.3 17.08,116.26 16.51,115.69 16.51,114.33 15.02,112.84 15.02,109.03 16.37,107.68 16.37,104.01 16.11,103.76 16.11,99.53 16.25,99.39 16.25,94.1 18.35,92 18.35,89.45 18.77,89.03 19.25,89.03 19.8,88.48 19.8,88.14 20.22,87.72 20.22,86.55 21.14,85.62 21.14,79.57 24.57,76.14 25.78,76.14 26.93,74.98 29.72,74.98 31.02,73.69 36.94,73.69 38.3,75.05 40.95,75.05 41.07,75.16 43.12,75.16 47.25,71.03 48.28,71.03 49.26,72.01 50.53,72.01 53.92,75.39 53.92,78.79 53.54,79.17 53.54,80.5 53.15,80.88 v1(52.67,80.88)
  IN2 w0.102: v1(17.96,120.28) 19,121.33 20.05,121.33 21.16,122.43 21.16,122.82 22.72,124.39 22.72,126.69 22.8,126.78 22.8,129.07 25.52,131.79 27.9,131.79 28.31,132.2 28.31,133.17 29.22,134.09 30.2,134.09 31.19,135.08 32.07,135.08 33.35,136.36 35.72,136.36 37.82,138.45 37.82,138.9 38.43,139.51 40.08,139.51 43.32,142.75 44.46,142.75 45.45,143.74 v1(45.76,143.74)
  BOTTOM w0.102: SR85.1 55.13,85.36 SR73.2 54.46,84.18 54.46,83.86 54.08,83.48 54.08,82.12 53.91,81.96 53.74,81.96 53.54,81.75 53.54,81.24 53.18,80.88 v1(52.67,80.88)
PWM1_SN_D:
  vias: v2(129.89,147.16)
PWM2_SN_D:
  vias: v2(105.71,146.07)
PWM3_SN_D:
  vias: v2(91.03,147.39)
PWR2_PRSNT: length 6.6
  BOTTOM w0.102: OR37.1 14.04,112.61 v2(14.04,112.09) 13.63,111.67 13.15,111.67 12.71,111.23 12.71,110.72 12.81,110.62 12.81,109.99 13.26,109.54 13.98,109.54 14.31,109.21 U104.108
PWR_LED+: length 15.1
  TOP w0.102: v1(1.45,27.04) 1.57,26.92 R55.2 2.06,26.17 2.16,26.27 2.16,26.79 2.63,27.26 Q16.3
  BOTTOM w0.102: v1(1.45,27.04) 1.67,26.81 D5502.2 2.16,24.36 2.16,21.91 1.28,21.03 SW10.L2
PWR_LED-: length 87.2
  TOP w0.102: Q17.3 28.35,75.1 28.57,75.33 R59.2 28.23,75.67 27.64,75.09 27.64,73.15 26.6,72.1 25.86,72.1 24.34,70.58 24.34,68.06 24.04,67.76 24.04,63.76 23.53,63.25 23.53,59.48 23.27,59.21 23.27,57.43 23.1,57.26 23.1,54.82 22.87,54.59 22.87,52.7 23.3,52.26 23.3,50.03 22.82,49.54 22.82,46.34 23.49,45.67 23.49,44.8 23.28,44.58 23.28,43.67 23.1,43.49 23.1,40.96 24.14,39.92 24.14,39.34 22.9,38.09 22.9,36.12 v1(22.33,35.55)
  BOTTOM w0.102: v1(22.33,35.55) 21.23,34.46 19.73,34.46 19.38,34.1 19.38,32.88 19.38,32.28 20.12,31.55 20.12,30.09 17.51,27.49 17.15,27.12 17.15,27.12 16.38,26.36 16,26.36 15.3,25.65 12.74,25.65 12.31,25.65 12.31,25.65 9.59,25.65 9.42,25.82 7.14,25.82 6.59,25.28 6.59,23.4 7.1,22.89 7.1,21.67 7.28,21.49 7.28,20.78 7.13,20.63 6.63,20.63 6.09,21.17 6.09,22.27 5.5,22.86 D5501.2 4.33,22.15 4.55,21.94 4.55,21.35 5.39,20.5 5.39,16.84 4.72,16.17 SW10.L1
PWRBTN#_APS: length 9.5
  BOTTOM w0.127: v2(53.92,55.98) 52.69,55.98 51.66,54.96 51.06,54.96 50.77,54.67 50.77,53.86 49.93,53.02 P466.11 48.96,54.08 47.98,55.06 APR10.2
PWRBTN_J68_N: length 9.3
  TOP w0.102: v2(85.7,155.82) 85.7,155.48 84.87,154.65 84.25,154.65 84,154.9 84,155.06 83.79,155.26 R205.2 83.59,155.07 83.59,154.93 84.58,153.94 84.58,153.74 85.14,153.18 85.14,151.58 84.71,151.15 J68.21
PWRBTN_N: length 314.1
  TOP w0.089: U1.BE46 39.55,82.3 39.55,82.33 39.09,82.79 38.84,82.79 38.63,82.58 38.63,82.03 38.28,81.68 38.28,81.54
  TOP w0.127: v1(74.37,144.85) 74.37,143.97 76.02,142.32 76.02,140.33 74.48,138.78 v1(74.48,138.51) ; v1(33.76,77.35) 34.77,78.36 36.16,78.36 37.91,80.11 37.91,80.38 38.12,80.59 38.12,81.38 38.28,81.54 ; R205.1 84.43,155.48 v1(84.43,155.13) ; v1(14.58,57.52) 13.87,56.81 13.87,53.3 10.88,50.32 7.37,50.32 6.55,49.51 6.55,44.44 v1(6.93,44.06) 6.93,37.98 R207.2 ; v1(68.47,121.83) 68.73,121.83 70.26,120.31 70.26,119.8 70,119.55 70,117.23 70.26,116.98 71.27,116.98 71.68,117.39 74.61,117.39 75.13,116.87 76.01,116.87 77.6,115.29 77.6,113.82 HR96.2
  IN1 w0.127: v1(19.33,116.19) 19.12,115.98 19.12,114.42 17.59,112.88 17.59,110.62 18.26,109.95 18.26,108.32 18.98,107.6 18.98,102.44 19.86,101.56 19.86,95.29 20.29,94.85 20.29,94.71 v1(20.47,94.53) ; v1(14.58,57.52) 15.24,56.85 21.86,56.85 23.21,55.5 25.79,55.5 26.06,55.23 v1(27.89,55.23) 28.32,55.67 32.64,55.67 32.7,55.6 v1(33.25,55.6) ; v1(25.32,77.78) 27.76,77.78 29.1,76.44 31.16,76.44 31.87,77.16 33.56,77.16 v1(33.76,77.35)
  IN2 w0.127: v1(23.02,86.59) 23.02,87.54 22.69,87.86 22.69,89.46 v1(22.54,89.61) ; v1(37.64,134.81) 37.74,134.81 39.22,136.3 40.4,136.3 40.61,136.51 40.61,137.4 43.41,140.2 46.15,140.2 47.47,141.52 51.11,141.52 51.78,142.19 52.38,142.19 52.75,141.83 54.99,141.83 55.32,142.15 58.13,142.15 58.16,142.12 58.53,142.12 58.53,142.12 64.98,142.12 66.43,143.56 70.55,143.56 71.83,144.85 v1(74.37,144.85)
  BOTTOM w0.127: v1(19.33,116.19) 17.9,116.19 17.31,116.79 17.31,117.38 18.78,118.86 18.78,129.58 20.43,131.23 21.33,131.23 21.7,130.86 25.32,130.86 26.06,131.6 26.06,132.77 26.53,133.24 28.27,133.24 29.15,134.12 34.6,134.12 35.26,133.46 36.29,133.46 v1(37.64,134.81) ; v1(68.47,121.83) 68.64,122 69.58,122 69.87,122.29 69.87,122.65 69.59,122.93 69.3,122.93 68.98,123.25 68.98,123.67 69.28,123.97 71.05,123.97 71.27,124.19 71.27,125.17 69.24,127.21 69.24,128.25 70.74,129.75 70.74,134.3 74.48,138.04 v1(74.48,138.51) ; v1(84.43,155.13) 84.43,153.74 85.55,152.62 85.55,150.08 84.56,149.09 83.79,149.09 83.2,148.49 79.77,148.49 79.59,148.31 77.84,148.31 77.54,148.02 75.48,148.02 73.62,146.17 73.62,145.27 74.04,144.85 v1(74.37,144.85) ; v1(33.76,77.35) 33.76,76.52 32.15,74.92 32.15,73.57 31.37,72.78 31.37,68.17 30.88,67.69 30.88,65.37 27.66,62.14 v2(27.66,61.46) 27.66,60.54 26.93,59.81 26.48,59.81 26.17,59.5 26.17,55.83 26.77,55.23 v1(27.89,55.23) ; v1(33.25,55.6) 33.39,55.46 37.08,55.46 37.09,55.46 37.41,55.13 40.63,55.13 41.19,55.69 42.7,55.69 43.41,54.98 44.39,54.98 45.67,56.25 46.59,56.25 46.6,56.26 APR10.1 ; SR256.2 23.09,74.63 23.09,75.16 25.32,77.4 v1(25.32,77.78) 25.32,78.7 23.02,81.01 v1(23.02,86.59) ; v1(6.93,44.06) 7.18,43.82 10.47,43.82 11.02,44.36 11.02,45.33 10.79,45.56 HCB4.1 10.52,45.95 10.81,46.23 11.03,46.23 11.65,46.85 XDP3.41 ; v1(22.54,89.61) 22.34,89.82 21.88,89.82 21.49,90.21 O2CB15.1 SC23.1 21.49,91.46 21.91,91.88 U104.34 21.91,93.5 20.88,94.53 v1(20.47,94.53)
PWRBTN_R_N: length 24.3
  TOP w0.102: R207.1 5.98,36.18 v1(5.97,36.18)
  BOTTOM w0.102: SW10.B 3.58,17.05 4.84,18.31 4.84,20.2 v2(3.53,21.5) 2.91,22.13 D5503.2 3.4,23.33 3.4,25.54 3.68,25.82 3.68,33.9 v1(5.97,36.18)
PWROK3_1: length 192.8
  TOP w0.127: SR274.1 37.62,112.29 35.36,112.29 v1(34.74,112.91)
  IN1 w0.127: v1(69.85,106.59) 69.85,106.71 70.71,107.57 70.71,109.24 70.31,109.64 70.31,110.58 71.86,112.13 71.86,114.89 72.62,115.65 72.62,117.66 73.18,118.21 73.18,122.95 73.63,123.41 v1(73.63,129.11)
  IN2 w0.127: v1(73.63,129.11) 73.49,129.26 67.62,129.26 67.12,128.77 65.74,128.77 64.43,130.08 64.43,130.41 63.7,131.14 62.86,131.14 62.28,130.55 62.28,127.85 60.78,126.35 60.17,126.35 58.96,125.15 58.96,124.31 57.68,123.03 56.23,123.03 55.6,123.66 51.01,123.66 48.33,120.98 36.55,120.98 35.44,119.88 35.44,113.61 v1(34.74,112.91) 34.22,113.44 32.14,113.44 31.81,113.11 31.81,112.82 31.09,112.09 30.57,112.09 28.37,109.89 26.39,109.89 23.32,106.82 23.32,105.59 22.32,104.6 22.32,104.4 22.32,104.23 22.32,104.06 22.32,103.9 22.32,102.96 20.92,101.55 20.92,99.73 20.3,99.11 20.3,98.41 18.49,96.61 18.49,92.81 17.88,92.2 17.88,87.09 19.64,85.33 19.64,79.13 18.12,77.61 18.12,71.83 v1(18.62,71.33)
  BOTTOM w0.127: v1(69.85,106.59) 70.08,106.37 70.94,106.37 71.22,106.65 74.45,106.65 75.67,105.43 77.46,105.43 78.84,104.05 78.84,103.76 79.13,103.47 80.75,103.47 81.71,102.5 82.27,102.5 82.69,102.92 HR98.2 ; v1(18.62,71.33) 18.2,71.75 18.2,72.93 16.55,74.58 9.59,74.58 8.37,73.36 5.95,73.36 v2(5.79,73.52) 5.79,73.89 4.67,75.01 4.67,86.29 7.41,89.03 8.13,89.03 9.12,90.02 11.39,90.02 11.78,90.41 11.78,91.08 12.71,92 U104.57
Q2Q5_PWRGOD_PS: length 61.7
  TOP w0.102: v1(24.33,118.79) 24.09,118.54 24.09,117.46 24.79,116.76 v1(24.79,116.58)
  IN2 w0.102: v1(21.08,118.63) 21.08,119.01 21.96,119.89 21.96,120.16 21.96,120.33 23.5,121.87 23.5,122.35 24.34,123.2 24.34,125.73 24.43,125.81 24.43,128.22 25.54,129.33 29.12,129.33 30.73,130.94 30.73,132.03 32.06,133.36 36.1,133.36 36.78,134.04 36.78,134.91 37.54,135.68 v1(37.67,135.68)
  BOTTOM w0.102: v1(24.79,116.58) 25.09,116.58 25.92,115.75 26.04,115.75 27.1,114.68 27.36,114.68 27.63,114.41 27.63,114.04 28.08,113.59 28.08,112.94 O2CB21.1 27.65,110.98 27.02,110.35 PQ93030.3 ; v1(24.33,118.79) 21.24,118.79 v1(21.08,118.63) ; v1(37.67,135.68) 38.84,134.51 v2(38.84,134.08) 39.03,133.89 R99536.2 41.58,134.33 41.43,134.48 39.82,134.48 38.56,135.75 38.56,136.16 40.45,138.05 ECR159.1 42.23,138.05 42.44,137.84 AC208.1 43.66,137.84 43.92,137.58 43.92,135.98 43.53,135.6 O2Q5.2
Q7201_G: length 5
  TOP w0.254: R7202.2 6.97,67 v1(6.69,67)
  BOTTOM w0.254: Q7201.1 7.48,68.6 7.22,68.34 6.97,68.34 6.72,68.09 C7208.2 6.72,67.07 6.69,67.05 v1(6.69,67) 6.72,66.97 6.72,65.86 v2(6.58,65.73)
Q9434_PIN3: length 8.5
  TOP w0.102: Q9435.1 30.04,52.95 29.64,53.35 29.64,54.38 R70291.1 29.72,55.32 29.72,56.08 v2(29.21,56.59) 29.21,56.98 30.07,57.84 30.07,58.61 30.63,59.17 Q9434.3
Q9436_PIN3: length 7.9
  BOTTOM w0.102: Q9436.3 32.74,31.1 33.74,30.11 v2(33.74,29.89) Q9437.1 32.5,28.75 31.72,29.53 30.19,29.53 R70293.1
Q9534_3: length 106.4
  TOP w0.102: R70300.2 83.51,73.6 v1(83.21,73.9)
  TOP w0.127: Q9534.3 31.57,29.58 32.29,30.3 R6502.2 31.7,31.3 R99529.1 31.7,31.64 32.26,32.2 32.74,32.2 33.92,33.38 33.92,37.32 v2(32.99,38.24) C941648.1 31.47,39.18 32.38,40.1 32.38,43.42 31.88,43.93 31.88,45.13 31.41,45.6 29.85,45.6 29.02,46.43 29.02,46.7 28.61,47.11 28.61,47.78 29.09,48.26 v1(29.09,49.23)
  IN2 w0.127: v1(83.21,73.9) 83.21,64.89 77.56,59.25 72.23,59.25 63.85,50.87 63.85,49.48 56.63,42.26 54.35,42.26 53.97,41.87 52.1,41.87 51.74,42.23 48.08,42.23 47.37,42.94 46.3,42.94 45.82,43.42 45.21,43.42 44.38,44.25 42.59,44.25 40.78,46.07 38,46.07 37.62,46.45 36.02,46.45 35.28,47.18 34.89,47.18 33.45,48.62 32.39,48.62 31.79,49.23 v1(29.09,49.23)
  BOTTOM w0.102: R99528.1 82.35,74.07 82.52,73.9 v1(83.21,73.9)
Q93033_PIN2: length 3.4
  TOP w0.102: Q93033.2 133.15,166.7 C941625.1 R93102.2 133.36,164.75 v2(133.2,164.58)
Q93033_PIN3: length 4.7
  TOP w0.102: v1(133.91,164.71) 133.75,164.86 133.75,166.26 133.89,166.4 R93098.2 133.8,166.89 Q93033.3
  BOTTOM w0.102: v1(133.91,164.71) 133.39,164.71 v2(133.15,164.95)
Q93033_PIN4: length 1.5
  TOP w0.102: Q93033.4 134.73,170.22 R93101.1
Q93034_P3: length 12.9
  BOTTOM w0.102: v2(117.45,39.29) 117.57,39.16 R93106.2
  BOTTOM w0.254: Q93034.3 110.21,36.93 110.69,36.44 Q93035.3 114.33,37.34 114.93,37.93 R93108.1 R93107.2 117.24,36.69 117.57,37.02 R93106.2
Q93034_P12567: length 1.2
  BOTTOM w0.254: R93104.1 111.85,40.36
  vias: v2(111.66,40.81)
Q93034_PIN8_4: length 1.6
  BOTTOM w0.254: R93109.1 109.37,41.7 109.42,41.65
  vias: v2(109.83,41.42)
Q93035_PIN1: length 4.3
  BOTTOM w0.254: v2(115.49,40.48) 115.11,40.1 114.18,40.1 R93104.2 ; R93104.2 113.38,39.83 Q93035.1 ; R93104.2 113.92,41.32 R93105.2
R_HPOUT_L: length 16.7
  TOP w0.254: AR22.2 23.97,13.23 v1(24.23,12.97) ; v1(34.59,13.16) C4306.1 33.02,13.16 D4307.2 33.6,12.07 J301.1
  IN1 w0.254: v1(24.23,12.97) 24.61,13.35 24.92,13.35 24.96,13.39 34.15,13.39 34.38,13.16 v1(34.59,13.16)
R_HPOUT_R: length 14.4
  TOP w0.254: AR23.2 24.67,16.17 v2(24.99,16.17) 25.22,15.94 C4305.1 25.22,13.72 25.08,13.58 D4306.2 25.08,9.82 26.4,8.51 26.4,5.46 26.1,5.16 J301.2
R_SPI_CK: length 29.2
  TOP w0.127: E61.16 59.39,75.25 58.75,75.9 57.52,75.9 57.1,75.48 U9434.6 57.1,74.11 57.58,73.62 58.88,73.62 59.03,73.47 63.52,73.47 63.98,73.01 63.98,72.5 64.61,71.87 64.63,71.87 F3R11.2 65.73,70.77 65.73,69 66.22,68.52 66.24,68.52 v1(66.67,68.09) 67.23,67.53 67.23,65.44 67.73,64.95 67.73,64.73 69.71,62.75 70.33,62.75 70.89,62.19 J303.6
  BOTTOM w0.127: v1(66.67,68.09) 66.98,67.78 v2(66.98,67.27)
R_SPI_CS0#_E56: length 43.4
  TOP w0.127: F3R7.2 48.4,67.36 48.31,67.45 47.98,67.45 47.56,67.87 47.56,68.25 48.44,69.13 49.07,69.13 49.4,69.46 49.4,70.12 49.58,70.3 50.21,70.3 50.42,70.09 50.42,67.76 50.54,67.63 U9435.7 E61.7 52.81,67.63 52.93,67.76 52.93,68.29 53.06,68.42 53.73,68.42 53.86,68.29 53.86,66.73 53.97,66.61 54.23,66.61 54.56,66.94 U9434.1 54.56,68.63 54.67,68.75 54.67,68.89 55.33,69.55 55.69,69.55 56.56,68.67 56.56,66.58 57.1,66.04 59.98,66.04 60.15,65.88 62.46,65.88 62.7,66.12 63.87,66.12 64.51,65.47 64.51,60.24 v2(64.87,59.88) 65.56,59.2 66.38,59.2 67.82,57.76 67.82,56.13 67.94,56 68.22,56 68.35,56.13 J303.1
R_SPI_IO0: length 23.4
  TOP w0.127: U9434.5 59.09,74.78 59.89,73.98 E61.15 U9435.15 63.73,73.98 64.49,73.22 64.49,72.72 F3R10.2 64.84,72.38 65.42,71.8 65.47,71.8 66.27,70.99 66.27,69.97 66.88,69.36 66.88,68.67 67.74,67.8 67.74,65.65 68.24,65.16 68.24,64.94 69.92,63.26 71.09,63.26 v1(71.37,62.98) 72.16,62.19 J303.8
  BOTTOM w0.127: v1(71.37,62.98) 71.37,63.44 v2(71.14,63.67)
R_SPI_IO1: length 52.1
  TOP w0.127: J303.3 69.62,56.53 68.71,55.62 67.79,55.62 67.44,55.97 67.44,57.61 66.3,58.74 63.45,58.74 v2(63.3,58.89) 63.3,59.64 64.03,60.38 64.03,62.86 63.47,63.42 63.47,65.54 63.27,65.74 62.86,65.74 62.61,65.5 59.97,65.5 59.8,65.66 56.94,65.66 55.83,66.78 U9434.2 55.83,68.53 55.7,68.66 55.17,68.66 55.04,68.53 55.04,66.08 55.17,65.95 56.08,65.95 56.34,65.69 56.34,65.51 56.17,65.34 54.63,65.34 54.53,65.45 54.53,66.13 54.46,66.21 54.23,66.21 54.02,66 53.82,66 53.47,66.36 53.47,67.11 53.34,67.24 53,67.24 52.91,67.15 52.91,66.54 52.73,66.36 E61.8 U9435.8 50.49,66.36 50.37,66.49 50.37,66.64 50.54,66.82 50.54,67 50.37,67.17 50.16,67.17 49.96,66.97 49.83,66.97 49.68,67.12 49.68,67.38 50.04,67.73 50.04,69.11 49.92,69.23 49.71,69.23 49.54,69.06 49.54,67.88 49.43,67.78 49.15,67.78 49.02,67.91 49.02,68.57 48.87,68.72 48.57,68.72 48.08,68.23 48.08,67.99 48.21,67.86 48.46,67.86 48.8,67.52 48.8,66.58 48.69,66.46 48.44,66.46 48.33,66.36 48.33,66.25 F3R8.2
R_SPI_IO2_R: length 23.4
  TOP w0.127: J303.5 70.89,58.51 69.62,59.78 67.49,59.78 v2(66.09,61.18) 65,62.27 65,64.56 65.38,64.94 65.38,65.52 65.25,65.65 64.93,65.65 64.49,66.08 64.49,66.22 F3R9.2 64.12,66.96 63.9,67.17 63.27,67.17 63.12,67.02 63.12,66.66 62.97,66.51 62.55,66.51 62.4,66.36 U9435.9 E61.9 60.55,66.36 60.25,66.66 60.25,66.94 59.92,67.27 59.61,67.27 58.76,66.42 57.57,66.42 57.1,66.89 U9434.3
R_SPI_IO3_R: length 49.3
  TOP w0.127: F3R12.2 48,70.53 49.6,72.13 49.88,72.13 50.16,72.41 50.16,73.01 49.78,73.4 49.78,73.88 50.49,74.59 50.49,75.15 50.6,75.25 U9435.1 E61.1 52.27,75.25 52.73,74.79 53.69,74.79 54.08,75.17 54.08,75.79 54.18,75.9 55.38,75.9 55.83,75.45 55.83,75.4 ; 55.83,75.4 56.11,75.68 56.5,75.68 57.54,76.72 61.24,76.72 61.55,76.41 61.6,76.41 62.51,75.5 62.51,75.03 63.13,74.41 63.88,74.41 64.44,73.85 66.33,73.85 66.47,73.71 66.47,72.41 67.51,71.37 67.51,68.57 68.12,67.96 68.12,65.81 68.62,65.31 68.62,65.1 70.05,63.67 72.1,63.67 72.61,64.18 v2(72.92,64.18) 72.92,63.77 72.69,63.54 72.69,59.91 72.59,59.8 70.21,59.8 69.62,60.39 J303.4 ; 55.83,75.4 U9434.7
REGOUT:
  vias: v1(21.49,141.14) v1(21.79,141.7) v2(22.27,140.43)
RING2: length 29.7
  TOP w0.229: U6.17 14.98,22.44 14.98,22.44 14.62,22.44 v1(14.21,22.86)
  IN2 w1.016: 36.3,16.91 35.94,17.26 33.48,17.26 32.47,16.26 28.91,16.26 28.4,16.77 24.33,16.77 23.25,15.69 20.67,15.69 17.88,18.48 15.94,18.48 15.51,18.04 14.61,18.04 14.09,18.56 14.09,19.57 14.65,20.13 14.65,22.03
  vias: v1(13.57,22.86) v1(36.02,16.35) v1(36.68,16.35) v2(36.22,17.13)
RING2_B: length 10
  TOP w1.016: J301.3 33.5,3.44 32.75,4.19 32.75,6.65 35.21,9.12
  BOTTOM w0.254: v1(38.46,15.44) v2(37.49,15.44)
RSM_RST#: length 289.3
  TOP w0.089: U1.BA47 41.46,81.42 41.46,81 41.5,80.96 41.5,80.33 40.99,79.82
  TOP w0.127: 40.99,79.82 40.03,78.86 v1(40.03,78.5)
  IN2 w0.127: v1(87.92,127.38) 87.92,125.86 88.72,125.06 88.72,123.08 88.97,122.83 88.97,122.44 88.54,122.01 88.54,121.78 87.76,121 87.6,121 87.35,120.74 87.35,118.35 v1(87.5,118.2) ; v1(80.72,147.28) 79.91,146.47 78.68,146.47 77.21,147.94 70.33,147.94 69.57,147.18 62.63,147.18 62.58,147.23 61.92,147.23 60.54,145.85 59.28,145.85 58.59,145.16 54.43,145.16 54.22,145.37 52.31,145.37 51.34,144.4 45.42,144.4 44.22,143.2 43.14,143.2 39.9,139.96 38.24,139.96 37.36,139.08 37.36,138.62 35.54,136.8 33.17,136.8 31.89,135.52 31,135.52 30.01,134.53 29.04,134.53 27.64,133.14 26.24,133.14 22.36,129.26 22.36,127.33 21.72,126.69 20.26,126.69 19.4,125.82 19.4,125.54 19.34,125.49 19.34,125.17 16.03,121.86 16.03,121.61 10.62,116.2 10.62,112.98 11.66,111.94 11.66,110.28 8.98,107.61 8.98,101.21 11.02,99.17 11.02,98.02 11.1,97.94 11.1,95.14 v1(11.76,94.48) 11.07,93.79 11.07,93.31 8.85,91.09 8.85,87.07 8.66,86.88 8.66,86.88 6.72,84.94 6.69,84.91 6.69,79.63 9.26,77.06 9.59,76.73 9.59,72.9 10.01,72.48 10.01,72.48 10.26,72.23 10.26,70.52 11,69.78 11,56.85 11.42,56.42 11.85,56.42 12.55,57.11 13.23,57.11 16.83,53.52 16.83,50.79 19.28,48.34 23.95,48.34 24.42,47.87 v1(24.71,47.87)
  BOTTOM w0.127: v1(40.03,78.5) 39.86,78.32 39.7,78.32 39.52,78.5 SC27.1 SR290.1 40.69,78.84 40.69,77.65 40.5,77.47 40.5,76.66 38.17,74.33 38.17,70.99 38.45,70.71 38.45,67.02 37.54,66.1 37.54,65.67 36.7,64.84 36.27,64.84 35.15,63.72 35.15,62.6 v2(34.39,61.84) 33.37,60.82 31.82,60.82 30.95,59.95 30.95,58.34 30.47,57.87 30.47,57.29 29.71,56.52 29.71,52.7 30.3,52.11 30.3,50.72 29.77,50.18 28.88,50.18 28.09,50.97 27.55,50.97 24.71,48.13 v1(24.71,47.87) 24.31,47.46 24.31,44.69 24.38,44.62 24.38,43.78 24.2,43.6 23.94,43.6 23.44,43.1 19.96,43.1 19.31,43.75 13.01,43.75 SR162.2 ; v1(87.92,127.38) 87.92,127.75 87.35,128.32 87.35,129.25 86.71,129.89 86.71,134.03 82.17,138.57 78.95,138.57 77.88,139.64 77.88,142.33 78.08,142.52 78.08,143.97 78.55,144.44 78.55,145.62 80.21,147.28 v1(80.72,147.28) ; v1(11.76,94.48) 12.31,93.93 U104.58 ; v1(87.5,118.2) 87.5,117.41 83.18,113.09 83.18,112.08 82.85,111.75 82.85,110.58 81.94,109.67 HR374.1
