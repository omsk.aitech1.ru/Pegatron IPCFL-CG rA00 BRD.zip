# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
OC1#_R: length 8
  BOTTOM w0.102: v2(22.83,58.89) 22.53,59.19 21.3,59.19 20.88,58.77 20.88,58.04 SR750.2 20.3,56.49 19.15,55.34 XDP3.12
OC2#_R: length 4.5
  BOTTOM w0.102: SR751.2 19.36,57.11 19.54,56.94 v2(19.54,56.56) 19.11,56.12 18.85,56.12 18.15,55.43 XDP3.16
OC3#_R: length 6.6
  BOTTOM w0.102: XDP3.18 17.65,55.23 18.35,55.93 SR752.2 18.87,57.99 18.87,58.54 19.52,59.19 v2(19.94,59.19)
P216_2: length 15.7
  TOP w0.102: v1(50.11,142.2) 49.36,141.46 R79.1
  BOTTOM w0.102: JMP1.2 52.27,153.01 52.97,152.31 52.97,150.29 53.57,149.69 53.57,147.36 50.52,144.31 50.52,143.27 50.11,142.86 v1(50.11,142.2)
P217_R: length 2.8
  TOP w0.102: SR123.1 48.55,147.03 JMP1.5
PC_SPKR_DET: length 225
  TOP w0.102: v1(51.79,45.94) 51.79,45.07 52.2,44.67 52.2,41.87 54.96,39.11 54.96,27.68 v1(55.47,27.17)
  IN1 w0.102: v1(92.56,32.63) 92.56,33.58 96.37,37.39 100.39,37.39 100.65,37.14 103.15,37.14 103.36,37.34 119.75,37.34 121.15,38.74 141.9,38.74 142.68,39.52 148.86,39.52 158.93,49.6 v1(160.21,49.6)
  IN2 w0.102: v1(51.79,45.94) 50.68,47.04 50.68,51.02 49.82,51.89 49.82,53.2 50.51,53.9 50.51,54.47 50.12,54.86 50.02,54.96 49.15,54.96 48.83,54.64 46.33,54.64 46.04,54.93 46.04,55.65 48.35,57.97 48.35,62.18 46.6,63.93 46.6,65 43.92,67.68 43.92,67.75 42.59,69.08 39.89,69.08 39.19,69.78 39.19,72.54 38.09,73.65 38.09,77.32 37.65,77.75 37.65,78.14 38.07,78.56 38.07,80.38 38.34,80.65 38.34,82.68 38.34,82.69 38.34,86.96 38.92,87.55 38.92,92.97 37.67,94.22 37.67,94.8 v1(37.31,95.16)
  BOTTOM w0.102: v1(55.47,27.17) 56.81,28.5 56.81,29.77 61.29,34.25 67.13,34.25 67.79,33.59 71.32,33.59 75.16,29.76 75.16,25.85 75.58,25.43 81.7,25.43 81.85,25.58 v2(85.27,25.58) 87.72,25.58 89,26.86 90.07,26.86 90.39,27.18 91.88,28.68 91.88,30.43 92.56,31.1 v1(92.56,32.63) ; P6.3 165.4,59.2 165.4,54.8 v1(160.21,49.6) ; v1(37.31,95.16) 36.76,95.16 36.55,95.37 36.33,95.37 SR7979.2
PC_SPKR_DET_R: length 7.8
  TOP w0.089: 39.22,94.73 39.46,94.49 U1.BF21
  TOP w0.102: 39.22,94.73 38.78,95.17 38.01,95.17 37.49,95.7 v1(36.92,95.7) 36.61,96 v2(36.24,96)
  BOTTOM w0.102: SR7941.2 34.05,96.21 34.23,96.21 34.56,95.87 34.99,95.87 SR7979.1 35.72,96.1 36.51,96.1 v1(36.92,95.7)
PC_SPKR_DET_SIO: length 5.2
  TOP w0.102: v1(13.45,93.98) 13.3,93.83 OR118.1 ; OR153.2 12.4,92.75 12.54,92.89 12.88,92.89 OR118.1 ; OR118.1 13.87,93.31 v2(14.28,93.72)
  BOTTOM w0.102: v1(13.45,93.98) 13.91,93.52 U104.54
PCBEEP_U6: length 12.1
  TOP w0.102: AC205.2 10.51,25.22 v1(10.63,25.1) 11.02,25.5 15.1,25.5 15.69,24.9 U6.12
  BOTTOM w0.102: v2(7.19,23.59) 6.79,23.98 6.79,24.95 7.36,25.51 9.12,25.51 9.53,25.1 v1(10.63,25.1)
PCH_AUD_MUTE: length 118.8
  TOP w0.127: v1(49.07,79.26) 49.07,80.66 48.8,80.93 48.8,81.48 U1.AF47 ; v1(24.89,50.71) 25.17,50.43 25.17,39.49 23.6,37.91 23.6,32.53 21.44,30.38 v1(20.99,30.38) 20.99,29.3 SR280.2
  IN1 w0.127: v1(50.31,73.55) 51.15,74.4 51.15,75.38 50.88,75.65 50.88,77.28 50.27,77.89 50.27,78.07 v1(49.07,79.26) ; v1(55.57,49.99) 53.17,47.59 51.81,47.59 51.36,47.13 44.09,47.13 42.6,45.63 41.83,45.63 40.88,46.58 39.3,46.58 38.04,47.84 37.36,47.84 35.89,49.32 33.78,49.32 33.22,49.88 29.95,49.88 29.57,50.26 29.55,50.26 29.49,50.32 28.91,50.32 28.26,50.97 27.43,50.97 26.97,50.51 25.09,50.51 v1(24.89,50.71)
  IN2 w0.127: v1(50.31,73.55) 50.61,73.85 56.66,73.85 57.44,73.07 57.44,72.43 58.34,71.53 58.34,69.76 57.91,69.32 57.91,66.94 59.57,65.28 60.86,65.28 60.93,65.21 60.93,64.56 60.53,64.16 60.53,63.01 60.74,62.79 60.74,62.11 60.92,61.93 60.92,56.81 59.06,54.96 58.71,54.96 58.3,54.55 58.3,53.27 56.26,51.22 56.26,50.68 v1(55.57,49.99)
  BOTTOM w0.127: AR36.1 27.85,21.27 26.62,22.49 24.58,22.49 23.9,23.18 23.9,24.53 22.74,25.69 22.74,26.96 22.55,27.14 21.67,27.14 21.03,27.78 v2(21.03,29.1) 21.03,30.28 20.99,30.32 v1(20.99,30.38)
PCH_C1: length 7.7
  TOP w0.089: U1.BC1 40.53,104.56 39.98,104.56 39.33,105.21 39.01,105.21
  TOP w0.102: 39.01,105.21 38.23,105.21 37.75,104.73 v1(37.75,104.7)
  BOTTOM w0.102: ST16.1 37.52,105.91 37.93,105.5 37.93,104.88 v1(37.75,104.7)
PCH_CHAR_CTL3: length 18.2
  TOP w0.102: U1.N48 55.86,81.12 55.9,81.08 55.9,79.09 56.84,78.16 57.24,78.16 57.66,78.58 59.13,78.58 59.14,78.59 59.14,78.59 59.54,78.98 v1(60.73,78.98) 62.75,78.98 63.35,79.58 63.35,80.7 63.78,81.13 64.22,81.13 64.46,80.89 64.46,80.88 64.65,80.7 64.98,80.7 65.21,80.47 SR7956.2
  BOTTOM w0.102: v1(60.73,78.98) 60.93,78.98 61.7,78.22 61.95,78.22 v2(62.23,77.94)
PCH_CLK_TO_LPC: length 3
  TOP w0.127: v1(41.19,87.28) 41.27,87.36 41.27,88.02 U1.BB34
  BOTTOM w0.127: SR24.2 40,87.53 40.13,87.66 41.06,87.66 41.19,87.53 v1(41.19,87.28)
PCH_CPUPWRGD: length 9.6
  TOP w0.089: 49.57,103.93 49.57,103.88 49.5,103.81 49.5,103.4 49.58,103.32 U1.AE3
  TOP w0.127: SR275.1 49.63,111.58 v2(49.63,110.61) 49.76,110.48 SC86.1 49.68,109.64 49.68,107.53 50.37,106.85 50.37,106.19 50.06,105.88 50.06,105.17 49.57,104.68 49.57,103.93
PCH_D1: length 2.8
  TOP w0.102: v1(48.87,98.54) 48.79,98.54 U1.AH14
  BOTTOM w0.102: ST17.1 49.54,99.44 48.87,98.77 v1(48.87,98.54)
PCH_DSW_PWROK: length 151.2
  TOP w0.127: v1(18.59,67.63) 18.5,67.72 13.3,67.72 11.49,65.91 v1(10.2,65.91) ; SR286.2 34.54,63.36 34.67,63.49 SR289.1 34.63,63.87 32.52,63.87 SC83.1 31.86,63.69 30.05,63.69 29.67,63.31 v2(27.86,63.31) 26.82,63.31 26.46,63.67 25.85,63.67 24.99,62.81 v1(24.99,62.38) ; U1.AW41 43.26,84.63 v1(43.33,84.7) ; v1(52.59,46.31) 52.53,46.37 51.61,46.37 51.36,46.12 51.36,44.99 51.95,44.39 51.95,42.19 51.59,41.82 51.13,41.82 v1(51.1,41.8)
  IN1 w0.127: v1(51.1,41.8) 47.47,41.8 46.51,40.83 42.52,40.83 42.17,41.19 38.14,41.19 37.55,40.6 37.17,40.21 33.54,40.21 33.16,39.83 27.4,39.83 26.88,40.35 25.89,41.34 21.4,41.34 18.05,44.69 15,44.69 9.07,50.63 9.07,50.99 9.44,51.36 9.44,53.29 6.85,55.88 6.85,56.69 9.05,58.88 9.05,59.89 9.52,60.37 9.52,65.23 v1(10.2,65.91) ; v1(24.99,62.38) 24.99,62.41 24.27,63.13 22.6,63.13 20.71,65.03 20.71,65.76 18.86,67.6 18.62,67.6 v1(18.59,67.63)
  IN2 w0.127: v1(52.59,46.31) 52.36,46.54 52.36,48.51 54.53,50.69 54.53,52.49 55.75,53.71 55.75,54.48 56.16,54.89 56.16,55.51 57.35,56.71 57.35,58.21 54.6,60.96 54.6,66.02 52.42,68.19 52.42,69.14 49.89,71.67 49.54,71.67 49.53,71.67 48.55,71.67 45.5,74.72 45.5,76.59 45.24,76.85 44.4,76.85 44.08,77.17 44.08,78.96 43.82,79.22 43.82,80.14 43.07,80.89 43.07,83.19 43.27,83.38 43.27,83.82 43.41,83.96 43.41,84.62 v1(43.33,84.7)
PCH_F_CHAR_CTL2: length 33.3
  TOP w0.102: v1(49.13,82.35) 49.58,81.9 U1.AE47
  IN1 w0.102: v1(46.24,76.19) 46.71,76.66 46.71,79.2 48.19,80.67 48.19,81.4 v1(49.13,82.35)
  BOTTOM w0.102: v1(46.24,76.19) 45.82,75.77 45.82,75.38 46.13,75.08 46.13,74.07 47.33,72.87 47.33,72.74 48.47,71.6 48.47,70.74 50.05,69.16 50.05,68.25 50.86,67.43 53.76,67.43 54.28,66.91 57.05,66.91 v2(57.42,67.28) 57.67,67.53 61.85,67.53 62.23,67.15 63.69,67.15 SR237.2
PCH_GPIO26_R_C: length 4.4
  BOTTOM w0.102: Q1.2 27,65.08 27.54,65.62 27.6,65.62 SR134.2 28.43,65.92 28.93,66.41 v2(28.93,66.84)
PCH_HEATSINK_DET: length 7.3
  TOP w0.102: JP2802.2 JP2802.1 34.33,65.62 SR7988.1
PCH_HEATSINK_DET_R: length 29.8
  TOP w0.102: SR7988.2 35.61,66.07 v1(35.61,67.38) ; U1.AN37 45.89,86.77 v1(45.53,86.41)
  IN1 w0.102: v1(39.19,77.44) 39.22,77.41 41.6,77.41 41.72,77.52 41.72,79.76 44.67,82.72 44.67,83.65 45.04,84.02 45.09,84.02 45.83,84.76 45.83,86.11 v1(45.53,86.41)
  BOTTOM w0.102: v1(45.53,86.41) 45.9,86.78 SR406.2 ; v1(39.19,77.44) 38.98,77.44 36.75,75.21 v2(36.75,74.62) 36.75,73.78 37.06,73.47 37.06,68.24 36.19,67.38 v1(35.61,67.38)
PCH_JTAG_TCK: length 171.1
  TOP w0.102: U1.AJ3 48.1,103.26 48.1,103.78 48.06,103.83 48.06,104.47 48.19,104.61 48.19,105.95 47.39,106.76 v1(47.39,107.03) ; v1(75.51,109.44) 75.42,109.53 75.42,111.98 75.65,112.22 75.7,112.22 v1(76.01,112.52)
  IN2 w0.102: v1(21.36,58.66) 20.25,59.76 20.25,63.12 19.95,63.43 19.95,67.97 19.29,68.63 19.29,70.36 19.65,70.73 19.65,71.76 18.97,72.44 18.97,77.26 20.49,78.78 20.49,85.68 18.92,87.25 18.92,87.6 19.37,88.04 19.37,89.99 19.82,90.44 19.82,92.94 19.89,93 20.05,93.17 20.05,94.77 19.61,95.21 19.61,96.52 21.15,98.06 21.15,98.75 21.77,99.37 21.77,101.2 23.18,102.61 23.18,104.08 23.18,104.25 24.17,105.24 24.17,105.32 24.17,105.32 24.17,106.03 24.17,106.46 25.78,108.08 26.91,108.08 27.75,108.92 28.61,108.92 28.85,109.16 29.04,109.16 30.07,109.17 31.72,110.82 31.72,110.89 32.78,111.94 34.14,111.94 34.23,111.85 38.43,111.85 38.99,111.29 39.82,111.29 40.8,110.31 41.83,110.31 43.09,109.05 46.28,109.05 47.39,107.95 v1(47.39,107.03)
  BOTTOM w0.102: HR370.2 79.11,104.14 77.58,105.67 76.15,105.67 75.83,105.99 75.83,106.4 75.96,106.53 75.96,108.99 v1(75.51,109.44) ; v1(47.39,107.03) 47.39,107.75 47.54,107.9 47.54,108.41 47.67,108.55 47.67,109.57 47.89,109.79 47.89,111.15 48.16,111.42 48.68,111.42 49.45,112.19 49.45,113.17 v2(50.04,113.76) 50.45,114.17 54.39,114.17 54.83,114.61 56.68,114.61 57.12,115.05 58.49,115.05 63.6,120.16 65.6,120.16 67.21,121.78 67.59,121.78 68.25,121.11 69.32,121.11 70.06,121.84 73.4,121.84 74.25,121 74.73,121 76.36,119.37 76.36,118.9 76.68,118.58 76.68,113.2 v1(76.01,112.52) ; v1(21.36,58.66) 21.82,58.2 21.82,57.64 22.07,57.4 22.07,52.68 21.95,52.56 21.86,52.47 17.51,52.47 15.26,50.23 14.27,50.23 13.17,51.34 11.87,51.34 11.39,51.82 9.12,51.82 8.15,50.85 XDP3.55 8.15,46.75 8.68,46.22 SR151.1
PCH_JTAG_TDI: length 195.2
  TOP w0.102: v1(17.86,132.86) 18.73,131.99 21.64,131.99 23.67,129.96 34,129.96 34.19,130.15 35.67,130.15 35.79,130.27 v1(36.24,130.27) ; v1(46.56,113.02) 45.92,112.38 44.81,112.38 44.43,112.01 44.43,110.91 SR173.2 45.35,110.49 45.41,110.43 45.41,110.21 45.85,109.78 45.85,109.59 45.93,109.51 45.93,108.68 SR765.2 46.74,107.87 47.37,107.87 47.89,107.35 47.89,106.54 48.4,106.04 48.4,104.52 48.26,104.38 48.26,104.13 48.41,103.98 U1.AH2
  IN1 w0.102: v1(6.21,60.86) 6.3,60.94 6.3,61.36 v1(4.82,62.83) ; v1(17.86,132.86) 16.59,131.59 14.66,131.59 13.64,132.6 11.48,132.6 9.42,130.55 6.9,130.55 3.47,127.11 3.47,111.89 4.15,111.2 4.15,108.71 2.5,107.06 2.5,68.66 v1(4.85,66.31) ; v1(36.24,130.27) 36.02,130.27 35.34,129.59 35.34,125.47 39.17,121.64 45.48,121.64 46.73,120.39 46.73,113.2 v1(46.56,113.02)
  IN2 w0.102: v1(81.58,125.57) 80.69,125.57 79.37,126.89 71.2,126.89 69.87,125.55 66.42,125.55 64.47,123.61 61.31,123.61 59.42,121.72 55.27,121.72 55.06,121.52 51.6,121.52 46.56,116.48 v1(46.56,113.02)
  BOTTOM w0.102: v1(4.85,66.31) v2(4.85,65.04) 4.85,62.85 v1(4.82,62.83) ; v1(81.58,125.57) 82.28,125.57 83.57,124.28 HR372.2 ; v1(6.21,60.86) 5.93,60.57 5.93,59.09 SR775.1
PCH_JTAG_TDI_R: length 18.9
  TOP w0.102: v2(7.34,68.7) 6.2,67.55 6.2,66.79 7.09,65.9 7.09,64.51 8.1,63.49 8.1,60.95 7.26,60.11 7.26,57.04 v1(7.57,56.73)
  BOTTOM w0.102: XDP3.56 8.15,54.84 7.9,55.09 7.73,55.09 6.87,55.95 6.87,56.3 7.11,56.55 7.38,56.55 v1(7.57,56.73) 7.21,57.09 7.09,57.09 SR775.2
PCH_JTAG_TDO: length 102.2
  TOP w0.102: U1.AH3 48.69,103.58 48.69,103.95 48.88,104.14 48.88,105.05 49.24,105.4 49.24,105.75 48.8,106.19 48.54,106.19 48.1,106.63 48.1,107.43 SR766.2 47.7,108.7 47.7,109.59 SR764.2 SR158.2 45.84,110.1 46.18,109.77 v1(46.28,109.77)
  IN2 w0.102: v1(19.43,61.55) 19.85,61.97 19.85,62.95 19.54,63.26 19.54,67.8 18.88,68.46 18.88,70.53 19.25,70.89 19.25,71.59 18.57,72.27 18.57,77.43 20.09,78.95 20.09,85.51 18.32,87.27 18.32,92.02 19.65,93.34 19.65,94.52 19.1,95.06 19.1,96.59 20.74,98.23 20.74,98.92 21.36,99.54 21.36,101.37 22.77,102.78 22.77,104.08 22.77,104.08 22.77,104.25 22.77,104.42 23.76,105.41 23.76,105.49 23.76,106.63 26.58,109.45 28.56,109.45 28.68,109.57 28.88,109.57 30.95,111.65 31.28,111.65 32.26,112.63 32.26,112.93 32.32,112.99 33.42,112.99 34.07,112.35 34.35,112.35 34.45,112.25 38.6,112.25 39.16,111.7 39.99,111.7 40.97,110.72 42,110.72 43.26,109.46 43.61,109.46 44.24,110.1 45.95,110.1 v1(46.28,109.77)
  BOTTOM w0.102: v1(19.43,61.55) 19.21,61.33 v2(18.34,61.33) 17.93,61.74 16.78,61.74 15.66,60.62 7.37,60.62 7.13,60.38 7.06,60.38 SR768.1
PCH_JTAG_TDO_R: length 8.7
  BOTTOM w0.102: XDP3.52 9.15,55.29 8.08,56.36 8.08,57.02 SR767.2 7.14,57.96 7.14,58.65 SR768.2 6.54,59.13 6.23,59.44 6.23,60.27 6.84,60.88 v2(6.92,60.88)
PCH_JTAG_TMS: length 153.6
  TOP w0.089: 47.85,103.44 47.66,103.25 47.66,102.89 U1.AJ4
  TOP w0.102: HR384.2 81.41,119.45 81.58,119.27 82.21,119.27 82.46,119.02 82.46,118.68 82.21,118.43 81.38,118.43 80.31,119.5 78.66,119.5 76.25,121.91 v1(73.94,121.91) ; 47.85,103.44 47.85,104.55 47.99,104.69 47.99,105.83 46.91,106.91 v1(46.91,107.45) 46.44,107.45 45.72,108.18 45.72,109.36 45.64,109.44 45.64,109.69 45.23,110.1 44.32,110.1 SR153.2
  IN2 w0.102: v1(21.2,62.51) 21.2,62.96 20.55,63.62 20.55,68.16 19.85,68.86 19.85,70.13 20.55,70.83 20.55,72.78 20.01,73.32 20.01,77.89 20.7,78.57 20.7,85.76 19.12,87.34 19.12,87.51 19.57,87.96 19.57,89.9 20.03,90.36 20.03,92.86 20.89,93.72 20.89,94.97 20.5,95.37 20.5,97.12 21.35,97.98 21.35,98.67 21.97,99.29 21.97,101.11 23.38,102.52 23.38,104.16 24.37,105.15 24.37,105.24 24.37,106.38 25.87,107.88 26.99,107.88 27.84,108.72 28.69,108.72 28.93,108.96 29.13,108.96 29.13,108.96 30.15,108.96 31.93,110.74 31.93,110.8 32.86,111.74 34.06,111.74 34.15,111.64 38.35,111.64 38.91,111.09 39.74,111.09 40.72,110.11 41.75,110.11 43.01,108.85 46.2,108.85 46.91,108.14 v1(46.91,107.45)
  BOTTOM w0.102: SR776.1 5.78,58.85 5.73,58.9 5.73,60.96 6.14,61.37 7.88,61.37 8.43,60.82 15.58,60.82 16.69,61.94 19.23,61.94 20.18,62.89 v2(20.42,62.89) 20.83,62.89 v1(21.2,62.51) ; v1(73.94,121.91) 73.8,122.05 69.97,122.05 69.28,121.35 68.32,121.35 67.63,122.04 67.17,122.04 65.49,120.36 63.51,120.36 58.4,115.26 56.97,115.26 56.53,114.81 54.75,114.81 54.3,114.37 49.95,114.37 47.89,112.31 47.89,111.44 47.69,111.23 47.69,109.87 47.47,109.66 47.47,108.64 SR769.2 47.03,107.57 v1(46.91,107.45)
PCH_JTAG_TMS_R: length 4.5
  BOTTOM w0.102: XDP3.58 7.65,54.84 7.29,55.2 7.24,55.2 6.65,55.79 6.65,56.5 v2(6.51,56.65) 6.27,56.89 6.27,57.01 SR776.2
PCH_JTAGX: length 50.3
  TOP w0.102: HR371.2 v2(78.71,120.74) 77.75,120.74 76.02,122.47 v1(69.44,122.47) ; v1(49.07,102.63) 48.94,102.76 U1.AH4
  BOTTOM w0.102: v1(49.07,102.63) 49.07,103.38 47.97,104.48 47.09,104.48 46.89,104.68 46.89,106.47 45.69,107.66 45.69,109.98 46.15,110.44 SR763.2 46.87,110.89 47.04,110.89 47.69,111.54 47.69,112.4 49.86,114.57 54.22,114.57 54.67,115.02 56.43,115.02 56.89,115.48 58.35,115.48 63.43,120.57 65.36,120.57 67.27,122.47 v1(69.44,122.47)
PCH_M2_SSD_CLKREQ_N: length 39.6
  TOP w0.127: U1.BB30 41.38,90.18 v1(41.17,90.39) ; v1(29.55,112.04) 29.16,111.65 28.93,111.65 28.45,111.17 28.45,110.38 28.18,110.11 APR112.1
  IN1 w0.127: v1(41.17,90.39) 38.93,92.63 38.93,93.34 37.81,94.46 37.81,95.81 37.41,96.21 36.95,96.21 36.41,96.75 36.41,98.52 35.71,99.22 35.71,102.7 33.27,105.14 33.27,106.02 32.87,106.42 32.87,108.07 32.54,108.4 31.69,108.4 31.3,108.79 31.3,109.95 29.55,111.7 v1(29.55,112.04)
  BOTTOM w0.127: SR7897.2 33.98,92.08 34.87,92.08 SR912.2 35.7,92.01 37.62,92.01 37.69,91.94 39.24,91.94 v2(39.57,91.61) 39.93,91.25 40.05,91.25 40.91,90.39 v1(41.17,90.39)
PCH_PME_N: length 12.3
  TOP w0.089: 38.35,86.81 39.16,86.81 39.2,86.78 39.47,86.63 39.5,86.62 39.85,86.62 40.09,86.86 U1.BE36
  TOP w0.102: SR111.2 30.66,83.35 30.81,83.2 v2(31.35,83.2) 31.6,83.2 31.91,83.52 32.29,83.52 32.51,83.3 33.94,83.3 34.68,84.03 34.68,84.98 35.02,85.32 35.89,85.32 36.11,85.54 36.4,85.54 37.09,86.23 37.09,86.37 37.45,86.74 38.03,86.74 38.1,86.81 38.35,86.81
PCH_PWROK: length 322.9
  TOP w0.127: v1(23.42,47.91) 23.06,48.26 23.06,49.44 23.54,49.93 23.54,52.36 23.11,52.8 23.11,54.37 23.34,54.6 23.34,57.16 23.54,57.36 23.54,58.71 23.77,58.95 23.77,63.11 24.28,63.62 24.28,67.58 24.59,67.89 24.59,70.48 25.96,71.86 26.7,71.86 27.88,73.05 27.88,73.08 29.04,74.24 29.04,75.16 29.2,75.32 29.2,76.56 30.12,77.49 30.12,78.27 v1(30.43,78.58) ; Q9535.3 29.95,26.28 29.77,26.1 C941649.1 30.39,23.84 R70299.2 32.65,22.14 34.87,22.14 36.09,23.36 36.09,40.71 35.63,41.16 35.63,43.42 33.12,45.94 32.59,45.94 32.28,46.24 v1(32.28,46.7) ; v1(42.77,83.54) 42.75,83.54 U1.AY42
  IN1 w0.127: v1(32.28,46.7) 31.15,47.83 27.59,47.83 27.09,48.33 23.84,48.33 v1(23.42,47.91) 22.54,47.91 19.28,51.17 18.18,51.17 17.68,51.68 17.68,52.72 16.29,54.11 13.16,54.11 11.6,55.66 v1(11.6,56.85) ; v1(42.77,83.54) 42.34,83.54 42.11,83.31 42.11,82.56 41.3,81.75 40.84,81.75 40.73,81.86 39.99,81.86 38.41,80.29 38.41,80.01 38.41,80.01 38.41,79.5 37.87,78.96 35.91,78.96 35.56,78.6 34.46,78.6 34.14,78.92 33.08,78.92 32.64,78.48 30.53,78.48 v1(30.43,78.58)
  IN2 w0.127: v1(120.72,37.61) 119.35,36.24 114.1,36.24 112.72,37.61 108.38,37.61 101.19,44.8 94.95,44.8 89.76,49.98 89.76,51.21 88.24,52.73 88.24,54.35 84.74,57.84 81.24,57.84 79.25,55.84 75.31,55.84 74.19,56.96 70.77,56.96 66.9,53.09 66.9,50.1 64.92,48.12 64.24,48.12 57.49,41.37 46.58,41.37 44.13,43.82 42.66,43.82 40.67,45.81 38.68,45.81 38.4,45.53 35.03,45.53 34.34,46.21 33.75,46.21 33.26,46.7 v1(32.28,46.7) ; v1(15.92,120.32) 11.25,115.65 11.25,113.24 12.29,112.2 12.29,110.02 10.31,108.04 10.31,106.19 9.96,105.83 9.96,101.13 11.66,99.43 11.66,98.28 12.21,97.72 12.21,93.64 9.9,91.33 9.9,87.76 6.94,84.8 6.94,79.74 9.52,77.15 9.84,76.83 9.84,73 10.11,72.74 10.51,72.33 10.51,70.62 11.28,69.86 11.28,57.18 v1(11.6,56.85)
  BOTTOM w0.127: SR288.1 SC28.1 31.34,81.06 30.74,80.46 30.74,79.77 30.43,79.46 v1(30.43,78.58) ; O2Q3.1 15.37,118.68 15.93,119.25 16.09,119.25 16.35,119.5 16.35,119.9 v1(15.92,120.32) ; v1(11.6,56.85) 11.77,57.02 11.77,57.87 SR823.2 ; R6.1 119.4,24.42 119.81,24.83 v2(119.81,26.06) 119.81,26.53 121.44,28.16 121.44,34.86 120.72,35.58 v1(120.72,37.61)
PCH_PWROK_DISCH_A: length 2.8
  BOTTOM w0.102: R6.2 117.93,22.91 v2(117.93,22.34) 118.15,22.12 Q8.3
PCH_SATA_LED_N: length 139
  TOP w0.102: v1(52.75,43.6) 52.65,43.7 v1(52.65,45.28) ; U1.AK48 47.55,81.14 47.47,81.06 47.47,79.11 48.05,78.53 48.05,76.21 47.92,76.08 v1(47.92,75.52) ; R70292.1 32.59,29.64 v1(32.92,29.97) 32.99,30.04 33.1,30.04 34.12,31.06 34.12,31.65 34.52,32.05 v1(34.52,37.85)
  IN1 w0.102: v1(52.75,43.6) 52.45,43.3 47.99,43.3 47.73,43.55 46.37,43.55 46.3,43.61 44.11,43.61 43.24,42.75 38.55,42.75 38,43.3 37.04,43.3 34.57,45.77 34.57,46.6 34.08,47.08 33.55,47.08 33.17,47.46 33.17,47.93 32.55,48.55 27.89,48.55 26.96,49.48 23.86,49.48 v1(23.49,49.11)
  IN2 w0.102: v1(52.65,45.28) 53.21,45.84 53.21,46.46 53.41,46.66 53.41,47.08 54.42,48.09 55.77,48.09 57.52,49.84 57.52,51.23 59.35,53.05 59.35,53.81 60.09,54.56 60.09,55.11 61.83,56.85 61.85,56.85 61.95,56.95 61.95,62.47 61.15,63.27 61.15,63.9 61.56,64.3 61.56,65.47 61.12,65.9 59.83,65.9 58.55,67.19 58.55,69.08 58.96,69.5 58.96,71.79 58.06,72.69 58.06,73.33 56.91,74.48 50.35,74.48 49.71,73.83 49.71,73.25 49.46,73 48.82,73 47.83,73.99 47.83,75.43 v1(47.92,75.52) ; v1(34.52,37.85) 28.33,37.85 23.53,42.66 23.53,43.68 v1(23.95,44.11)
  BOTTOM w0.102: v1(32.92,29.97) 31.32,29.97 31.13,30.15 Q9436.1 29.55,30.15 29.13,29.73 29.13,29.25 28.69,28.81 v2(27.41,28.81) ; SR625.1 13.06,44.53 13.6,44 19.41,44 20.06,43.34 23.18,43.34 v1(23.95,44.11) 23.53,44.54 23.53,45.04 22.83,45.74 22.83,48.45 v1(23.49,49.11)
PCH_SIO_DPWROK: length 74.4
  TOP w0.127: v1(22.23,96.43) 21.79,95.99 21.67,95.99 21.2,95.52 21.2,93.58 20.78,93.16 20.78,90.27 20.88,90.17 20.88,89.24 20.11,88.47 20.11,86.98 18.78,85.64 18.78,80.54 14.32,76.08 14.32,75.25 v2(13.54,74.46) 12.87,74.46 11.94,73.53 11.94,69.94 11.45,69.46 11.45,67.41 10.51,66.47 10.15,66.47 9.77,66.09 9.77,65.15 12.9,62.02 13.51,62.02 v1(13.82,62.32) ; SR286.1 33.04,63.05 31.28,63.05 v1(31.09,63.24)
  IN1 w0.127: v1(15.09,58.91) 16.8,57.2 21.96,57.2 23.4,55.75 25.9,55.75 26.16,55.49 27.46,55.49 v1(27.87,55.91)
  IN2 w0.127: v1(13.82,62.32) 13.82,61.2 15.04,59.98 15.04,58.96 v1(15.09,58.91)
  BOTTOM w0.127: v1(27.87,55.91) 28.14,56.17 28.14,57.77 29.03,58.66 29.31,58.66 29.58,58.93 29.58,60.71 31.09,62.22 v1(31.09,63.24) ; v1(22.23,96.43) 22.23,96.43 22.23,96.42 22.25,96.42 22.25,96.43 22.83,96.43 22.96,96.3 22.96,96.09 23.09,95.96 U104.28
PCH_SLP_A_N: length 104.7
  TOP w0.102: U1.BE40 39.97,85.17 39.75,84.95 38.67,84.95 37.75,84.03 37.48,84.03 37.22,83.77 v1(37.2,83.77)
  TOP w0.127: v1(37.2,83.77) 37.06,83.77 36.14,82.86 35.9,82.86 35.11,82.07 34.83,82.07 33.99,81.23 33.51,81.23 32.58,80.29 32.58,80.28 31.85,79.55 31.85,79.08 31.71,78.94 31.71,77.37 31.18,76.84 30.94,76.84 30.26,76.16 30.26,74.98 30.03,74.75 30.03,73.82 29.02,72.81 29.02,72.78 27.07,70.83 26.34,70.83 25.6,70.1 25.6,68.98 27.44,67.14 27.44,65.45 26.12,64.12 25.94,64.12 24.56,62.74 24.56,60.06 25.19,59.43 25.19,55.59 23.62,54.02 23.62,53.09 24.05,52.65 24.05,50.31 24.18,50.18 24.18,44.87 24.48,44.57 24.48,43.91 24.18,43.6 23.94,43.6 23.66,43.33 23.66,42.77 23.99,42.44 v1(24.61,42.44)
  IN1 w0.127: v1(27.18,114.26) 26.97,114.06 26.97,113.1 27.56,112.52 27.56,111.27 27.31,111.03 27.31,110.29 28.99,108.61 28.99,107.88 29.27,107.6 29.27,105.74 29.27,105.52 29.8,105 29.8,103.92 29.95,103.77 29.95,102.53 30.22,102.25 31.67,102.25 32.82,101.11 32.82,100.35 33.15,100.02 33.15,99.02 33.86,98.31 33.86,96.39 34.47,95.78 34.47,95.23 35.52,94.17 35.52,92.67 39.14,89.05 39.14,86.27 37.2,84.33 v1(37.2,83.77)
  BOTTOM w0.127: ECR149.1 23.98,113.93 25.55,115.51 25.94,115.51 v1(27.18,114.26) ; APR7.2 28.81,43.78 SR215.1 26.83,43.78 v2(26.52,43.78) 26.18,43.78 24.84,42.44 v1(24.61,42.44)
PCH_SPI_CS1#: length 7
  TOP w0.089: U1.AW48 43.15,80.5 43.36,80.29 43.36,79.42
  TOP w0.127: v1(45.07,76.41) 44.54,76.41 43.88,77.07 43.88,77.61 44.05,77.79 44.05,78.32 43.36,79.01 43.36,79.42
  BOTTOM w0.127: v1(45.07,76.41) 44.86,76.62 ST33.1
PCH_SPI_CS2#: length 4.6
  TOP w0.127: U1.AT40 44.92,85.27 v1(45.06,85.41)
  BOTTOM w0.127: SR7785.2 45.38,82.3 44.93,82.74 44.93,83.26 44.78,83.41 44.78,83.84 45.47,84.53 v2(45.47,84.67) 45.47,85 v1(45.06,85.41)
PCH_SPKR_C: length 3.5
  TOP w0.102: v1(8.71,26.28) 8.63,26.28 8.4,26.04 SR7813.2 AC84.2
  BOTTOM w0.102: v1(8.71,26.28) 8.53,26.46 v2(6.91,26.46)
PCH_SPKR_C_R: length 8.1
  TOP w0.102: SR7813.1 6.96,26.04 6.8,26.2 SR7814.2 ; SR7814.2 5.72,25.49 v1(5.56,25.49) 5.44,25.61 SR7884.1 ; SR7814.2 6.42,25.78 6.3,25.65 6.3,25.32 AC204.2 7.02,25.59 8.81,25.59 AC205.1
  BOTTOM w0.102: v2(4.85,25.49) v1(5.56,25.49)
PCH_TGR_L900MIL: length 7.3
  TOP w0.127: v1(47.34,105.09) 47.19,104.94 47.19,103.21 U1.AK3
  BOTTOM w0.127: v1(47.34,105.09) 47.95,105.09 49.11,103.93 R2420.1 50.25,103.49 51.38,103.49 v2(51.64,103.75)
PCH_THMTRIP#_R: length 5.8
  TOP w0.102: U1.AD3 50.28,103.35 50.01,103.62 50.01,104.48 50.48,104.96 50.48,105.2 v1(50.9,105.62)
  TOP w0.127: v2(51.61,106.35) 51.22,105.96 51.22,105.94 v1(50.9,105.62)
  BOTTOM w0.127: SR266.1 49.93,106.12 SC24.1 v1(50.9,105.62)
PCH_WAKE#: length 18.6
  TOP w0.089: U1.BB47 40.96,80.91 41.12,80.76 41.12,80.51 40.94,80.34 40.93,80.34
  TOP w0.102: 40.17,79.64 40.84,80.31 40.91,80.31 40.93,80.34
  TOP w0.127: 40.17,79.64 40.17,79.64 39.21,78.68 v1(39.21,78.07) ; v1(36.88,66.66) 37.01,66.54 SR255.2 SR262.1
  BOTTOM w0.127: v1(39.21,78.07) 39.62,77.66 39.62,77.21 v2(38.42,76) 37.31,74.89 37.31,67.1 v1(36.88,66.66)
PCH_XDP_PRDY#: length 89.3
  IN2 w0.102: v1(42.94,110.65) 42.67,110.92 41.05,110.92 40.08,111.9 39.24,111.9 38.69,112.46 34.57,112.46 33.83,113.2 32.24,113.2 32.05,113.01 32.05,112.72 31.19,111.85 30.67,111.85 28.47,109.65 26.49,109.65 23.56,106.72 23.56,105.49 22.57,104.5 22.57,104.33 22.57,104.16 22.57,104 22.57,102.86 21.16,101.45 21.16,99.63 20.54,99.01 20.54,98.31 18.73,96.51 18.73,92.71 18.12,92.1 18.12,87.19 19.88,85.43 19.88,79.03 18.36,77.51 18.36,72.18 19.04,71.5 19.04,70.98 18.68,70.62 18.68,68.38 19.34,67.72 19.34,63.63 19.01,63.3 19.01,56.21 19.61,55.62 19.61,54.36 20.33,53.63 20.33,51.62 20.36,51.6 v1(20.39,51.6)
  BOTTOM w0.102: HR410.2 42.31,109.44 42.43,109.55 v2(42.43,110.02) 42.43,110.14 v1(42.94,110.65) ; v1(20.39,51.6) 20.33,51.6 20.13,51.4 20.13,50.12 20.65,49.59 XDP3.5
PCH_XDP_PRDY#_R: length 10.3
  TOP w0.102: v1(47.19,102.02) 46.76,102.02 U1.AM5
  BOTTOM w0.102: HR410.1 HR369.1 43.25,107.7 v2(43.72,107.24) 44.6,106.36 44.6,104.68 44.87,104.41 44.87,103.24 44.96,103.14 46.14,103.14 46.58,102.7 46.58,102.46 47.01,102.02 v1(47.19,102.02)
PCH_XDP_PREQ#: length 97
  TOP w0.102: v1(45.06,109.68) 45.3,109.44 HR373.2
  IN2 w0.102: v1(45.06,109.68) 44.64,109.26 43.17,109.26 41.91,110.52 40.89,110.52 39.91,111.49 39.07,111.49 38.52,112.05 34.32,112.05 34.22,112.14 32.69,112.14 31.99,111.44 31.04,111.44 28.96,109.37 28.76,109.37 28.64,109.25 26.66,109.25 23.96,106.55 23.96,105.95 23.96,105.32 22.97,104.33 22.97,102.69 21.56,101.28 21.56,99.46 20.94,98.84 20.94,98.14 19.4,96.6 19.4,95.06 19.85,94.62 19.85,93.25 18.53,91.93 18.53,87.36 20.29,85.6 20.29,78.86 18.77,77.34 18.77,72.35 19.45,71.67 19.45,70.81 19.09,70.45 19.09,68.55 19.75,67.89 19.75,63.34 20.05,63.04 20.05,56.82 21.21,55.66 21.21,51.7 v1(21.32,51.59)
  BOTTOM w0.102: v2(23.14,57.17) 22.91,56.94 22.91,52.54 21.84,51.48 21.44,51.48 v1(21.32,51.59) 20.76,51.03 20.58,51.03 20.33,50.79 20.33,50.27 21.15,49.45 XDP3.3
PCH_XDP_PREQ#_R: length 6.9
  TOP w0.102: HR368.1 44.66,108.6 44.93,108.6 HR373.1 45.3,107.7 45.6,107.4 v2(45.78,107.4) 46.11,107.4 47.08,106.43 47.08,105.72 46.92,105.56 46.92,103.96 46.89,103.93 U1.AL2
PCH_XDP_PRSNT_R: length 6.6
  BOTTOM w0.127: SR760.1 4.89,58.97 v2(4.89,58) 4.89,57.42 SR778.1 6.07,56.24 6.07,55.84 7.15,54.76 XDP3.60
PCIAUX_CTRL_N: length 4.7
  TOP w0.102: OR119.1 10.12,102.66 v1(10.4,102.94) 10.5,102.94 v2(10.95,102.48)
  BOTTOM w0.102: v1(10.4,102.94) 9.75,103.58 9.75,104.12 9.12,104.76 U104.91
PCIAUX_GATE: length 72.2
  TOP w0.102: v1(19.2,98.77) v2(19.2,98.06) ; v1(46.26,84.86) 46.03,84.86 U1.AN40 ; OR109.1 v1(10.4,103.58)
  IN1 w0.102: v1(46.26,84.86) 46.66,84.46 46.66,83.77 46.16,83.28 46.16,80.83 45.98,80.65 45.98,79.4 45.17,78.59 45.17,77.41 44.55,76.79 40.39,76.79 39.87,76.27 37.76,76.27 36.82,75.33 36.26,75.33 34.71,76.88 31.93,76.88 31.26,76.2 29,76.2 27.84,77.37 25.07,77.37 22.36,80.07 22.36,86.46 21.84,86.97 21.84,88.24 21.47,88.61 21.47,90.19 19.85,91.82 19.85,94.56 19.29,95.12 19.29,98.68 v1(19.2,98.77)
  BOTTOM w0.102: U104.92 9,105.16 9.96,104.21 9.96,104.03 v1(10.4,103.58) 10.84,103.14 10.84,101.73 12.44,100.14 13.43,100.14 14.28,100.99 14.96,100.99 15.95,100 15.95,99.69 16.57,99.08 17.18,99.08 17.71,98.54 18.97,98.54 v1(19.2,98.77)
PCIAUX_GATE1: length 77.5
  TOP w0.102: U1.AP47 45.44,81.65 45.45,81.65 45.69,81.41 45.69,80.59 45.58,80.47 45.58,79.79 45.8,79.56 45.8,78.87 45.62,78.68 45.62,78.11 46.2,77.53 v1(46.25,77.53)
  IN1 w0.102: v1(63.1,60.06) 63.1,59.61 61.99,58.49 60.96,58.49 59.82,57.34 58.25,57.34 57.27,56.37 56.2,56.37 55.96,56.12 54.75,56.12 54.61,56.26 53.44,56.26 52.85,55.67 52.68,55.67 51.88,54.87 51.88,54.53 51.48,54.13 51.48,53.41 50.61,52.53 46.18,52.53 45.76,52.95 42.72,52.95 v1(42.21,53.46)
  IN2 w0.102: v1(62.72,68.64) 62.7,68.64 61.41,67.35 61.41,65.91 61.76,65.55 61.76,64.22 61.41,63.87 61.41,63.32 62.36,62.37 62.36,60.81 v1(63.1,60.06)
  BOTTOM w0.102: v1(46.25,77.53) 46.73,77.05 46.73,76.67 46.86,76.54 46.86,75.3 46.74,75.17 46.74,74.32 47.94,73.12 47.94,72.99 49.08,71.85 49.08,70.99 50.65,69.42 50.65,68.5 51.11,68.04 54.01,68.04 54.54,67.52 56.36,67.52 57.12,68.28 60.4,68.28 SR407.2 v2(61.82,68.81) 62.55,68.81 v1(62.72,68.64) ; D522.1 33.11,49.33 34.91,49.33 35.66,50.08 37.92,50.08 38.11,50.26 39.43,50.26 39.99,50.83 41.5,50.83 42.21,51.54 v1(42.21,53.46)
PCIE_RCOMPN_W15S15MIL: length 5.2
  TOP w0.102: v2(64.87,98.88) 64.56,98.57 64.41,98.57 64.17,98.82 61.19,98.82 U1.B12
  TOP w0.127: v2(64.87,98.88) 65.19,99.2 65.44,99.2 SR316.1
PCIE_RCOMPP_W15S15MIL: length 7.1
  TOP w0.102: U1.A13 61.61,98.54 64.16,98.54 64.34,98.36 64.87,98.36
  TOP w0.127: v2(68.22,98.8) 68.07,98.64 66.84,98.64 SR316.2 66.1,98.36 64.87,98.36
PCIE_RXN5_LAN: length 112.7
  TOP w0.127: v1(58.77,95.39) 58.82,95.39 U1.F20
  IN1 w0.127: v1(58.77,95.39) 58.47,95.09 58.47,95.07 57.89,94.49 56.98,94.49 56.22,95.25 56.22,98.33 55.79,98.76 54.16,98.76 53.36,99.56 53.36,102.53 51.52,104.37 51.52,105.96 51.96,106.39 52.68,106.39 53.22,105.84 53.22,104.73 54.14,103.81 54.88,103.81 55.14,104.08 55.14,105.43 54.04,106.53 54.04,107.25 52.75,108.54 50.71,108.54 49.53,109.72 49.53,114.41 50.43,115.31 50.43,123.17 49.16,124.44 42.93,124.44 42.43,124.94 39.12,124.94 37.63,126.43 37.63,128.53 39.64,130.53 39.64,131.29 39.06,131.87 39.06,132.75 39.58,133.27 39.58,134.34 39.06,134.86 39.06,135.29 39.43,135.66 39.43,136.48 39.06,136.85 39.06,137.58 39.61,138.12 39.61,138.74 39.06,139.29 39.06,139.94 39.61,140.49 39.61,141.13 39.06,141.67 39.06,142.3 39.56,142.8 39.56,146.89 38.36,148.1 35.3,148.1 33.6,146.4 30.05,146.4 29.09,145.44 24.92,145.44 22.87,143.39 17.54,143.39 16.73,144.2 16.34,144.2 v1(16.18,144.03)
  BOTTOM w0.127: 17.63,143.47 17.93,143.47 18.06,143.35 C4019.1 ; 17.63,143.47 v2(17.63,143.74) ; 17.63,143.47 17.25,143.47 16.92,143.8 16.41,143.8 v1(16.18,144.03)
PCIE_RXN5_LAN_C: length 2.1
  BOTTOM w0.127: C4019.2 17.73,141.65 17.73,141.4 18.06,141.07 18.06,140.68 18.15,140.59 U114.18
PCIE_RXN8_WLAN: length 71.6
  TOP w0.127: v1(58.66,92.55) 58.67,92.55 U1.F24 ; v1(45.37,58.66) 45.18,58.66 45.06,58.79 45.06,58.97 45.2,59.11 J218.43
  IN1 w0.127: v1(45.37,58.66) 45.05,58.66 44.92,58.79 44.92,59.9 45.46,60.43 45.85,60.43 45.97,60.31 45.97,59.81 46.3,59.48 46.86,59.48 47.81,60.43 50.29,60.43 50.87,61.01 51.72,61.01 52.21,61.51 54.97,61.51 55.81,62.35 57.73,62.35 58.76,63.38 60.59,63.38 63.27,66.06 66.11,66.06 67.38,67.33 67.38,68.98 66.23,70.13 66.23,74.15 66.47,74.39 66.47,81.98 66.64,82.16 67.22,82.16 67.31,82.07 68.22,82.07 68.82,82.67 68.82,85.93 68.53,86.22 68.53,91.89 65.82,94.59 63.31,94.59 62.83,95.07 61.58,95.07 60.51,94 60.51,92.33 60.25,92.06 58.72,92.06 58.6,92.19 58.6,92.49 v1(58.66,92.55)
PCIE_RXN9_M.2_SSD: length 133.4
  TOP w0.127: TC19.2 7.45,121.47 7.45,121.59 7.17,121.87 7.17,123.24 7.62,123.69 8.88,123.69 9.59,122.98 11.33,122.98 12.01,122.29 v1(12.01,122.28) ; U1.G36 58.11,87.51 58.11,87.95 v1(58.01,88.05)
  IN1 w0.127: v1(12.01,122.28) 12.01,122.27 11.91,122.16 11.91,121.78 11.77,121.65 11.77,118.98 9.6,116.81 9.6,112.16 9.37,111.93 9.37,110.12 9.51,109.98 9.51,108.9 8.91,108.3 8.91,99.96 10.16,98.71 10.16,87.86 7.88,85.58 7.88,80.13 10.85,77.16 17.34,77.16 19.12,75.38 19.58,75.38 21.52,73.43 21.52,71.98 23.36,70.14 25.06,70.14 26.55,68.65 28.14,68.65 29.37,67.41 32.4,67.41 33.75,66.06 35.06,66.06 36.41,67.41 39.05,67.41 39.11,67.35 43.1,67.35 43.62,66.83 47.17,66.83 47.48,66.53 49.95,66.53 50.42,67 51.95,67 52.58,67.63 54.76,67.63 57.5,70.37 57.5,70.5 59.45,72.44 59.45,76.33 60.32,77.21 60.32,78.4 60.03,78.69 60.03,79.27 60.7,79.95 60.7,85.46 60.08,86.08 59.53,86.08 58.19,87.42 58.19,87.87 v1(58.01,88.05)
PCIE_RXN9_M.2_SSD_C: length 5.8
  TOP w0.127: TC19.1 7.39,120.14 7.39,119.92 5.54,118.07 5.54,117.77 4.94,117.18 4.94,116.84 4.69,116.6 J219.5
PCIE_RXN10_M.2_SSD: length 119.3
  TOP w0.127: TC15.2 9.68,120.5 9.68,120.77 v1(9.42,121.02) ; v1(56.56,86.34) 56.67,86.34 U1.K37
  IN1 w0.127: v1(9.42,121.02) 9.63,121.02 9.87,121.26 9.87,122.43 11.66,124.22 13.03,124.22 13.25,124 14.13,124 15.75,122.39 15.75,120.76 15.34,120.35 15.34,119.09 12.38,116.14 12.38,113.44 12.13,113.19 12.13,108.87 11.96,108.7 11.96,103.31 12.36,102.92 12.36,101.91 12.19,101.75 12.19,101.01 12.77,100.42 12.77,99.3 13.15,98.93 13.15,98.72 13.89,97.97 13.89,96.56 14.16,96.29 14.16,90.49 15.63,89.02 15.9,89.02 19.24,85.68 19.24,85.43 19.83,84.83 19.83,79.02 23.35,75.5 23.35,75.09 24.36,74.08 24.36,73.6 24.59,73.36 26.61,73.36 28.04,71.92 29.02,71.92 29.44,71.5 29.85,71.5 30.61,70.74 32.13,70.74 32.84,70.03 34,70.03 34.2,70.23 36.64,70.23 39.88,73.47 41.15,73.47 41.27,73.34 41.88,73.34 42.01,73.47 42.62,73.47 44.21,71.89 44.21,71.09 44.84,70.46 45.63,70.46 46.52,69.57 48.42,69.57 48.79,69.2 49.35,69.2 49.55,69.41 51.07,69.41 51.62,69.96 53.15,69.96 53.65,70.45 53.66,70.45 54.33,71.12 54.6,71.38 54.6,72.06 55.35,72.81 55.35,73.29 55.95,73.9 55.95,80.73 56.44,81.22 56.44,82.36 55.7,83.09 55.7,85.16 56.56,86.02 v1(56.56,86.34)
PCIE_RXN10_M.2_SSD_C: length 4.5
  TOP w0.127: TC15.1 9.41,119.01 9.13,118.73 9.13,118.52 9.13,117.74 8.12,116.73 7.83,116.73 7.69,116.6 J219.17
PCIE_RXN11_M.2_SSD: length 115
  TOP w0.127: v1(58.28,84.97) 58.41,85.1 U1.G38 ; v1(12.52,121.88) 12.17,121.53 12.08,121.53 11.75,121.2 11.75,120.67 TC17.2
  IN1 w0.127: v1(12.52,121.88) 12.69,121.72 13.01,121.72 13.3,121.44 13.3,119.34 10.37,116.41 10.37,112.72 10.37,111.84 10.22,111.68 10.14,111.61 10.14,110.62 10.4,110.36 10.4,106.5 9.69,105.79 9.69,100.28 11.02,98.95 11.02,91.88 11.76,91.15 11.76,89.64 12.43,88.97 13.41,88.97 14.91,87.47 15.26,87.47 17.69,85.03 17.69,84.78 18.28,84.19 18.28,77.77 22.31,73.74 22.31,73.33 24.1,71.54 25.83,71.54 27.88,69.48 28.4,69.48 29.62,68.26 36.4,68.26 36.63,68.49 38.2,68.49 39.05,69.34 43.06,69.34 44.75,67.66 49.99,67.66 50.11,67.77 51.63,67.77 52.26,68.41 54.33,68.41 54.67,68.75 54.67,69.27 57.53,72.13 57.53,75.53 57.97,75.97 57.97,76.5 59.4,77.93 59.4,79.43 59.69,79.73 59.69,80.74 58.53,81.89 58.53,82.55 58.89,82.91 58.89,83.87 58.38,84.38 58.38,84.86 v1(58.28,84.97)
PCIE_RXN11_M.2_SSD_C: length 4.4
  TOP w0.127: J219.29 10.69,116.45 10.83,116.58 10.83,116.81 11.69,117.68 11.69,118.85 11.83,118.99 11.83,119.27 TC17.1
PCIE_RXN12_M.2_SSD: length 112.6
  TOP w0.127: v1(14.54,121.84) 14.32,121.62 14.32,121.31 TC13.2 ; U1.H42 58.17,84.07 58.02,84.22 57.81,84.22 57.66,84.07 v1(57.66,83.67)
  IN1 w0.127: v1(57.66,83.67) 57.86,83.87 58.06,83.87 58.24,83.69 58.24,83.33 58.09,83.17 57.68,83.17 57.6,83.09 57.6,82.54 57.52,82.45 57.52,82.02 58.35,81.18 58.35,80.52 57.95,80.11 57.86,80.11 57.71,79.96 57.71,78.05 57.47,77.81 57.47,76.18 57.01,75.72 57.01,72.42 56.69,72.1 56.1,72.1 55.64,71.63 55.64,70.95 54.6,69.91 53.6,68.91 52.05,68.91 51.51,68.37 49.98,68.37 49.78,68.16 48.12,68.16 47.75,68.53 46.09,68.53 45.32,69.31 44.47,69.31 42.7,71.08 39.54,71.08 37.65,69.19 34.83,69.19 34.47,68.82 32.36,68.82 32.05,69.13 29.47,69.13 28.61,69.99 28.09,69.99 25.83,72.25 24.11,72.25 22.82,73.54 22.82,73.95 18.79,77.98 18.79,84.4 18.2,84.99 18.2,85.24 15.47,87.98 15.18,87.98 13.63,89.52 12.64,89.52 12.29,89.88 12.29,97.45 11.53,98.21 11.53,99.16 10.29,100.4 10.29,100.98 10.91,101.6 10.91,109.12 11.09,109.3 11.09,113.11 10.88,113.32 10.88,116.16 13.8,119.08 13.8,120.32 14.71,121.22 14.71,121.68 v1(14.54,121.84)
PCIE_RXN12_M.2_SSD_C: length 4.7
  TOP w0.127: J219.43 14.19,116.47 14.02,116.64 14.02,117.23 14.4,117.61 14.4,119.81 TC13.1
PCIE_RXP5_LAN: length 112.6
  TOP w0.127: v1(57.96,95.29) 58.27,95.29 58.43,95.12 U1.G20
  IN1 w0.127: v1(57.96,95.29) 57.96,94.94 57.78,94.76 57.09,94.76 56.49,95.36 56.49,98.44 55.9,99.02 54.27,99.02 53.63,99.67 53.63,102.64 51.79,104.48 51.79,105.85 52.07,106.12 52.57,106.12 52.96,105.73 52.96,104.62 54.03,103.55 54.99,103.55 55.41,103.97 55.41,105.54 54.3,106.64 54.3,107.36 52.86,108.8 50.82,108.8 49.8,109.83 49.8,114.3 50.7,115.2 50.7,123.28 49.27,124.71 43.04,124.71 42.54,125.21 39.23,125.21 37.9,126.54 37.9,128.42 39.9,130.42 39.9,131.41 39.33,131.98 39.33,132.64 39.85,133.16 39.85,134.45 39.33,134.97 39.33,135.18 39.7,135.55 39.7,136.59 39.33,136.96 39.33,137.47 39.88,138.01 39.88,138.85 39.33,139.4 39.33,139.83 39.88,140.38 39.88,141.24 39.33,141.79 39.33,142.19 39.83,142.69 39.83,147.01 38.47,148.36 35.19,148.36 33.49,146.66 29.94,146.66 28.98,145.71 24.81,145.71 22.76,143.65 17.65,143.65 16.84,144.47 15.8,144.47 v1(15.42,144.08)
  BOTTOM w0.127: C4018.1 17.14,143.22 16.81,143.55 16.29,143.55 16.24,143.6 15.89,143.6 15.42,144.07 v1(15.42,144.08)
PCIE_RXP5_LAN_C: length 2.1
  BOTTOM w0.127: C4018.2 17.47,141.65 17.47,141.29 17.8,140.96 17.8,140.63 17.75,140.58 U114.17
PCIE_RXP8_WLAN: length 71.6
  TOP w0.127: J218.41 44.7,58.46 v1(44.65,58.41) ; v1(57.88,92.52) U1.G24
  IN1 w0.127: v1(57.88,92.52) 58.61,91.8 60.36,91.8 60.78,92.22 60.78,93.89 61.35,94.46 61.7,94.81 62.72,94.81 63.2,94.33 65.71,94.33 68.26,91.78 68.26,86.11 68.55,85.82 68.55,82.78 68.11,82.34 67.42,82.34 67.33,82.43 66.53,82.43 66.2,82.09 66.2,74.5 65.96,74.26 65.96,70.02 67.12,68.87 67.12,67.44 66,66.33 63.16,66.33 60.48,63.64 58.65,63.64 57.62,62.61 55.69,62.61 54.86,61.78 52.1,61.78 51.61,61.28 50.76,61.28 50.18,60.7 47.7,60.7 46.75,59.74 46.41,59.74 46.24,59.92 46.24,60.42 45.96,60.7 45.35,60.7 44.65,60.01 v1(44.65,58.41)
PCIE_RXP9_M.2_SSD: length 133.3
  TOP w0.127: TC20.2 7.7,121.58 7.7,121.7 7.43,121.98 7.43,123.14 7.72,123.43 8.77,123.43 9.48,122.72 11.23,122.72 11.58,122.37 11.58,122.06 v1(11.45,121.94) ; U1.F36 58.77,87.13 58.77,87.34 58.62,87.49 v1(58.62,87.82)
  IN1 w0.127: v1(11.45,121.94) 11.51,121.88 11.51,119.09 9.33,116.92 9.33,112.27 9.1,112.04 9.1,110.01 9.24,109.87 9.24,109.01 8.65,108.41 8.65,99.85 9.9,98.6 9.9,87.97 7.62,85.69 7.62,80.02 10.74,76.9 17.23,76.9 19.01,75.11 19.47,75.11 21.26,73.32 21.26,71.87 23.25,69.88 24.94,69.88 26.44,68.38 28.03,68.38 29.26,67.15 32.29,67.15 33.64,65.8 35.17,65.8 36.52,67.15 38.94,67.15 39,67.08 42.99,67.08 43.51,66.56 47.06,66.56 47.37,66.26 50.06,66.26 50.53,66.73 52.06,66.73 52.7,67.36 54.87,67.36 57.77,70.26 57.77,70.39 59.71,72.33 59.71,76.22 60.59,77.09 60.59,78.51 60.3,78.8 60.3,79.16 60.97,79.84 60.97,85.57 60.19,86.35 59.64,86.35 58.48,87.5 58.48,87.68 v1(58.62,87.82)
PCIE_RXP9_M.2_SSD_C: length 5.8
  TOP w0.127: TC20.1 7.64,119.91 7.64,119.82 5.79,117.97 5.79,117.67 5.19,117.07 J219.7
PCIE_RXP10_M.2_SSD: length 119.2
  TOP w0.127: v1(10.21,121) 9.93,120.72 9.93,120.63 TC16.2 ; U1.J37 57.56,86.44 v1(57.08,85.97)
  IN1 w0.127: v1(57.08,85.97) 56.89,85.97 55.97,85.05 55.97,83.2 56.7,82.47 56.7,81.1 56.22,80.62 56.22,73.79 55.61,73.18 55.61,72.7 54.86,71.95 54.86,71.27 54.44,70.86 53.77,70.18 53.76,70.18 53.26,69.69 51.73,69.69 51.18,69.14 49.66,69.14 49.46,68.94 48.68,68.94 48.31,69.31 46.41,69.31 45.52,70.2 44.73,70.2 43.94,70.98 43.94,71.78 42.51,73.21 42.12,73.21 41.99,73.08 41.16,73.08 41.04,73.21 39.99,73.21 36.75,69.97 34.31,69.97 34.11,69.76 32.73,69.76 32.02,70.47 30.5,70.47 29.74,71.24 29.33,71.24 28.91,71.66 27.93,71.66 26.5,73.09 24.48,73.09 24.09,73.48 24.09,73.97 23.09,74.97 23.09,75.39 19.57,78.91 19.57,84.72 18.97,85.32 18.97,85.57 15.79,88.75 15.52,88.75 13.89,90.38 13.89,96.18 13.63,96.45 13.63,97.86 12.88,98.6 12.88,98.82 12.51,99.19 12.51,100.31 11.92,100.9 11.92,101.86 12.09,102.02 12.09,102.81 11.7,103.2 11.7,108.81 11.86,108.98 11.86,113.3 12.11,113.55 12.11,116.25 15.07,119.2 15.07,120.46 15.48,120.87 15.48,122.28 14.02,123.74 13.13,123.74 12.92,123.95 11.77,123.95 10.13,122.32 10.13,121.07 v1(10.21,121)
PCIE_RXP10_M.2_SSD_C: length 4.6
  TOP w0.127: J219.19 8.19,116.44 9.38,117.63 9.38,118.63 9.77,119.01 9.95,119.01 TC16.1
PCIE_RXP11_M.2_SSD: length 114.9
  TOP w0.127: v1(58.91,84.94) 59.07,85.1 U1.F39 ; TC18.2 12.2,120.66 12.13,120.66 12.01,120.79 12.01,121.1 12.18,121.28 12.36,121.28 v1(12.52,121.12)
  IN1 w0.127: v1(12.52,121.12) 12.52,121.12 12.52,121.33 12.65,121.45 12.9,121.45 13.03,121.33 13.03,119.45 10.11,116.53 10.11,112.61 10.11,111.95 9.88,111.72 9.88,110.51 10.13,110.25 10.13,106.61 9.42,105.9 9.42,100.17 10.76,98.84 10.76,91.77 11.49,91.04 11.49,89.53 12.32,88.7 13.3,88.7 14.8,87.2 15.15,87.2 17.42,84.92 17.42,84.67 18.02,84.08 18.02,77.66 22.05,73.63 22.05,73.22 23.99,71.27 25.72,71.27 27.77,69.22 28.28,69.22 29.51,68 36.51,68 36.74,68.23 38.31,68.23 39.16,69.08 42.95,69.08 44.64,67.39 50.1,67.39 50.22,67.51 51.74,67.51 52.37,68.14 54.44,68.14 54.94,68.64 54.94,69.16 57.8,72.02 57.8,75.42 58.24,75.86 58.24,76.39 59.66,77.82 59.66,79.32 59.96,79.61 59.96,80.85 58.8,82 58.8,82.44 59.16,82.8 59.16,83.98 58.65,84.49 58.65,84.68 v1(58.91,84.94)
PCIE_RXP11_M.2_SSD_C: length 4.4
  TOP w0.127: J219.31 11.19,116.45 11.08,116.56 11.08,116.71 11.95,117.57 11.95,118.75 12.09,118.89 12.09,119.25 TC18.1
PCIE_RXP12_M.2_SSD: length 112.6
  TOP w0.127: TC14.2 14.07,121.23 14.07,121.48 13.98,121.57 13.98,122.1 14.37,122.49 v1(14.37,122.65) ; U1.J41 57.6,84.37 v1(57.2,84.37)
  IN1 w0.127: v1(57.2,84.37) 57.2,83.52 57.33,83.38 57.33,82.65 57.25,82.56 57.25,81.91 58.09,81.07 58.09,80.63 57.84,80.38 57.75,80.38 57.44,80.07 57.44,78.16 57.2,77.92 57.2,76.29 56.74,75.83 56.74,72.53 56.58,72.36 55.99,72.36 55.37,71.74 55.37,71.06 54.49,70.18 53.49,69.18 51.94,69.18 51.4,68.63 49.87,68.63 49.67,68.43 48.23,68.43 47.86,68.8 46.2,68.8 45.43,69.57 44.58,69.57 42.81,71.35 39.43,71.35 37.54,69.46 34.72,69.46 34.36,69.09 32.47,69.09 32.17,69.4 29.58,69.4 28.72,70.26 28.21,70.26 25.94,72.52 24.22,72.52 23.09,73.65 23.09,74.06 19.06,78.09 19.06,84.51 18.46,85.1 18.46,85.35 15.58,88.24 15.29,88.24 13.74,89.79 12.75,89.79 12.56,89.99 12.56,97.56 11.8,98.32 11.8,99.27 10.55,100.51 10.55,100.87 11.17,101.49 11.17,109.01 11.35,109.19 11.35,113.22 11.15,113.43 11.15,116.05 14.07,118.97 14.07,120.21 14.97,121.11 14.97,122.05 v1(14.37,122.65)
PCIE_RXP12_M.2_SSD_C: length 4.7
  TOP w0.127: J219.41 13.69,116.48 13.77,116.55 13.77,117.34 14.15,117.72 14.15,119.73 TC14.1
PCIE_TXN5_LAN: length 110.3
  TOP w0.127: v1(62.08,94.38) 61.8,94.38 61.67,94.5 61.67,94.64 61.52,94.8 61.07,94.8 60.95,94.67 60.95,94.47 U1.B21
  IN1 w0.127: v1(62.08,94.38) 62.08,94.18 61.95,94.06 61.48,94.06 61.1,93.67 61.1,93.02 61.38,92.74 61.38,91.82 60.87,91.32 57.94,91.32 57.69,91.57 55.94,91.57 54.44,93.07 53.86,93.07 53.39,93.54 53.39,93.77 53.71,94.08 53.71,96.29 52.14,97.86 52.14,98.72 52.78,99.36 52.78,102.38 50.47,104.69 50.47,108.04 49.02,109.49 49.02,115.13 49.76,115.86 49.76,122.85 48.67,123.93 40.67,123.93 40.17,124.43 38.91,124.43 37.13,126.22 37.13,128.74 38.78,130.4 38.78,131.43 38.56,131.66 38.56,132.96 38.78,133.19 38.78,134.42 38.56,134.65 38.56,135.5 38.78,135.73 38.78,136.41 38.15,137.04 38.15,140.64 38.56,141.04 38.56,142.56 39.05,143.06 39.05,146.41 38.05,147.41 35.61,147.41 33.97,145.77 30.19,145.77 29.35,144.93 25.14,144.93 24.22,144.02 22.6,142.39 15.81,142.39 15.52,142.69 15.52,142.96 15.72,143.17 v1(15.86,143.17)
  BOTTOM w0.127: C4021.1 16.23,142.71 16.08,142.86 15.86,142.86 15.79,142.94 15.79,143.09 v1(15.86,143.17)
PCIE_TXN5_LAN_C: length 4.3
  BOTTOM w0.127: C4021.2 16.41,141.45 16.41,141.27 16.28,141.14 15.9,141.14 15.77,141.01 15.77,139.87 16.8,138.84 16.98,138.84 17.03,138.89 U114.14
PCIE_TXN8_WLAN: length 61.8
  TOP w0.127: U1.B24 61.49,92.98 61.57,92.9 62.08,92.9 v1(62.47,93.3)
  IN1 w0.127: v1(59.51,64.71) 59.33,64.89 59.33,65.37 59.49,65.52 60.07,65.52 60.7,66.15 60.7,66.79 62.28,68.38 62.28,68.82 62.54,69.08 63.85,69.08 64.35,69.57 65.11,69.57 65.39,69.86 65.39,70.73 65.11,71.01 64.84,71.01 64.72,71.14 64.72,71.52 64.84,71.64 65.11,71.64 65.39,71.93 65.39,72.53 65.11,72.81 64.84,72.81 64.72,72.94 64.72,73.32 64.84,73.45 65.11,73.45 65.39,73.73 65.39,74.42 65.7,74.73 65.7,83.06 65.87,83.24 67.68,83.24 67.99,83.56 67.99,84.43 67.71,84.71 67.52,84.71 67.38,84.85 67.38,90.46 66.87,90.98 66.4,90.98 66.04,91.35 66.04,92.12 64.98,93.17 62.6,93.17 v1(62.47,93.3)
  BOTTOM w0.127: 59.38,63.57 v2(59.65,63.57) ; 59.38,63.57 59.38,64.58 v1(59.51,64.71) ; 59.38,63.57 59.38,63.06 59.62,62.83 60.07,62.83 60.6,62.3 60.6,57.7 59.97,57.06 58.5,57.06 57.22,55.79 54.9,55.79 53.55,57.13 52.09,57.13 51.65,56.69 51.48,56.69 M1C70.1
PCIE_TXN9_M.2_SSD: length 135.9
  TOP w0.089: 62.48,87.91 62.46,87.91 62.42,87.87 62.02,87.87 61.87,88.03 60.7,88.03 60.56,87.89 U1.C34
  TOP w0.127: v1(7.82,119.37) 7.93,119.26 7.93,119.08 TC1.1 ; v1(64.13,86.64) 64.13,87.57 63.79,87.91 62.48,87.91
  IN1 w0.127: v1(7.82,119.37) 7.82,118.74 7,117.91 7,115.9 6.54,115.44 6.54,112.88 6.18,112.52 6.18,107.25 5.36,106.43 5.36,99.79 6.22,98.93 6.22,98.06 7.16,97.12 7.16,94.6 6.63,94.07 6.63,89.55 3.85,86.77 3.85,80 9.45,74.4 16.07,74.4 17.05,73.42 17.05,72.63 17.05,72.49 17.05,72.35 17.92,71.47 17.92,70.43 21.09,67.27 23.07,67.27 25.76,64.57 27.02,64.57 27.84,63.74 31.22,63.74 31.99,62.97 38.58,62.97 39.25,62.3 43.13,62.3 43.81,62.97 48.38,62.97 49.24,62.97 49.87,63.6 50.2,63.93 51.03,63.93 51.5,64.41 52.29,64.41 52.64,64.06 53.33,64.06 53.93,64.06 54.91,65.04 55.84,65.04 58.87,68.07 59.6,68.07 60.16,68.63 60.16,68.9 61.65,70.39 61.65,70.39 62.04,70.78 62.04,73.89 62.74,74.59 62.74,75.93 63.03,76.22 63.03,78.87 63.49,79.33 63.49,81.54 63.75,81.8 63.75,86.53 63.87,86.64 v1(64.13,86.64)
PCIE_TXN9_M.2_SSD_C: length 3.4
  TOP w0.127: TC1.2 7.83,117.69 7.83,117.58 7.74,117.5 6.9,117.5 6.44,117.04 6.44,116.69 6.19,116.45 J219.11
PCIE_TXN10_M.2_SSD: length 147
  TOP w0.089: U1.C35 60.55,87.36 60.7,87.21 62.42,87.21 62.46,87.18 62.48,87.18
  TOP w0.127: v1(64.24,85.03) 63.8,85.03 63.68,85.16 63.68,85.38 63.8,85.51 63.8,85.74 63.52,86.02 63.52,86.22 62.57,87.18 62.48,87.18 ; TC5.1 10.3,118.37 10.48,118.37 10.58,118.47 10.58,118.88 10.82,119.12 10.82,121.2 10.82,121.2 10.82,121.32 10.18,121.96 9.17,121.96 8.57,122.56 8.37,122.56 8.24,122.43 v1(8.24,122.23)
  IN1 w0.127: v1(8.24,122.23) 8.24,122.42 8.11,122.54 7.76,122.54 7.61,122.39 7.61,120.2 6.48,119.07 6.48,116.17 6.03,115.72 6.03,113.21 5.66,112.84 5.66,107.69 4,106.03 4,99.64 4.25,99.39 4.58,99.39 5.42,98.55 5.42,98.1 6.12,97.41 6.12,89.97 3.34,87.19 3.34,79.75 9.2,73.89 15.86,73.89 16.54,73.21 16.54,72.42 16.54,72.12 17.42,71.24 17.42,70.15 20.81,66.76 22.86,66.76 25.62,64 26.85,64 28.48,62.36 37.63,62.36 38.2,61.79 43.39,61.79 44.06,62.47 49.45,62.47 50.08,63.09 50.72,63.09 50.92,63.09 51.37,63.54 54.12,63.54 54.96,64.38 55.9,64.38 57.5,65.98 58.24,65.98 61.24,68.98 61.24,69.25 62.8,70.81 62.8,71.07 63.68,71.94 63.68,76.7 64.65,77.68 64.65,81.13 64.53,81.26 64.53,84.9 64.4,85.03 v1(64.24,85.03)
PCIE_TXN10_M.2_SSD_C: length 2.7
  TOP w0.127: J219.23 9.19,116.6 9.68,117.09 10,117.09 10.31,117.4 10.31,117.52 TC5.2
PCIE_TXN11_M.2_SSD: length 142.9
  TOP w0.127: v1(63.02,85.18) 63.02,86.18 62.27,86.92 61.37,86.92 61.31,86.86 U1.B36 ; v1(9.52,123.84) 9.52,123.84 9.88,123.48 11.58,123.48 13.01,122.05 13.01,119.41 12.8,119.19 12.8,118.87 TC3.1
  IN1 w0.127: v1(63.02,85.18) 62.25,84.42 62.25,76.55 61.96,76.25 61.96,74.91 61.26,74.21 61.26,71.1 59.55,69.38 59.08,69.38 55.52,65.82 54.58,65.82 53.61,64.84 52.96,64.84 52.62,65.18 51.18,65.18 50.7,64.71 49.88,64.71 48.92,63.75 48.7,63.75 43.43,63.75 42.76,63.07 39.58,63.07 37.82,64.82 36.7,64.82 35.63,63.76 32.4,63.76 30.78,65.37 26.16,65.37 23.38,68.15 22.08,68.15 19.52,70.71 19.52,71.12 17.82,72.82 17.82,73.59 17.82,73.74 16.24,75.33 9.62,75.33 4.62,80.32 4.62,86.37 7.93,89.68 7.93,98.33 6.16,100.11 6.16,106.1 6.96,106.9 6.96,109.82 7.5,110.37 7.5,112.22 7.31,112.41 7.31,115.12 7.78,115.59 7.78,117.6 9.1,118.92 9.1,119.6 8.24,120.47 8.24,121.13 8.87,121.76 8.87,123.18 9.36,123.67 v1(9.52,123.84)
PCIE_TXN11_M.2_SSD_C: length 2.4
  TOP w0.127: TC3.2 12.8,117.6 12.8,117.22 12.19,116.61 J219.35
PCIE_TXN12_M.2_SSD: length 142.1
  TOP w0.127: U1.D38 60.24,86.38 60.24,86.56 v1(59.95,86.85) ; v1(13.44,123.23) 13.14,123.53 13.14,123.74 13.27,123.87 13.91,123.87 15.14,122.64 15.14,119.48 15.47,119.15 15.47,118.86 15.28,118.68 TC7.1
  IN1 w0.127: v1(13.44,123.23) 13.23,123.23 13.08,123.08 13.08,122.52 12.95,122.39 12.62,122.39 12.49,122.52 12.49,122.93 12.33,123.09 12,123.09 10.91,122 10.91,119.23 8.82,117.15 8.82,112.48 8.55,112.2 8.55,109.93 8,109.39 8,99.76 8.98,98.79 8.98,87.91 5.66,84.6 5.66,80.75 10.05,76.37 16.67,76.37 18.86,74.17 18.86,73.25 20.64,71.48 20.64,71.07 22.4,69.31 24.13,69.31 25.58,67.86 26.82,67.86 28.04,66.64 32,66.64 33.76,64.89 35.28,64.89 35.84,65.44 35.84,65.67 36.39,66.22 40.34,66.22 41.22,65.34 44.43,65.34 44.95,65.86 46.08,65.86 46.54,65.41 48.38,65.41 48.72,65.75 50.27,65.75 50.74,66.22 52.27,66.22 52.91,66.86 55.09,66.86 58.46,70.23 58.46,70.36 60.22,72.12 60.22,75.99 61.21,76.98 61.21,79.49 61.36,79.64 61.36,87.37 60.72,88.01 59.93,88.01 59.8,87.89 59.8,87.56 59.94,87.42 60.09,87.42 60.22,87.3 60.22,87.12 v1(59.95,86.85)
PCIE_TXN12_M.2_SSD_C: length 2.3
  TOP w0.127: J219.47 15.19,116.43 15.28,116.51 15.28,116.92 15.4,117.04 15.4,117.47 TC7.2
PCIE_TXP5_LAN: length 110.5
  TOP w0.127: U1.A22 61.77,93.94 62.48,93.94 v1(62.69,94.15)
  IN1 w0.127: v1(62.69,94.15) 62.46,94.15 62.1,93.79 61.59,93.79 61.36,93.56 61.36,93.13 61.64,92.85 61.64,91.71 60.98,91.05 57.83,91.05 57.58,91.3 55.83,91.3 54.33,92.8 53.75,92.8 53.12,93.43 53.12,93.88 53.44,94.19 53.44,96.18 51.88,97.75 51.88,98.83 52.51,99.47 52.51,102.27 50.2,104.58 50.2,107.93 48.75,109.38 48.75,115.24 49.49,115.98 49.49,122.74 48.56,123.67 40.56,123.67 40.06,124.17 38.8,124.17 36.86,126.11 36.86,128.85 38.52,130.51 38.52,131.32 38.29,131.55 38.29,133.07 38.52,133.3 38.52,134.31 38.29,134.54 38.29,135.61 38.52,135.84 38.52,136.3 37.89,136.93 37.89,140.75 38.29,141.15 38.29,142.67 38.78,143.17 38.78,146.3 37.94,147.14 35.72,147.14 34.08,145.51 30.3,145.51 29.46,144.67 25.25,144.67 22.71,142.13 15.7,142.13 15.24,142.59 v1(15.24,143.32)
  BOTTOM w0.127: v1(15.24,143.32) 15.24,142.92 15.31,142.84 C4020.1
PCIE_TXP5_LAN_C: length 4.3
  BOTTOM w0.127: U114.13 16.97,138.49 16.88,138.59 16.69,138.59 15.52,139.76 15.52,141.43 C4020.2
PCIE_TXP8_WLAN: length 61.7
  TOP w0.127: U1.C24 60.5,93.31 61.06,93.31 61.14,93.24 61.59,93.24 61.6,93.23 61.67,93.23 v1(61.8,93.36)
  IN1 w0.127: v1(61.8,93.36) 61.8,93.08 62.01,92.86 62.65,92.86 62.69,92.9 64.87,92.9 65.77,92 65.77,91.24 66.29,90.72 66.76,90.72 67.12,90.35 67.12,84.74 67.41,84.44 67.6,84.44 67.73,84.32 67.73,83.67 67.57,83.51 65.76,83.51 65.43,83.17 65.43,74.84 65.12,74.54 65.12,73.84 65,73.71 64.73,73.71 64.45,73.43 64.45,72.83 64.73,72.55 65,72.55 65.12,72.42 65.12,72.04 65,71.91 64.73,71.91 64.45,71.63 64.45,71.03 64.73,70.74 65,70.74 65.12,70.62 65.12,69.97 65,69.84 64.24,69.84 63.74,69.34 62.43,69.34 62.02,68.93 62.02,68.49 60.44,66.9 60.44,66.27 59.96,65.79 59.6,65.79 59.38,65.79 59.06,65.48 59.06,64.87 v1(58.87,64.68)
  BOTTOM w0.127: v1(58.87,64.68) 59.13,64.43 59.13,62.96 59.51,62.58 59.97,62.58 60.35,62.19 60.35,61.74 ; 60.35,61.74 60.35,57.8 59.86,57.32 58.39,57.32 57.11,56.04 55,56.04 53.65,57.39 51.99,57.39 51.54,56.94 51.36,56.94 M1C69.1 ; 60.35,61.74 v2(60.08,61.74)
PCIE_TXP9_M.2_SSD: length 135.8
  TOP w0.089: 62.48,87.66 62.46,87.66 62.42,87.7 61.95,87.7 61.8,87.85 60.81,87.85 60.58,87.62 60.23,87.62 U1.D34
  TOP w0.127: TC2.1 8.27,119 8.27,119.18 v1(8.58,119.5) ; v1(63.65,87.11) 63.86,87.33 63.86,87.48 63.69,87.66 62.48,87.66
  IN1 w0.127: v1(8.58,119.5) 8.58,119.14 8.51,119.07 8.21,119.07 8.09,118.94 8.09,118.62 7.26,117.8 7.26,115.79 6.81,115.33 6.81,112.77 6.45,112.41 6.45,107.14 5.62,106.32 5.62,99.9 6.49,99.04 6.49,98.17 7.43,97.23 7.43,94.49 6.89,93.96 6.89,89.44 4.11,86.66 4.11,80.11 9.56,74.67 16.18,74.67 17.31,73.53 17.31,72.74 17.31,72.74 17.31,72.46 18.19,71.58 18.19,70.54 21.2,67.53 23.18,67.53 25.87,64.84 27.13,64.84 27.95,64.01 31.33,64.01 32.1,63.24 38.69,63.24 39.36,62.56 43.02,62.56 43.7,63.24 48.49,63.24 49.13,63.24 49.76,63.87 50.09,64.2 50.91,64.2 51.39,64.67 52.4,64.67 52.75,64.33 53.22,64.33 53.82,64.33 54.8,65.31 55.73,65.31 58.76,68.34 59.49,68.34 59.89,68.74 59.89,69.01 61.39,70.5 61.77,70.89 61.77,74 62.47,74.7 62.47,76.04 62.76,76.34 62.76,78.98 63.22,79.44 63.22,81.65 63.49,81.91 63.49,86.64 63.65,86.8 v1(63.65,87.11)
