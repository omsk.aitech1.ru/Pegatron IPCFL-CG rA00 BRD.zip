# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LINE2-R_C_R: length 5.3
  TOP w0.254: AR14.2 39.71,15.03 39.79,15.03 R123.1 40.19,15.85 40.24,15.9 C4308.1 41.26,16.42 L123.1 v1(41.32,15.69)
  BOTTOM w0.254: v2(41.07,14.54) 41.07,15.43 v1(41.32,15.69)
LINE2_JD: length 41.9
  TOP w0.127: v1(34.71,14.56) 35.22,14.05 D4303.2 35.66,14.3 35.66,14.65 v1(35.79,14.77) ; R70262.2 9.62,22.06 v1(9.46,21.9)
  IN1 w0.127: v1(9.46,21.9) 9.46,21.19 10.62,20.03 10.62,17.49 11.73,16.37 13.16,16.37 13.46,16.68 16.75,16.68 17.96,15.47 18.78,15.47 19.54,14.71 19.81,14.71 20.13,14.39 23.76,14.39 24.42,15.05 28.73,15.05 29.39,14.39 34.14,14.39 34.3,14.56 v1(34.71,14.56) ; v1(35.79,14.77) 36.42,14.77 37.62,13.57 37.62,10.28 J89.4
  BOTTOM w0.127: v1(34.71,14.56) 34.71,15.32 v2(34.77,15.38)
LINE2_JD_R: length 9.8
  TOP w0.127: U6.14 13.27,23.64 AC97.1 12.44,22.8 11.57,22.8 11.5,22.73 10.68,22.73 v1(10.25,23.17) 10.23,23.19 8.18,23.19 8.02,23.03 R70264.1 R70262.1
  BOTTOM w0.127: v2(10.41,22.24) 10.27,22.39 10.27,23.15 v1(10.25,23.17)
LINK_1000#_D: length 2.7
  TOP w0.102: Q2.3 37.88,158.07 37.95,158.14 LR11.2 38.78,157.84 v1(39.22,157.84)
  BOTTOM w0.102: v2(39.82,158.31) 39.34,157.84 v1(39.22,157.84)
LPC_0_ESPI_CLK_EC: length 13.9
  TOP w0.127: v1(41.91,86.51) 41.8,86.51 U1.BB36
  BOTTOM w0.127: SR19.2 SC72.1 33.87,87.78 33.87,87.26 34.6,86.53 v2(34.6,86.13) 34.6,85.89 35.05,85.44 36.24,85.44 36.99,84.68 37.48,84.68 37.98,85.18 38.96,85.18 39.32,85.54 40.29,85.54 40.92,86.17 40.92,86.37 41.28,86.73 41.68,86.73 v1(41.91,86.51)
LPC_PME_N: length 3.7
  TOP w0.127: v2(5.98,97.96) 5.98,98.75 6.11,98.88 ECR147.2 6.5,98.41 6.72,98.2 v1(7.12,98.2)
  BOTTOM w0.127: v1(7.12,98.2) 7.28,98.36 U104.75
LPC_PME_R_N: length 58.2
  TOP w0.127: v1(42.24,93.97) 43.1,93.97 U1.AV21 ; v1(31.29,110.98) 30.87,110.98 30.06,110.17 29.03,110.17 28.22,109.36 28.22,107.74 28.16,107.69 28.16,106.79 27.75,106.38 27.75,106.15 26.69,105.09 26.69,103.88 25.22,102.4 22.2,102.4 21.95,102.15 16.66,102.15 15.11,100.6 15.11,100.4 14.76,100.04 12.35,100.04 11.82,99.51 11.3,99.51 11.3,99.51 8.2,99.51 7.87,99.84 FR10.2 ECR147.1
  IN1 w0.127: v1(31.29,110.98) 31.29,110.74 33.37,108.65 33.37,106.63 33.78,106.23 33.78,105.35 36.22,102.91 36.22,99.43 36.93,98.72 v1(36.93,96.86)
  BOTTOM w0.127: v1(42.24,93.97) 42.44,94.17 42.44,95.06 41.91,95.59 41.91,95.9 41.5,96.31 40.98,96.31 40.42,96.87 v2(39.98,96.87) 39,96.87 38.58,96.45 37.34,96.45 v1(36.93,96.86)
LPCPD_N: length 10.1
  TOP w0.102: U1.BF38 39.25,86.18 39.2,86.13 38.88,86.13 38.87,86.14 38.43,86.14 38.26,85.97 38.25,85.97 37.97,85.69 37.12,85.69 36.35,84.91 35.34,84.91 35.08,84.66 35.08,83.45 v2(34.91,83.29) 34.78,83.15 34.39,83.15 34.1,82.87 33.59,82.87 32.47,81.75 32.47,81.74 SR44.1
LPSS_GSPI0_MOSI: length 12.2
  TOP w0.102: v2(29.79,89.02) 30.22,89.45 SR211.2 30.59,89.87 30.69,89.77 SR230.1 32.13,89.11 35.62,89.11 36.19,89.68 36.19,89.69 36.98,90.48 37.71,90.48 38.17,90.02 39,90.02 39.22,90.24 40.01,90.24 U1.BE30
LPSS_GSPI1_MOSI: length 5.8
  TOP w0.127: v1(41.78,91.48) U1.BA26
  BOTTOM w0.127: SR228.2 39.73,94.36 SR229.1 40.17,93.32 40.73,93.32 41.27,92.78 41.27,91.99 v1(41.78,91.48)
M2_ WAKE: length 137.3
  TOP w0.127: v2(59.97,58.66) 59.7,58.66 v1(59.32,59.04) 59.32,58.36 APR120.2 ; APR119.1 17.54,105.26 v1(17.3,105.02)
  IN1 w0.127: v1(59.32,59.04) 59.02,59.04 58.94,58.96 58.52,58.96 57.99,58.42 57.58,58.42 56.57,58.42 55.64,57.49 54.56,57.49 53.99,56.92 53.19,56.92 52.58,56.31 52.41,56.31 51.24,55.14 51.24,54.8 50.81,54.37 50.81,53.78 50.22,53.18 46.44,53.18 46.03,53.6 43.39,53.6 42.43,54.55 37.38,54.55 35.89,56.04 35.89,57.01 35.16,57.74 33.57,57.74 33.18,57.36 32.57,57.36 32.29,57.08 30.16,57.08 29.97,57.27 29.32,57.92 28.64,57.92 28.29,57.57 23.47,57.57 22.34,58.7 v1(22.04,58.7) 21.64,59.09 16.13,59.09 15.46,59.77 v1(13.79,59.77)
  IN2 w0.127: v1(59.32,59.04) 59.32,59.64 59.21,59.76 59.21,60.77 58.9,61.08 58.41,61.08 56.5,62.98 56.5,69.35 v1(56.17,69.67) ; v1(13.79,59.77) 11.53,62.03 11.53,69.97 10.77,70.73 10.77,72.44 10.22,72.99 10.22,72.99 10.1,73.11 10.1,76.94 9.78,77.26 7.2,79.84 7.2,84.7 10.16,87.66 10.16,91.22 12.47,93.53 12.47,96.44 13.15,97.11 13.15,98.58 12.54,99.19 12.54,99.76 12.67,99.89 12.67,100.85 13.99,102.17 15.19,102.17 15.75,102.73 15.75,103.67 16.45,104.37 16.65,104.37 v1(17.3,105.02)
  BOTTOM w0.127: XDP3.15 18.15,49.64 18.21,49.7 18.21,50.74 18.49,51.02 19.14,51.02 20.15,52.03 22.04,52.03 22.26,52.25 22.63,52.62 22.63,57.52 22.71,57.6 22.71,58.03 v1(22.04,58.7) ; v1(56.17,69.67) 56.96,69.67 57.13,69.85 SR549.2
M.2_BT_PCMCLK: length 84.3
  TOP w0.102: v1(47.34,55.13) 46.34,54.13 44.82,54.13 44.17,54.79 41.43,54.79 40.63,53.98 40.63,51.52 39.56,50.45 39.56,48.97 39.36,48.77 39.36,47.61 39.17,47.43 39.17,46.73 39.5,46.41 39.5,45.27 39.13,44.9 39.13,43.47 37.52,41.86 37.06,41.86 36.82,42.11 36.82,44.73 35.96,45.58 35.96,47.15 35.53,47.58 35.53,48.76 v2(35.15,49.14) 35.66,49.65 35.86,49.65 36.45,50.23 J218.8
  IN2 w0.102: v1(43.51,92.47) 43.11,92.86 41.56,92.86 41.26,92.57 41.26,92.32 39.4,90.46 39.4,87.45 38.75,86.8 38.75,82.86 38.75,82.85 38.75,80.79 39.3,80.24 39.3,79.28 38.68,78.65 38.68,78.6 38.49,78.41 38.49,77.16 38.84,76.81 38.84,75.47 41.14,73.16 41.14,71.76 41.82,71.08 42.77,71.08 43.1,70.74 43.1,69.74 44.32,68.52 44.32,67.85 46.39,65.78 46.46,65.78 47,65.24 47,64.1 49.17,61.94 49.17,59.64 50.2,58.61 50.2,57.61 49.81,57.22 48.46,57.22 47.35,56.11 47.35,55.15 v1(47.34,55.13)
  BOTTOM w0.102: v1(43.51,92.47) 43.51,93.51 R3132.1
M.2_BT_PCMCLK_R: length 2.2
  TOP w0.102: v1(43.18,95.34) 43.23,95.34 U1.AV18
  BOTTOM w0.102: R3132.2 43.13,95.29 v1(43.18,95.34) 43.18,95.77 43.11,95.84 v2(43.11,96.29)
M.2_BT_PCMFRM_CRF_RST_N: length 101.1
  TOP w0.102: J218.10 36.95,50.4 36.51,49.96 36.51,49.14 SR7932.1 35.79,48.42 35.79,47.61 36.17,47.23 36.17,46.08 v2(36.88,45.36) 37.26,44.98 37.26,42.89 37.23,42.87 v1(37.23,42.28) ; R3133.1 31.41,99.15 v1(31.33,99.24) 30.56,99.24 30.16,98.84 29.3,98.84 28.78,98.31 28.32,98.31 26.54,96.54 26.54,94.44 25.64,93.54 25.64,91.1 24.68,90.14 24.68,88.27 23.56,87.16 23.56,86.53 21.61,84.58 21.61,78.63 18.16,75.17 18.16,71.2 18.48,70.88 19.33,70.88 19.61,70.6 20.26,70.6 21.58,69.29 21.58,63.96 20.74,63.12 20.74,57.64 22.07,56.31 22.07,55.22 21.86,55.01 21.86,52.27 22.29,51.84 22.29,50.47 21.8,49.99 21.8,45.46 21.75,45.41 21.75,44.03 v1(22.02,43.76)
  IN2 w0.102: v1(22.02,43.76) 23.01,43.76 23.83,44.58 24.4,44.58 25.73,43.24 30.64,43.24 30.72,43.17 30.86,43.02 36.49,43.02 v1(37.23,42.28)
  BOTTOM w0.102: v1(31.33,99.24) 31.77,99.68 33.72,99.68 33.97,99.94 34.72,99.94 35.24,99.42 36.3,99.42 36.86,98.86 SR411.1
M.2_BT_PCMFRM_CRF_RST_N_R: length 14.9
  TOP w0.102: U1.BE16 39.51,97.01 38.29,98.24 35.46,98.24 35.16,98.54 33.73,98.54 33.37,98.9 33.13,98.9 R3133.2 32.76,99.15 32.33,99.58 31.93,99.58 31.85,99.66 31.15,99.66 31.03,99.54 30.42,99.54 29.93,99.04 29.16,99.04 28.77,98.65 27.92,98.65 v2(27.09,97.82)
M.2_BT_PCMIN: length 63.5
  TOP w0.102: v1(46.46,55.1) 44.67,55.1 44.56,54.99 38.28,54.99 37.45,54.15 J218.12
  IN2 w0.102: v1(46.46,55.1) 46.46,55.69 48.55,57.79 48.55,62.27 46.8,64.01 46.8,65.08 44.12,67.77 44.12,68.3 43.11,69.31 39.95,69.31 39.4,69.86 39.4,72.73 38.47,73.66 38.47,76.89 38.29,77.07 38.29,77.75 v1(38.07,77.97) 38.28,78.17 38.28,80.29 38.55,80.57 38.55,82.77 38.54,82.77 38.54,86.88 39.19,87.53 39.19,91.47 41.69,93.97 41.69,94.26 41.92,94.49 41.92,96.4 v1(42.34,96.81)
  BOTTOM w0.102: v1(42.34,96.81) 42.53,96.81 R3134.1 ; v1(38.07,77.97) 37.79,77.97 v2(37.36,77.54)
M.2_BT_PCMINR: length 2.8
  TOP w0.102: v1(43.76,96.61) 43.53,96.61 U1.AW18
  BOTTOM w0.102: v2(44.73,97.07) 44.55,97.25 R3134.2 43.8,96.65 v1(43.76,96.61)
M.2_BT_PCMOUT_CLKREQ0: length 93.5
  TOP w0.102: J218.14 37.95,51.38 37.39,50.82 37.39,50.41 36.83,49.85 36.83,48.35 37.31,47.87 37.31,47.02 SR7933.1 37.76,46.57 37.76,42.69 v1(37.74,42.68) ; v1(31.46,97.47) 31.03,97.04 29.14,97.04 28.96,97.22 28.44,97.22 28.03,96.81 28.03,96.13 28.53,95.62 28.53,95.2 28.18,94.85 28.18,94.48 27.83,94.13 26.52,94.13 25.84,93.46 25.84,91.02 24.88,90.06 24.88,88.19 23.76,87.07 23.76,86.44 21.82,84.49 21.82,78.54 18.36,75.09 18.36,72.22 19.72,70.86 20.75,70.86 v2(21.13,70.47) 21.41,70.2 21.41,69.74 21.78,69.37 21.78,61.86 20.94,61.02 20.94,57.72 22.27,56.39 22.27,55.14 22.06,54.93 22.06,52.36 22.49,51.93 22.49,50.39 22.01,49.9 22.01,44.6 v1(22.25,44.36)
  IN2 w0.102: v1(37.74,42.68) 37.19,43.23 30.95,43.23 30.7,43.47 25.93,43.47 24.63,44.78 22.69,44.78 22.27,44.36 v1(22.25,44.36)
  BOTTOM w0.102: v1(31.46,97.47) 31.47,97.48 R3135.1 SR410.2
M.2_BT_PCMOUT_CLKREQ0_R: length 10.7
  TOP w0.089: 38.31,96.38 38.62,96.06 39.09,96.06 39.29,96.26 40.32,96.26 40.59,95.98 41.05,95.98 41.36,96.29 U1.BA17
  TOP w0.102: v1(34.83,97.77) 35.28,97.33 v2(36.37,97.33) 37.71,97.33 37.98,97.05 37.98,96.7 38.31,96.38
  BOTTOM w0.102: v1(34.83,97.77) 34.65,97.96 33.4,97.96 R3135.2
M_A_A0: length 40.5
  TOP w0.198: v1(119,94.16) 119.28,94.16 119.45,94.33 XU1.AW15 ; v1(121.94,62.54) 121.94,62.19 122.12,62.01 DIMM2.144
  IN2 w0.102: 118.62,91.82 119.07,92.27 119.07,92.65 118.74,92.98 118.69,93.03 118.69,93.44 118.85,93.59 119.15,93.59 119.28,93.72 119.28,93.88 v1(119,94.16)
  IN2 w0.211: 118.62,91.82 118.62,89.55 121,87.17 121,65.08 121.21,64.87 122.01,64.87 122.27,64.61 122.27,64.08 122.01,63.82 120.58,63.82 120.36,63.61 120.36,63.09 120.91,62.54 v1(121.94,62.54)
  BOTTOM w0.198: v2(121.39,61.99) v1(121.94,62.54)
M_A_A1: length 42.4
  TOP w0.198: DIMM2.133 124.87,72.06 125.45,72.64 v1(125.9,72.64) ; XU1.AU18 v1(122.66,95.96)
  IN2 w0.102: 123.35,92.74 123.47,92.86 123.47,94 123.82,94.35 123.82,96.1 124.05,96.33 124.05,96.59 123.87,96.77 123.57,96.77 123.47,96.87 123.47,97.18 123.57,97.28 123.93,97.28 124.03,97.38 124.03,97.81 123.8,98.03 123.19,98.03 123.05,97.9 123.05,97.63 122.91,97.49 122.91,97.21 123.04,97.08 123.04,96.66 122.66,96.29 v1(122.66,95.96)
  IN2 w0.211: v1(125.9,72.64) 125.91,72.64 126.39,73.11 126.39,73.86 126.19,74.06 125.86,74.06 125.6,74.31 125.6,74.74 125.84,74.98 126.78,74.98 127.02,75.22 127.02,75.78 126.77,76.03 125.89,76.03 125.59,76.33 125.59,76.77 126.05,77.23 126.47,77.23 126.72,76.98 127.19,76.98 127.4,77.19 127.4,86.32 127.19,86.53 126.49,86.53 126.16,86.86 126.16,87.62 122.93,90.84 122.93,92.32 123.35,92.74
  BOTTOM w0.198: v1(125.9,72.64) 126.36,72.64 v2(126.64,72.92)
M_A_A2: length 41.4
  TOP w0.198: v1(124.54,62.37) 124.74,62.37 125.12,61.99 DIMM2.132 ; v1(120.82,96.89) XU1.AU17
  IN2 w0.211: v1(124.54,62.37) 123.29,62.37 122.76,62.9 122.76,65.32 123.31,65.88 123.31,69.49 121.83,70.97 121.83,73.26 121.83,87.52 119.45,89.9 119.45,91.48 119.73,91.76 119.73,95.41 120.26,95.95 120.26,96.34 v1(120.82,96.89)
  BOTTOM w0.198: v2(123.82,62.37) v1(124.54,62.37)
M_A_A3: length 42.8
  TOP w0.198: v1(122.78,94.29) 123.11,94.62 XU1.AV19 ; DIMM2.131 125.37,70.84 v1(125.88,71.34)
  IN2 w0.102: v1(122.78,94.29) 123.19,94.7 123.19,95.11 122.96,95.34 122.96,95.67 123.17,95.87 123.47,95.87 123.61,95.73 123.61,94.47 123.21,94.07 123.21,93.18 123.02,92.99 122.71,92.99 122.59,92.86 122.59,92.56
  IN2 w0.211: v1(125.88,71.34) 125.69,71.16 125.38,71.16 125.17,71.37 125.17,72.66 125.42,72.91 125.42,73.37 125.17,73.62 125.17,74.9 125.53,75.25 125.53,75.76 125.17,76.11 125.17,76.95 125.71,77.48 125.71,78.31 125.93,78.54 126.76,78.54 126.99,78.77 126.99,79.36 126.76,79.59 125.93,79.59 125.71,79.82 125.71,80.42 125.93,80.65 126.76,80.65 126.99,80.87 126.99,81.47 126.76,81.7 125.93,81.7 125.71,81.93 125.71,82.53 125.93,82.75 126.76,82.75 126.99,82.98 126.99,83.58 126.76,83.81 125.93,83.81 125.71,84.04 125.71,84.63 125.93,84.86 126.76,84.86 126.99,85.09 126.99,85.69 126.76,85.92 125.93,85.92 125.71,86.15 125.71,87.48 122.59,90.6 122.59,92.56
  BOTTOM w0.198: v2(125.17,71.34) v1(125.88,71.34)
M_A_A4: length 42.9
  TOP w0.198: DIMM2.128 126.12,62.28 v1(125.8,62.61) ; XU1.AT19 122.65,97.81 v1(122.63,97.81)
  IN2 w0.102: 122.18,93.04 122.18,93.46 122.05,93.59 122.05,93.87 122.36,94.18 122.36,94.36 122.26,94.45 122.07,94.45 121.97,94.55 121.97,94.73 122.14,94.9 122.14,95.13 122.35,95.34 122.35,95.65 122.18,95.82 122.18,96.13 122.38,96.33 122.38,96.56 122.17,96.77 122.17,97.02 121.97,97.23 121.97,97.48 122.3,97.81 v1(122.63,97.81)
  IN2 w0.211: 122.18,93.04 122.18,90.42 125.29,87.31 125.29,77.65 124.76,77.12 124.76,70.89 125.17,70.48 125.17,69.84 124.76,69.43 124.76,67.79 125.2,67.35 125.2,66.8 124.76,66.36 124.76,64.99 125.01,64.74 125.01,64.3 124.68,63.97 124.68,63.65 125.12,63.21 125.12,62.84 125.36,62.61 v1(125.8,62.61)
  BOTTOM w0.198: v2(125.8,61.82) v1(125.8,62.61)
M_A_A5: length 44.3
  TOP w0.198: v1(125.86,63.92) 126.26,63.92 126.62,63.56 DIMM2.126 ; XU1.AU20 124.44,96.01 v1(124.44,96)
  IN2 w0.102: 123.71,92.61 123.71,93.91 124.02,94.22 124.02,95.21 124.18,95.37 124.18,95.54 124.02,95.7 124.02,95.89 124.13,96 v1(124.44,96)
  IN2 w0.211: 123.71,92.61 123.25,92.15 123.25,91.11 126.57,87.79 126.57,87.31 126.94,86.94 127.42,86.94 127.82,86.54 127.82,86.49 127.82,86.49 127.82,86.15 127.82,86.15 127.82,76.96 127.44,76.58 127.44,76.21 127.74,75.91 127.74,75.61 127.44,75.31 127.44,74.92 127.83,74.53 127.83,73.97 127.55,73.69 127.09,73.69 126.8,73.4 126.8,72.08 126.5,71.78 126.5,70.43 125.17,69.11 125.17,68.29 125.61,67.85 125.61,67.17 125.8,66.97 126.28,66.97 126.49,66.76 126.49,66.16 126.28,65.95 125.45,65.95 125.2,65.7 125.2,65.14 125.44,64.9 125.82,64.9 126.08,64.63 126.08,64.14 v1(125.86,63.92)
  BOTTOM w0.198: v2(125.3,64.49) v1(125.86,63.92)
M_A_A6: length 43.3
  TOP w0.102: v1(124.44,93.73) 124.01,94.16 124.01,95.18 124.02,95.19 XU1.AV20
  TOP w0.198: DIMM2.127 126.37,66.98 127.53,65.83 v1(127.61,65.83)
  IN2 w0.102: v1(124.44,93.73) 123.92,93.2 123.92,92.91 124.09,92.73 124.09,92.44
  IN2 w0.211: 124.09,92.44 123.67,92.01 123.67,91.27 128.24,86.7 128.24,73.75 127.84,73.36 127.84,72.44 126.91,71.51 126.91,70.26 125.63,68.97 125.63,68.42 126.02,68.02 126.02,67.61 126.23,67.4 126.69,67.4 126.9,67.19 126.9,65.63 126.5,65.22 126.5,64.34 126.71,64.13 127.18,64.13 127.61,64.55 v1(127.61,65.83)
  BOTTOM w0.198: v2(128.4,66.08) 128.27,65.95 127.73,65.95 v1(127.61,65.83)
M_A_A7: length 44.8
  TOP w0.198: v1(128.6,64.51) 128.38,64.29 128.1,64.02 128.1,64.02 127.62,63.54 DIMM2.122 ; XU1.AU21 124.94,96.18 125.36,95.76 125.36,93.68 v1(125.83,93.21)
  IN2 w0.102: v1(125.83,93.21) 125.83,92.93 126.25,92.51 126.25,92.11 126.01,91.86 126.01,91.54
  IN2 w0.211: 126.01,91.54 126.01,91.28 131.02,86.27 131.02,80.92 129.9,79.8 129.9,73.41 130.26,73.05 130.26,71.14 128.88,69.76 128.88,68.87 128.6,68.59 128.6,68.2 128.83,67.97 129.56,67.97 129.81,67.71 129.81,67.25 129.56,66.99 128.83,66.99 128.6,66.75 128.6,66.36 128.84,66.12 129.4,66.12 129.64,65.88 129.64,64.34 129.4,64.1 129.01,64.1 v1(128.6,64.51)
  BOTTOM w0.198: v2(127.63,64.51) v1(128.6,64.51)
M_A_A8: length 42.5
  TOP w0.198: DIMM2.125 126.87,67.65 127.4,67.12 v1(127.58,67.12) ; v1(124.45,97.8) 124.02,97.37 XU1.AT20
  IN2 w0.102: v1(124.45,97.8) 124.45,98.15 124.66,98.36 125.09,98.36 125.27,98.19 125.27,97.53 125.12,97.38 124.96,97.38 124.86,97.28 124.86,96.98 124.96,96.87 125.31,96.87 125.47,96.71 125.47,96.43 125.31,96.26 125.03,96.26 124.89,96.13 124.89,92.35 124.8,92.27
  IN2 w0.211: v1(127.58,67.12) 126.52,68.19 126.52,68.97 126.9,69.36 127.72,69.36 127.93,69.57 127.93,70.15 127.33,70.75 127.33,71.34 128.26,72.27 128.26,73.18 128.66,73.58 128.66,86.87 124.82,90.71 124.82,91.03 124.59,91.26 124.22,91.26 123.98,91.5 123.98,91.84 124.22,92.08 124.61,92.08 124.8,92.27
  BOTTOM w0.198: v2(126.84,67.12) v1(127.58,67.12)
M_A_A9: length 45.4
  TOP w0.198: v1(126.33,97.8) 126.3,97.8 XU1.AT22 ; v1(129.18,71.72) 128.34,70.89 128.34,70.68 127.87,70.21 DIMM2.121
  IN2 w0.102: 125.6,91.1 125.39,91.31 125.39,91.45 125.61,91.67 125.61,91.9 125.31,92.2 125.31,93.61 125.53,93.83 125.53,94.12 125.31,94.34 125.31,94.58 125.53,94.79 125.53,95.09 125.31,95.3 125.31,95.59 125.5,95.77 125.8,95.77 126.15,95.43 126.49,95.43 126.67,95.6 126.67,96.15 126.47,96.35 126.47,96.51 126.67,96.71 126.67,97.2 126.88,97.4 126.88,98.1 126.74,98.24 126.11,98.24 125.86,98.49 125.6,98.49 125.5,98.39 125.5,97.15 125.6,97.04 125.81,97.04 125.96,97.19 125.96,97.65 126.11,97.8 v1(126.33,97.8)
  IN2 w0.211: 125.6,91.1 129.49,87.21 129.49,86.47 129.71,86.24 130.38,86.24 130.61,86.02 130.61,85.42 130.38,85.19 129.71,85.19 129.49,84.96 129.49,84.37 129.71,84.14 130.38,84.14 130.61,83.91 130.61,83.31 130.38,83.08 129.71,83.08 129.49,82.85 129.49,82.26 129.71,82.03 130.38,82.03 130.61,81.8 130.61,81.2 130.38,80.97 129.71,80.97 129.49,80.75 129.49,73.24 129.84,72.88 129.84,71.59 129.69,71.44 129.46,71.44 v1(129.18,71.72)
  BOTTOM w0.198: v1(129.18,71.72) v2(128.47,71.72)
M_A_A10: length 39.9
  TOP w0.198: XU1.AY14 118.54,93.36 118.36,93.19 v1(118.14,93.19) ; DIMM2.146 119.62,62.17 119.45,62.34 v1(119,62.34)
  IN2 w0.102: 118.21,91.94 118.03,92.11 118.03,93.08 v1(118.14,93.19)
  IN2 w0.211: 118.21,91.94 118.21,89.38 120.59,87 120.59,65.06 119.73,64.2 119.73,62.73 120.06,62.4 120.45,62.4 120.72,62.12 120.72,61.56 120.32,61.15 119.41,61.15 119,61.57 v1(119,62.34)
  BOTTOM w0.198: v2(119,61.58) v1(119,62.34)
M_A_A11: length 44.2
  TOP w0.198: v1(128.6,63.19) 128.12,62.72 DIMM2.120 ; XU1.AU22 125.85,96.71 126.02,96.88 v1(126.24,96.88)
  IN2 w0.102: v1(126.24,96.88) 125.98,96.88 125.86,96.76 125.86,96.26 125.75,96.15 125.51,96.15 125.11,95.75 125.11,91.31 125.13,91.29
  IN2 w0.211: v1(128.6,63.19) 127.79,62.38 127.03,62.38 126.78,62.64 126.78,63.12 128.1,64.44 128.1,68.23 127.86,68.47 127.86,68.87 128.37,69.38 128.37,71.79 128.67,72.09 128.67,73.01 129.07,73.41 129.07,87.04 125.13,90.98 125.13,91.29
  BOTTOM w0.198: v1(128.6,63.19) 128.04,63.19 v2(127.63,62.78)
M_A_A12: length 41.9
  TOP w0.198: XU1.AV22 125.85,95.33 v1(126.18,95.01) ; v1(130.27,66.92) 129.23,66.92 128.37,67.78 DIMM2.119
  IN2 w0.102: 126.47,91.9 126.47,92.6 126.25,92.81 126.25,93.15 126.4,93.3 126.4,93.69 126.3,93.79 126.16,93.79 126.03,93.67 125.83,93.67 125.73,93.77 125.73,94.21 125.55,94.38 125.55,94.53 125.73,94.71 125.73,94.9 125.83,95.01 v1(126.18,95.01)
  IN2 w0.211: 126.47,91.9 126.47,91.41 131.43,86.44 131.43,80.04 131.11,79.72 130.58,79.72 130.31,79.45 130.31,78.74 130.56,78.5 131.19,78.5 131.43,78.26 131.43,77.68 131.2,77.44 130.64,77.44 130.31,77.12 130.31,73.58 130.78,73.12 130.78,70.01 130.52,69.75 129.53,69.75 129.29,69.52 129.29,68.94 129.53,68.7 130.5,68.7 130.78,68.43 130.78,67.42 v1(130.27,66.92)
  BOTTOM w0.198: v1(130.27,66.92) v2(129.77,67.43)
M_A_A13: length 39.8
  TOP w0.198: DIMM2.158 116.62,63.96 v1(116.13,64.46) ; XU1.AV12 116.71,95.81 116.88,95.98 v1(117.1,95.98)
  IN2 w0.102: 114.91,93.72 115.01,93.82 115.39,93.82 115.63,94.06 115.63,95.05 116.09,95.51 116.63,95.51 v1(117.1,95.98)
  IN2 w0.211: 114.91,93.72 114.11,92.92 114.11,75.62 115.82,73.91 115.82,70.37 115.1,69.65 115.1,65.91 116.13,64.89 v1(116.13,64.46)
  BOTTOM w0.198: v2(116.65,64.98) v1(116.13,64.46)
M_A_A14: length 42.8
  TOP w0.198: XU1.AV14 118.54,95.45 v1(118.15,95.06) ; DIMM2.151 118.37,70.21 119.68,71.52 v1(119.68,72.3)
  IN2 w0.102: v1(118.15,95.06) 118.15,95.37 117.98,95.54 117.7,95.54 117.53,95.37 117.53,94.78 117.73,94.58 117.73,94 117.37,93.65 117.37,92.85 117.59,92.63 117.59,91.24 117.45,91.1
  IN2 w0.211: v1(119.68,72.3) 119.68,71.44 119.43,71.19 119.07,71.19 118.83,71.43 118.83,72.62 119.33,73.12 119.33,73.55 118.83,74.05 118.83,74.54 119.04,74.75 119.55,74.75 119.76,74.96 119.76,75.62 119.55,75.84 118.78,75.84 118.57,76.05 118.57,76.68 118.78,76.89 119.55,76.89 119.76,77.1 119.76,77.73 119.55,77.94 118.62,77.94 118.41,78.15 118.41,78.79 118.62,79 119.55,79 119.76,79.21 119.76,79.84 119.55,80.05 118.6,80.05 118.39,80.26 118.39,80.89 118.6,81.11 119.55,81.11 119.76,81.32 119.76,81.95 119.5,82.21 118.72,82.21 118.38,82.55 118.38,86.06 118.41,86.09 118.41,86.12 119.02,86.73 119.02,87.4 118.62,87.8 117.62,87.8 117.18,88.25 117.18,90.81 117.17,90.82 117.45,91.1
  BOTTOM w0.198: v1(119.68,72.3) v2(118.93,71.55)
M_A_A15: length 38.2
  TOP w0.198: DIMM2.156 117.12,64.98 v1(116.05,66.06) ; v1(115.21,93.35) 115.45,93.35 XU1.AY11
  IN2 w0.211: v1(115.21,93.35) 114.52,92.66 114.52,77.62 114.96,77.18 114.96,76.65 114.52,76.22 114.52,75.84 116.42,73.94 116.42,70.06 116.45,70.03 117.31,69.17 117.31,68.61 116.99,68.29 116.56,68.29 116.25,68.6 115.83,68.6 115.52,68.28 115.52,66.36 115.82,66.06 v1(116.05,66.06)
  BOTTOM w0.198: v1(116.05,66.06) v2(115.26,66.06)
M_A_A16: length 40.6
  TOP w0.198: XU1.AW13 117.38,94.61 117.1,94.32 v1(117.1,94.14) ; DIMM2.152 118.12,61.98 118.01,62.1 118.01,64.05 118.9,64.94 v1(119,64.94)
  IN2 w0.102: 117.33,92.3 117.33,92.59 117.17,92.75 117.17,93.51 117.05,93.63 116.91,93.63 116.79,93.51 116.65,93.51 116.55,93.61 116.55,93.84 116.85,94.14 v1(117.1,94.14)
  IN2 w0.211: v1(119,64.94) 119.13,64.81 119.55,64.81 119.78,65.05 119.78,65.39 119.38,65.8 119.38,66.97 120.17,67.77 120.17,69.83 119.82,70.18 118.96,70.18 118.41,70.73 118.41,75.48 117.97,75.93 117.97,86.23 117.99,86.26 117.99,86.29 118.34,86.63 118.34,87.11 118.06,87.39 117.33,87.39 116.76,87.95 116.76,91.07 117.33,91.65 117.33,92.3
  BOTTOM w0.198: v1(119,64.94) 119.61,64.94 v2(119.76,65.09)
M_A_ACT#: length 43.3
  TOP w0.198: XU1.AU24 128.12,95.99 v1(128.16,95.99) ; DIMM2.114 129.62,63.25 130.17,63.79 v1(130.17,64.61)
  IN2 w0.102: 127.39,92.04 127.18,92.25 127.18,92.71 126.81,93.08 126.81,95.17 127.12,95.48 127.6,95.48 127.74,95.62 127.74,96.39 127.84,96.5 128.25,96.5 128.35,96.39 128.35,96.18 v1(128.16,95.99)
  IN2 w0.211: v1(130.17,64.61) 131,64.61 131.88,65.49 131.88,72.74 132.15,73.01 132.15,73.5 131.41,74.24 131.41,75.99 132.53,77.11 132.53,86.89 127.39,92.04
  BOTTOM w0.198: v1(130.17,64.61) v2(130.96,64.61)
M_A_ALERT#: length 42.9
  TOP w0.102: v1(127.3,97.81) 127.07,97.81 126.77,97.51 XU1.AT23
  TOP w0.127: v1(130.3,65.52) 129.12,64.35 DIMM2.116
  IN2 w0.102: 126.97,91.68 126.85,91.8 126.85,92.76 126.61,92.99 126.61,95.25 126.87,95.52 126.87,97.07 127.3,97.49 v1(127.3,97.81)
  IN2 w0.127: 126.97,91.68 131.98,86.67 131.98,77.34 130.86,76.22 130.86,73.81 131.33,73.35 131.33,66.55 v1(130.3,65.52)
  BOTTOM w0.127: v2(131.19,66.41) v1(130.3,65.52)
M_A_BA0: length 40.3
  TOP w0.198: XU1.AY13 117.62,92.9 117.17,92.45 v1(116.71,92.45) ; DIMM2.150 118.62,62.05 118.51,62.16 118.51,63.39 118.76,63.64 v1(119,63.64)
  IN2 w0.211: v1(119,63.64) 118.82,63.46 118.8,63.46 118.04,62.7 117.4,62.7 117.02,63.08 117.02,63.92 118.96,65.87 118.96,67.29 119.68,68.01 119.68,68.87 118,70.56 118,75.31 117.55,75.75 117.55,86.37 116.23,87.69 116.23,91.96 v1(116.71,92.45)
  BOTTOM w0.198: v1(119,63.64) 119.39,63.64 v2(119.72,63.3)
M_A_BA1: length 42.3
  TOP w0.198: v1(119.03,96.01) 119.03,95.69 119.2,95.52 XU1.AV15 ; v1(119.71,70.7) 119.87,70.54 DIMM2.145
  IN2 w0.102: v1(119.03,96.01) 119.26,95.77 119.73,95.77 120,96.05 120,96.44 120.27,96.71 120.27,97.98 120.17,98.08 119.58,98.08 119.48,97.98 119.48,96.74 119.22,96.48 118.71,96.48 118.58,96.35 118.58,95.86 118.74,95.7 118.74,95.4 118.58,95.24 118.58,94.84 118.69,94.73 118.69,94.44 118.58,94.33 118.58,94.3 118.58,94.3 118.58,93.83 118.41,93.67 117.8,93.67 117.6,93.46 117.6,92.91 117.83,92.68 117.83,90.83 117.8,90.79
  IN2 w0.211: 117.8,90.79 117.59,90.59 117.59,88.65 118.02,88.21 118.79,88.21 120.17,86.83 120.17,86.49 119.89,86.21 119.08,86.21 118.82,85.94 118.82,85.41 119.08,85.15 119.87,85.15 120.17,84.84 120.17,84.4 119.87,84.1 119.08,84.1 118.79,83.81 118.79,83.33 119.08,83.04 119.87,83.04 120.17,82.73 120.17,71.17 v1(119.71,70.7)
  BOTTOM w0.198: v1(119.71,70.7) v2(120.67,70.7)
M_A_BG0: length 41.5
  TOP w0.198: XU1.AW23 127.02,94.61 127.24,94.39 v1(127.24,94.12) ; DIMM2.115 129.37,70.28 130.18,71.08 130.91,71.08 131.68,71.85 v1(132.38,71.85)
  IN2 w0.102: v1(127.24,94.12) 127.24,93.91 127.67,93.48 127.67,92.38
  IN2 w0.211: 127.67,92.38 127.95,92.11 128.63,92.11 128.88,91.86 128.88,91.14 129.88,90.13 130.2,90.13 130.49,90.41 130.81,90.41 131.23,89.99 131.23,89.67 130.95,89.39 130.95,89.06 131.37,88.64 131.7,88.64 131.98,88.92 132.3,88.92 132.72,88.5 132.72,88.18 132.44,87.89 132.44,87.57 132.8,87.21 133.5,87.21 133.78,86.93 133.78,86.23 132.95,85.39 132.95,84.99 133.18,84.76 133.55,84.76 133.78,84.53 133.78,83.94 133.55,83.71 133.18,83.71 132.95,83.48 132.95,82.88 133.18,82.65 133.55,82.65 133.78,82.42 133.78,81.83 133.55,81.6 133.18,81.6 132.95,81.37 132.95,80.77 133.18,80.54 133.55,80.54 133.78,80.32 133.78,79.72 133.55,79.49 133.18,79.49 132.95,79.26 132.95,76.53 132.55,76.14 132.15,76.14 131.83,75.82 131.83,74.49 132.15,74.16 132.78,74.16 133.02,73.92 133.02,73.55 132.79,73.32 132.79,73 133.05,72.74 133.43,72.74 133.65,72.52 133.65,72.18 133.2,71.72 132.51,71.72 v1(132.38,71.85)
  BOTTOM w0.198: v1(132.38,71.85) v2(133.09,71.85)
M_A_BG1: length 42.2
  TOP w0.198: DIMM2.113 129.87,70.15 130.3,70.58 v1(132.38,70.58) ; v1(127.3,95.06) 127.22,95.06 XU1.AV23
  IN2 w0.102: 128,92.7 128,93.52 127.66,93.87 127.66,94.4 127.84,94.58 127.84,94.81 127.58,95.06 v1(127.3,95.06)
  IN2 w0.211: 128,92.7 128.28,92.42 128.8,92.42 129.19,92.03 129.19,91.37 129.51,91.05 130.87,91.05 134.2,87.72 134.2,78.51 133.68,77.99 133.68,77.08 134.09,76.67 134.09,76.16 133.73,75.81 133.32,75.81 132.99,75.48 132.99,74.97 133.3,74.67 133.83,74.67 134.09,74.41 134.09,73.93 133.68,73.52 133.68,73.08 134.09,72.67 134.09,72.02 133.8,71.74 133.8,70.85 134.09,70.56 134.09,69.2 133.32,68.44 132.74,68.44 132.51,68.67 132.51,69.18 133.15,69.81 133.15,70.24 132.81,70.58 v1(132.38,70.58)
  BOTTOM w0.198: v1(132.38,70.58) v2(131.67,70.58)
M_A_CKE0: length 41.7
  TOP w0.198: v1(132.48,67.21) 131.58,67.21 130.87,67.92 DIMM2.109 ; v1(128.42,93.07) 128.42,93.13 127.86,93.69 XU1.AY24
  IN2 w0.211: v1(132.48,67.21) 132.85,66.84 133.37,66.84 133.7,67.17 133.7,67.83 134.6,68.73 134.6,70.78 134.31,71.06 134.31,71.52 134.6,71.81 134.6,74.63 134.24,74.99 134.24,75.59 134.6,75.95 134.6,76.92 134.31,77.21 134.31,77.9 134.71,78.3 134.71,88.72 134.4,89.03 133.61,89.03 133.19,89.46 133.19,89.75 133.92,90.48 133.92,90.91 133.6,91.23 133.17,91.23 132.44,90.5 132.14,90.5 131.52,91.12 131.52,91.49 131.81,91.79 131.81,92.21 131.52,92.5 130.58,92.5 130.25,92.83 130.25,93.08 130.25,93.09 130.25,93.34 129.92,93.67 129.02,93.67 v1(128.42,93.07)
  BOTTOM w0.198: v1(132.48,67.21) v2(133.19,67.21)
M_A_CKE1: length 42.5
  TOP w0.198: XU1.AW24 128.14,95.07 v1(128.14,95.09) ; v1(130.15,63.03) 130.15,63.03 130.62,62.56 DIMM2.110
  IN2 w0.102: 130.39,93.87 130.39,94.32 130.14,94.57 128.67,94.57 v1(128.14,95.09)
  IN2 w0.211: v1(130.15,63.03) 134.24,67.12 134.24,67.78 135.13,68.67 135.13,91 132.48,93.64 130.62,93.64 130.39,93.87
  BOTTOM w0.198: v2(129.44,63.03) v1(130.15,63.03)
M_A_CLK0: length 35.3
  TOP w0.173: v1(121.72,95.08) 121.86,95.08 122.19,94.74 XU1.AW18
  TOP w0.191: DIMM2.137 123.87,70.65 123.46,71.07 123.23,71.07 123.04,71.26 v1(123.04,71.36)
  IN2 w0.102: v1(121.72,95.08) 121.72,95.16 121.45,95.43 120.63,95.43 120.34,95.14 120.34,94.91 120.32,94.88
  IN2 w0.185: 120.32,94.88 120.32,90.26 122.7,87.88 122.7,86.9 122.88,86.72 123.32,86.72 123.67,86.36 123.67,85.57 123.32,85.22 122.88,85.22 122.7,85.03 122.7,84.47 122.88,84.29 123.32,84.29 123.67,83.94 123.67,83.14 123.32,82.79 122.88,82.79 122.7,82.6 122.7,82.05 122.88,81.86 123.32,81.86 123.67,81.51 123.67,80.71 123.32,80.36 122.88,80.36 122.7,80.17 122.7,79.62 122.88,79.43 123.32,79.43 123.67,79.08 123.67,78.28 123.32,77.93 122.88,77.93 122.7,77.75 122.7,72.9 122.7,71.58 122.91,71.36 v1(123.04,71.36)
M_A_CLK0#: length 35.2
  TOP w0.173: XU1.AV18 121.77,95.94 v1(121.72,95.94)
  TOP w0.191: DIMM2.139 123.37,70.26 v1(123.04,70.6)
  IN2 w0.102: v1(121.72,95.94) 121.72,95.9 121.44,95.63 120.55,95.63 120.03,95.11
  IN2 w0.185: 120.03,95.11 120.03,90.14 122.41,87.76 122.41,86.78 122.76,86.43 123.2,86.43 123.38,86.24 123.38,85.69 123.2,85.5 122.76,85.5 122.41,85.15 122.41,84.35 122.76,84 123.2,84 123.38,83.82 123.38,83.26 123.2,83.07 122.76,83.07 122.41,82.72 122.41,81.93 122.76,81.57 123.2,81.57 123.38,81.39 123.38,80.83 123.2,80.65 122.76,80.65 122.41,80.29 122.41,79.5 122.76,79.14 123.2,79.14 123.38,78.96 123.38,78.4 123.2,78.22 122.76,78.22 122.41,77.86 122.41,73.02 122.41,71.46 122.58,71.29 122.58,71.05 123.02,70.6 v1(123.04,70.6)
M_A_CLK1: length 36.5
  TOP w0.173: v1(121.71,94.19) 121.29,94.61 XU1.AW17
  TOP w0.191: DIMM2.138 123.62,61.99 122.86,62.76 122.86,63.34 123.16,63.64 v1(123.34,63.64)
  IN2 w0.102: v1(121.71,94.19) 121.44,93.92 121.44,93.64 121.34,93.54 121.34,93.1 121.51,92.92 121.51,92.63 121.55,92.59 121.55,92.54 121.6,92.5 121.6,92.49
  IN2 w0.185: v1(123.34,63.64) 123.44,63.64 124.18,64.38 124.18,77.36 124.71,77.89 124.71,87.07 121.6,90.18 121.6,92.49
M_A_CLK1#: length 36.5
  TOP w0.173: v1(120.85,94.13) 120.85,94.12 XU1.AY17
  TOP w0.191: v1(123.34,64.4) 122.57,63.63 122.57,62.64 123.12,62.08 DIMM2.140
  IN2 w0.102: v1(120.85,94.13) 121.02,94.13 121.23,93.92 121.23,93.72 121.13,93.62 121.13,93.01 121.31,92.84 121.31,92.49
  IN2 w0.185: 121.31,92.49 121.31,90.07 124.43,86.95 124.43,78.01 123.89,77.48 123.89,64.59 123.71,64.4 v1(123.34,64.4)
M_A_CS#0: length 42.3
  TOP w0.198: v1(118.39,67.86) 118.87,68.35 DIMM2.149 ; v1(116.26,94.19) 116.46,94.4 116.5,94.4 XU1.AW12
  IN2 w0.211: v1(116.26,94.19) 116.18,94.11 116.18,92.62 115.49,91.94 115.49,86.93 115.85,86.58 116.61,86.58 117.04,86.16 117.04,85.73 116.74,85.44 115.7,85.44 115.45,85.19 115.45,84.64 115.7,84.39 116.74,84.39 117.04,84.09 117.04,83.6 116.77,83.33 115.73,83.33 115.45,83.06 115.45,82.53 115.7,82.28 116.74,82.28 117.04,81.99 117.04,81.52 116.74,81.23 115.7,81.23 115.45,80.97 115.45,80.42 115.7,80.17 116.77,80.17 117.04,79.9 117.04,79.31 116.72,78.99 115.8,78.99 115.49,78.68 115.49,78.2 115.75,77.94 116.72,77.94 117.04,77.62 117.04,74.77 117.48,74.33 117.48,70.34 119.05,68.77 119.05,68.21 118.69,67.86 v1(118.39,67.86)
  BOTTOM w0.198: v1(118.39,67.86) v2(119.43,67.86)
M_A_CS#1: length 43.2
  TOP w0.198: v1(116.26,95.97) 116.24,95.98 XU1.AU11 ; v1(115.34,71.47) 116.15,71.47 116.87,70.74 DIMM2.157
  IN2 w0.211: v1(115.34,71.47) 115.18,71.47 114.26,72.39 114.26,74.09 113.07,75.28 113.07,96.9 113.64,97.46 113.64,101.28 113.99,101.64 114.41,101.64 115.78,100.27 115.78,96.45 v1(116.26,95.97)
  BOTTOM w0.198: v2(114.53,71.49) 114.55,71.47 v1(115.34,71.47)
M_A_DQ0: length 60.6
  TOP w0.102: XU1.AE38 140.08,107.01 v1(140.04,107.01)
  TOP w0.127: DIMM2.3 v1(157.37,68)
  IN2 w0.127: v1(157.37,68) 156.96,68 156.81,68.15 156.81,68.96 157.02,69.18 157.73,69.18 157.88,69.33 157.88,69.91 157.73,70.06 156.95,70.06 156.79,70.22 156.79,70.55 156.94,70.69 157.77,70.69 157.94,70.86 157.94,71.19 157.79,71.33 156.95,71.33 156.79,71.49 156.79,71.8 156.96,71.96 157.77,71.96 157.94,72.13 157.94,96.12 157.94,96.43 146.55,107.81 145.92,107.81 145.79,107.94 145.52,107.94 145.21,107.64 144.85,107.64 144.55,107.94 142.57,107.94 142.08,107.46 141.55,107.46 141.37,107.28 141.37,106.59 141.2,106.42 140.21,106.42 140.04,106.59 v1(140.04,107.01)
  BOTTOM w0.127: v2(158.09,68) v1(157.37,68)
M_A_DQ1: length 61.9
  TOP w0.102: v1(140.02,107.88) 140.02,107.86 XU1.AE37
  TOP w0.127: v1(157.35,62.35) 157.12,62.12 DIMM2.4
  IN2 w0.127: v1(157.35,62.35) 157.58,62.58 157.58,65.6 158.72,66.74 158.72,96.72 146.84,108.6 146.53,108.6 146.53,108.6 140.74,108.6 v1(140.02,107.88)
  BOTTOM w0.127: v1(157.35,62.35) v2(158.33,62.35)
M_A_DQ2: length 59.9
  TOP w0.102: v1(140.94,105.12) 140.92,105.14 XU1.AG38
  TOP w0.127: v1(154.02,67.93) 153.87,68.08 DIMM2.17
  IN2 w0.102: v1(140.94,105.12) 141.19,105.12 141.67,105.6 141.68,105.6 141.68,105.61 142.12,105.61 142.38,105.34
  IN2 w0.127: v1(154.02,67.93) 153.57,67.48 153.57,64.58 153.8,64.35 154.68,64.35 154.94,64.61 154.94,64.96 154.57,65.33 154.57,65.51 154.94,65.88 154.94,66.23 154.53,66.64 154.53,67.12 154.86,67.45 154.86,68.47 154.46,68.87 154.07,68.87 153.59,69.36 153.59,73.91 155.5,75.82 155.5,80.53 154.84,81.19 154.84,81.55 155.12,81.83 155.12,85.86 154.43,86.54 154.43,96.15 145.6,104.99 142.74,104.99 142.38,105.34
  BOTTOM w0.127: v2(154.79,67.93) v1(154.02,67.93)
M_A_DQ3: length 60.7
  TOP w0.102: v1(139.11,105.97) 139.18,105.97 XU1.AG37
  TOP w0.127: v1(153.02,70.73) 153.01,70.73 152.87,70.6 DIMM2.21
  IN2 w0.102: 141.5,104.58 141.1,104.18 140.54,104.18 140.05,104.66 139.67,104.66 139.19,104.18 138.89,104.18 138.7,104.37 138.7,105.56 v1(139.11,105.97)
  IN2 w0.127: 141.5,104.58 145.46,104.58 154.05,96 154.05,85.8 154.19,85.66 154.57,85.66 154.71,85.52 154.71,85.17 154.57,85.03 154.19,85.03 154.05,84.89 154.05,84.53 154.19,84.39 154.57,84.39 154.71,84.25 154.71,83.9 154.57,83.76 154.19,83.76 154.05,83.62 154.05,83.26 154.19,83.12 154.57,83.12 154.71,82.98 154.71,82.63 154.57,82.49 154.19,82.49 154.05,82.35 154.05,81.12 154.86,80.3 154.86,79.85 154.68,79.67 153.97,79.67 153.82,79.52 153.82,79.1 153.96,78.96 154.9,78.96 155.04,78.82 155.04,78.46 154.9,78.32 153.96,78.32 153.82,78.18 153.82,77.83 153.96,77.69 154.9,77.69 155.04,77.55 155.04,77.19 154.9,77.05 153.96,77.05 153.82,76.91 153.82,76.56 153.96,76.42 154.9,76.42 155.04,76.28 155.04,75.92 154.9,75.78 153.96,75.78 153.82,75.64 153.82,74.68 152.93,73.79 152.93,72.63 152.55,72.24 152.55,71.2 v1(153.02,70.73)
  BOTTOM w0.127: v2(153.02,69.99) v1(153.02,70.73)
M_A_DQ4: length 59.5
  TOP w0.102: v1(141.85,107.91) 141.4,107.45 XU1.AE39
  TOP w0.127: v1(156.23,62.35) 156.12,62.24 DIMM2.8
  IN2 w0.127: v1(141.85,107.91) 142.16,108.22 146.69,108.22 158.34,96.56 158.34,66.9 156.67,65.22 156.67,62.78 v1(156.23,62.35)
  BOTTOM w0.127: v2(156.77,61.58) 156.77,61.81 v1(156.23,62.35)
M_A_DQ5: length 58.3
  TOP w0.127: DIMM2.7 v1(156.37,68.01) ; v1(141.83,106.92) 142.31,107.4 XU1.AE40
  IN2 w0.127: v1(156.37,68.01) 156.37,69.34 156.21,69.51 155.85,69.51 155.65,69.71 155.65,69.99 155.83,70.17 156.26,70.17 156.41,70.32 156.41,71.69 156.06,72.05 156.06,72.4 156.26,72.6 157.37,72.6 157.55,72.79 157.55,73.07 157.38,73.24 156.47,73.24 156.28,73.42 156.28,73.7 156.49,73.9 157.35,73.9 157.55,74.11 157.55,96.27 146.4,107.43 145.69,107.43 145.31,107.05 144.91,107.05 144.37,107.58 144.09,107.58 143.71,107.2 143.36,107.2 142.98,107.58 142.7,107.58 142.54,107.43 142.54,107.13 142.76,106.91 142.76,106.58 142.6,106.42 142.01,106.42 141.83,106.59 v1(141.83,106.92)
  BOTTOM w0.127: v2(156.37,68.77) v1(156.37,68.01)
M_A_DQ6: length 58.9
  TOP w0.102: v1(144.49,105.49) 143.95,106.03 141.85,106.03 XU1.AG39
  TOP w0.127: DIMM2.20 153.12,62.36 v1(153.01,62.47)
  IN2 w0.127: v1(144.49,105.49) 145.63,105.49 154.81,96.31 154.81,86.7 155.88,85.63 155.88,75.66 153.97,73.75 153.97,70.31 155.32,68.96 155.32,63.77 155.17,63.62 154.84,63.62 154.71,63.74 154.28,63.74 153.99,63.45 153.99,61.88 153.77,61.66 153.41,61.66 153.21,61.86 153.21,62.27 v1(153.01,62.47)
  BOTTOM w0.127: v2(153.01,61.74) v1(153.01,62.47)
M_A_DQ7: length 57.7
  TOP w0.102: v1(143.19,105.43) 143.04,105.58 XU1.AG40
  TOP w0.127: v1(154.46,62.63) 154.13,62.3 154.13,61.08 DIMM2.16
  IN2 w0.127: v1(154.46,62.63) 154.46,62.17 154.79,61.84 155.42,61.84 155.7,62.12 155.7,69.12 154.43,70.39 154.43,73.68 156.26,75.5 156.26,85.79 155.19,86.86 155.19,96.47 145.74,105.92 143.4,105.92 143.19,105.72 v1(143.19,105.43)
  BOTTOM w0.127: v1(154.46,62.63) 154.91,62.63 v2(155.14,62.85)
M_A_DQ8: length 55.9
  TOP w0.102: XU1.AJ38 140.07,103.34 v1(140.07,103.31)
  TOP w0.127: v1(150.77,70.55) 150.87,70.45 DIMM2.29
  IN2 w0.102: v1(140.07,103.31) 140.44,103.68 141.11,103.68 141.42,103.37 141.42,103.13 141.92,102.63 142.04,102.63
  IN2 w0.127: 142.04,102.63 145.05,102.63 152.37,95.3 152.37,92.49 151.66,91.77 151.66,91.34 151.94,91.06 151.94,89.08 151.66,88.8 151.66,88.46 151.8,88.32 152.23,88.32 152.37,88.18 152.37,87.82 152.23,87.68 151.8,87.68 151.66,87.54 151.66,87.19 151.8,87.05 152.23,87.05 152.37,86.91 152.37,86.55 152.23,86.41 151.8,86.41 151.66,86.27 151.66,85.92 151.8,85.78 152.23,85.78 152.37,85.64 152.37,85.28 152.23,85.14 151.8,85.14 151.66,85 151.66,83.81 151.03,83.17 151.03,82.44 151.23,82.23 151.23,81.59 151.37,81.45 151.98,81.45 152.12,81.31 152.12,80.96 151.98,80.82 151.37,80.82 151.23,80.68 151.23,80.32 151.37,80.18 151.98,80.18 152.12,80.04 152.12,79.69 151.98,79.55 151.37,79.55 151.23,79.41 151.23,79.05 151.37,78.91 151.98,78.91 152.12,78.77 152.12,78.42 151.98,78.28 151.37,78.28 151.23,78.14 151.23,77.78 151.37,77.64 151.98,77.64 152.12,77.5 152.12,77.15 151.98,77.01 151.37,77.01 151.23,76.87 151.23,75.09 150.92,74.78 150.21,74.07 150.21,73.73 150.35,73.59 150.63,73.59 150.77,73.45 150.77,73.09 150.63,72.95 150.35,72.95 150.21,72.81 150.21,72.46 150.35,72.32 150.63,72.32 150.77,72.18 150.77,71.82 150.63,71.68 150.35,71.68 150.21,71.54 150.21,70.75 150.42,70.55 v1(150.77,70.55)
  BOTTOM w0.127: v1(150.77,70.55) 150.77,70.25 v2(150.44,69.92)
M_A_DQ9: length 56.8
  TOP w0.102: v1(139.14,103.32) XU1.AJ37
  TOP w0.127: v1(150.9,59.68) 151.12,59.9 DIMM2.28
  IN2 w0.102: 142.04,103.71 141.65,103.71 141.48,103.88 139.7,103.88 v1(139.14,103.32)
  IN2 w0.127: 142.04,103.71 142.41,103.35 142.41,103.23 142.76,102.88 145.34,102.88 152.75,95.46 152.75,84.34 152.53,84.11 152.53,76.37 151.64,75.48 151.64,73.16 151.26,72.78 151.26,70.3 150.9,69.94 v1(150.9,59.68)
  BOTTOM w0.127: v2(150.61,60.34) 150.61,59.97 v1(150.9,59.68)
M_A_DQ10: length 54.8
  TOP w0.102: XU1.AL38 140.07,101.51 v1(140.02,101.51)
  TOP w0.127: v1(147.55,62.34) 147.62,62.26 DIMM2.42
  IN2 w0.127: v1(147.55,62.34) 147.55,61.76 147.42,61.64 146.78,61.64 146.58,61.83 146.58,62.74 147.95,64.11 147.95,68.89 147.32,69.53 147.32,71.01 147.09,71.24 147.09,75.16 147.36,75.44 147.67,75.75 147.67,80.83 147.24,81.26 147.24,82.97 147.55,83.28 147.55,83.54 147.24,83.85 147.24,84.3 147.38,84.44 147.61,84.44 147.75,84.58 147.75,84.94 147.61,85.08 147.38,85.08 147.24,85.22 147.24,85.57 147.38,85.71 147.86,85.71 148,85.85 148,86.21 147.86,86.35 147.38,86.35 147.24,86.49 147.24,86.84 147.38,86.98 147.61,86.98 147.75,87.12 147.75,87.48 147.61,87.62 147.38,87.62 147.24,87.76 147.24,88.11 147.38,88.25 147.94,88.25 148.08,88.39 148.08,88.75 147.94,88.89 147.38,88.89 147.24,89.03 147.24,89.38 147.38,89.52 147.76,89.52 147.9,89.66 147.9,90.02 147.76,90.16 147.38,90.16 147.24,90.3 147.24,90.68 145.57,92.35 145.57,98.11 143.13,100.54 141.66,100.54 141.13,101.08 140.45,101.08 v1(140.02,101.51)
  BOTTOM w0.127: v2(147.55,61.59) v1(147.55,62.34)
M_A_DQ11: length 55.8
  TOP w0.102: XU1.AL37 v1(139.11,102.38)
  TOP w0.127: v1(148.72,59.81) 148.62,59.9 DIMM2.38
  IN2 w0.102: 142.31,101.58 142.31,101.66 142.02,101.96 139.53,101.96 v1(139.11,102.38)
  IN2 w0.127: v1(148.72,59.81) 148.72,60.37 148.59,60.49 147.7,60.49 147.57,60.62 147.57,61 147.7,61.13 148.59,61.13 148.72,61.25 148.72,63.59 148.44,63.87 148.44,74.67 149.55,75.78 149.55,80.5 149.2,80.85 148.73,80.85 148.31,81.27 148.31,83.52 149.99,85.2 149.99,89.01 146.38,92.62 146.38,98.47 143.83,101.02 142.87,101.02 142.31,101.58
  BOTTOM w0.127: v1(148.72,59.81) v2(148.72,60.52)
M_A_DQ12: length 53.7
  TOP w0.102: XU1.AJ40 142.68,103.38 v1(142.87,103.38)
  TOP w0.127: v1(151.86,67.96) 151.87,67.97 DIMM2.25
  IN2 w0.127: v1(151.86,67.96) 152.3,67.53 152.3,66.31 152.09,66.11 152.09,64.05 151.89,63.85 151.48,63.85 151.28,64.05 151.28,69.78 151.64,70.14 151.64,72.62 152.02,73 152.02,74.45 152.91,75.34 152.91,83.96 153.14,84.19 153.14,95.62 145.65,103.11 143.15,103.11 v1(142.87,103.38)
  BOTTOM w0.127: v2(151.86,68.67) v1(151.86,67.96)
M_A_DQ13: length 54.7
  TOP w0.102: XU1.AJ39 141.79,104.14 v1(141.86,104.14)
  TOP w0.127: v1(151.79,62.6) 151.79,62.45 152.12,62.11 DIMM2.24
  IN2 w0.127: v1(151.79,62.6) 151.79,61.86 152.02,61.64 152.27,61.64 152.47,61.84 152.47,65.95 152.68,66.15 152.68,68.01 152.02,68.67 152.02,72.47 152.4,72.85 152.4,74.29 153.29,75.18 153.29,83.8 153.52,84.03 153.52,95.78 145.15,104.14 v1(141.86,104.14)
  BOTTOM w0.127: v2(151.27,62.08) v1(151.79,62.6)
M_A_DQ14: length 53.5
  TOP w0.102: XU1.AL39 141.8,101.52 v1(141.86,101.52)
  TOP w0.127: v1(147.9,70.61) 147.87,70.58 DIMM2.41
  IN2 w0.127: v1(141.86,101.52) 141.6,101.26 141.6,100.98 141.81,100.77 142,100.77 142.21,100.98 142.49,100.98 142.7,100.77 143.64,100.77 143.84,100.57 143.84,100.16 144.06,99.94 144.47,99.94 144.7,99.71 144.7,99.3 144.92,99.08 145.36,99.08 145.62,98.82 145.62,98.38 145.95,98.05 145.95,92.51 148.89,89.56 148.89,89.3 148.66,89.07 148.66,88.8 148.8,88.66 149.41,88.66 149.55,88.52 149.55,88.16 149.41,88.02 148.8,88.02 148.66,87.88 148.66,87.53 148.8,87.39 149.41,87.39 149.55,87.25 149.55,86.89 149.41,86.75 148.8,86.75 148.66,86.61 148.66,86.26 148.8,86.12 149.41,86.12 149.55,85.98 149.55,85.62 149.41,85.48 148.8,85.48 148.66,85.34 148.66,85.05 148.82,84.9 148.82,84.57 147.93,83.68 147.93,83.12 147.62,82.81 147.62,82.51 147.8,82.34 147.8,81.93 147.62,81.75 147.62,81.42 148.06,80.99 148.06,80.46 148.19,80.32 149.03,80.32 149.17,80.18 149.17,79.83 149.03,79.69 148.19,79.69 148.06,79.55 148.06,79.19 148.19,79.05 149.03,79.05 149.17,78.91 149.17,78.56 149.03,78.42 148.19,78.42 148.06,78.28 148.06,77.92 148.19,77.78 149.03,77.78 149.17,77.64 149.17,77.29 149.03,77.15 148.19,77.15 148.06,77.01 148.06,76.65 148.19,76.51 149.03,76.51 149.17,76.37 149.17,76.02 149.03,75.88 148.34,75.88 147.47,75.01 147.47,74.49 147.62,74.34 147.93,74.34 148.06,74.21 148.06,73.83 147.93,73.7 147.67,73.7 147.47,73.5 147.47,73.15 147.61,73.01 147.92,73.01 148.06,72.87 148.06,72.52 147.92,72.38 147.61,72.38 147.47,72.24 147.47,71.54 147.9,71.11 v1(147.9,70.61)
  BOTTOM w0.127: v1(147.9,70.61) 148.15,70.61 v2(148.56,70.2)
M_A_DQ15: length 52.6
  TOP w0.102: v1(142.89,101.61) 142.63,101.61 XU1.AL40
  TOP w0.127: v1(148.92,67.99) 148.87,68.03 DIMM2.37
  IN2 w0.102: 144.03,101.56 143.59,102 143.03,102 142.89,101.86 v1(142.89,101.61)
  IN2 w0.127: v1(148.92,67.99) 148.92,68.6 148.97,68.65 148.97,68.66 149.45,69.14 149.45,69.56 148.92,70.09 148.92,74.61 149.93,75.63 149.93,80.99 149.69,81.23 148.89,81.23 148.72,81.41 148.72,81.9 148.89,82.08 149.17,82.08 149.38,82.29 149.38,83.4 149.2,83.58 149.2,83.87 149.52,84.19 149.7,84.19 149.85,84.04 150.06,84.04 150.32,84.29 150.32,84.47 150.15,84.64 150.15,84.82 150.37,85.04 150.37,89.9 150.64,90.17 150.64,90.35 150.37,90.62 150.19,90.62 149.73,90.16 149.55,90.16 149.27,90.44 149.27,90.62 149.7,91.05 149.7,91.23 149.43,91.5 149.25,91.5 148.82,91.07 148.64,91.07 146.76,92.95 146.76,96.06 146.89,96.19 148.16,96.19 148.28,96.31 148.28,96.7 148.16,96.82 146.89,96.82 146.76,96.95 146.76,97.33 146.89,97.46 147.88,97.46 148,97.58 148,97.84 147.75,98.09 146.89,98.09 146.76,98.22 146.76,99.08 146.51,99.33 146.02,99.33 145.74,99.61 145.74,100.09 145.54,100.29 145.11,100.29 144.89,100.51 144.89,100.94 144.71,101.13 144.28,101.13 144.03,101.37 144.03,101.56
  BOTTOM w0.127: v1(148.92,67.99) 149.27,68.34 v2(149.27,68.62)
M_A_DQ16: length 48.6
  TOP w0.102: v1(140.93,100.62) 140.93,100.55 XU1.AN38
  TOP w0.127: DIMM2.45 v1(146.87,68.01)
  IN2 w0.127: v1(146.87,68.01) 146.4,67.54 146.4,64.1 146.61,63.9 146.99,63.9 147.39,64.3 147.39,68.7 146.79,69.31 146.79,70.79 146.56,71.02 146.56,75.39 147.14,75.97 147.14,80.61 146.71,81.04 146.71,90.46 145.03,92.13 145.03,98.29 143.03,100.29 141.26,100.29 v1(140.93,100.62)
  BOTTOM w0.127: v1(146.87,68.01) 147.21,67.68 v2(147.52,67.68)
M_A_DQ17: length 46.8
  TOP w0.102: XU1.AN40 v1(141.83,99.61)
  TOP w0.127: v1(145.46,62.45) 145.62,62.29 DIMM2.50
  IN2 w0.127: v1(141.83,99.61) 142.57,98.87 142.57,98.59 142.98,98.19 143.39,98.19 143.61,97.97 143.61,97.55 143.2,97.14 143.2,92.22 145.57,89.86 145.57,80.2 146,79.77 146,76.44 145.11,75.55 145.11,73.02 144.83,72.74 144.83,68.52 145.31,68.04 145.31,66.84 144.47,66 144.47,65.22 144.35,65.09 143.74,65.09 143.61,64.96 143.61,64.58 143.74,64.46 144.35,64.46 144.47,64.33 144.47,62.07 144.68,61.86 145.26,61.86 145.46,62.07 v1(145.46,62.45)
  BOTTOM w0.127: v1(145.46,62.45) 145.63,62.28 v2(145.63,61.72)
M_A_DQ18: length 47.1
  TOP w0.102: v1(140.05,97.83) 140.05,97.83 XU1.AR38
  TOP w0.127: DIMM2.63 v1(142.37,68.02)
  IN2 w0.102: 141.42,96.64 141.42,97.01 141,97.43 140.73,97.43 140.51,97.66 140.51,99.11 140.41,99.21 139.76,99.21 139.66,99.11 139.66,98.87 139.56,98.77 139.27,98.77 139.14,98.9 139.14,99.13 139.06,99.21 138.74,99.21 138.63,99.1 138.63,98.44 138.81,98.26 139.93,98.26 140.05,98.14 v1(140.05,97.83)
  IN2 w0.127: v1(142.37,68.02) 142.29,68.11 142.29,71.97 141.44,72.82 141.44,79.05 140.99,79.5 140.99,84.63 141.12,84.75 141.71,84.75 141.83,84.88 141.83,85.26 141.71,85.39 141.12,85.39 140.99,85.51 140.99,85.9 141.12,86.02 141.71,86.02 141.83,86.15 141.83,86.53 141.71,86.66 141.12,86.66 140.99,86.78 140.99,87.17 141.12,87.29 141.71,87.29 141.83,87.42 141.83,87.8 141.71,87.93 141.12,87.93 140.99,88.05 140.99,88.44 141.12,88.56 141.71,88.56 141.83,88.69 141.83,89.07 141.71,89.2 141.12,89.2 140.99,89.32 140.99,89.71 141.12,89.83 141.71,89.83 141.83,89.96 141.83,90.34 141.71,90.47 141.12,90.47 140.99,90.59 140.99,90.97 141.6,91.58 141.6,96.47 141.42,96.64
  BOTTOM w0.127: v2(142.37,68.73) v1(142.37,68.02)
M_A_DQ19: length 48.1
  TOP w0.102: v1(139.18,97.81) 139.18,97.87 XU1.AR37
  TOP w0.127: v1(142.62,62.35) DIMM2.62
  IN2 w0.102: 141.24,96.35 141.1,96.49 140.76,96.49 140.41,96.84 140.41,97.04 140.16,97.28 139.7,97.28 v1(139.18,97.81)
  IN2 w0.127: 141.24,96.35 141.37,96.21 141.37,91.86 140.61,91.1 140.61,79.34 141.06,78.89 141.06,72.66 141.91,71.81 141.91,68.81 141.76,68.65 141.76,60.59 142.23,60.12 142.23,59.06 142.39,58.89 142.75,58.89 142.89,59.03 142.89,60.45 142.62,60.72 v1(142.62,62.35)
  BOTTOM w0.127: v2(142.62,61.63) v1(142.62,62.35)
M_A_DQ20: length 47.4
  TOP w0.102: v1(143.01,99.53) 143.01,100.01 142.51,100.5 141.8,100.5 XU1.AN39
  TOP w0.127: v1(145.97,59.43) 146.62,60.08 DIMM2.46
  IN2 w0.127: v1(143.01,99.53) 143.22,99.32 143.5,99.32 144.63,98.19 144.63,92 146.33,90.3 146.33,80.79 146.76,80.36 146.76,76.13 146.18,75.54 146.18,70.86 146.31,70.73 146.31,68.55 146.26,68.5 146.26,68.49 145.97,68.2 v1(145.97,59.43)
  BOTTOM w0.127: v1(145.97,59.43) v2(145.46,59.93)
M_A_DQ21: length 49.2
  TOP w0.102: XU1.AN37 140.03,99.63 v1(140.09,99.63)
  TOP w0.127: v1(145.87,70.55) DIMM2.49
  IN2 w0.127: v1(140.09,99.63) 139.29,100.44 139.29,100.75 139.52,100.98 139.77,100.98 140.71,100.04 142.01,100.04 142.33,99.72 142.33,99.43 142.67,99.09 143.41,99.09 144.25,98.25 144.25,97.05 144.12,96.92 143.56,96.92 143.43,96.79 143.43,96.41 143.56,96.29 144.12,96.29 144.25,96.16 144.25,95.78 144.12,95.65 143.56,95.65 143.43,95.52 143.43,95.14 143.56,95.02 144.12,95.02 144.25,94.89 144.25,94.51 144.12,94.38 143.56,94.38 143.43,94.25 143.43,93.87 143.56,93.75 144.12,93.75 144.25,93.62 144.25,93.18 144.07,93 143.66,93 143.53,92.88 143.53,92.45 143.69,92.29 144.07,92.29 144.25,92.12 144.25,91.81 145.95,90.11 145.95,80.36 146.38,79.93 146.38,76.29 145.52,75.42 145.52,72.89 145.21,72.58 145.21,68.68 145.39,68.49 145.72,68.49 145.87,68.65 v1(145.87,70.55)
  BOTTOM w0.127: v2(145.87,69.84) v1(145.87,70.55)
M_A_DQ22: length 46
  TOP w0.102: v1(140.97,97.85) 140.98,97.85 XU1.AR39
  TOP w0.127: DIMM2.58 143.62,62.62 v1(143.64,62.63)
  IN2 w0.102: v1(140.97,97.85) 141.49,97.33 142,97.33
  IN2 w0.127: v1(143.64,62.63) 143.84,62.42 143.84,62.12 143.69,61.97 143.2,61.97 143.08,62.09 143.08,63.53 142.95,63.65 142.34,63.65 142.21,63.78 142.21,64.16 142.34,64.29 142.9,64.29 143.03,64.42 143.03,64.8 142.9,64.92 142.34,64.92 142.21,65.05 142.21,65.43 142.34,65.56 142.9,65.56 143.03,65.69 143.03,66.07 142.9,66.19 142.34,66.19 142.21,66.32 142.21,66.7 142.34,66.83 142.73,66.83 142.95,67.05 142.95,68.54 142.67,68.82 142.67,72.13 141.82,72.98 141.82,79.21 141.37,79.66 141.37,83.88 142.21,84.72 142.21,84.72 142.23,84.74 142.23,96.12 142.23,96.34 142.28,96.39 142.28,97.08 142.03,97.33 142,97.33
  BOTTOM w0.127: v2(144.42,62.63) v1(143.64,62.63)
M_A_DQ23: length 45
  TOP w0.102: v1(141.85,97.85) 141.9,97.85 XU1.AR40
  TOP w0.127: DIMM2.59 143.37,70.57 143.56,70.76 v1(143.59,70.76)
  IN2 w0.127: v1(141.85,97.85) 141.85,97.83 142.51,97.17 142.51,96.29 142.46,96.25 142.46,96.03 142.46,90.95 142.98,90.44 142.98,84.94 141.76,83.73 141.76,83.43 141.9,83.29 142.48,83.29 142.62,83.15 142.62,82.8 142.48,82.66 141.9,82.66 141.76,82.52 141.76,82.16 141.9,82.02 142.48,82.02 142.62,81.88 142.62,81.53 142.48,81.39 141.9,81.39 141.76,81.25 141.76,80.03 142.1,79.68 142.84,79.68 142.98,79.54 142.98,79.19 142.84,79.05 142.34,79.05 142.2,78.91 142.2,78.26 142.34,78.12 142.81,78.12 142.95,77.98 142.95,77.63 142.81,77.49 142.34,77.49 142.2,77.35 142.2,76.99 142.34,76.85 142.81,76.85 142.95,76.71 142.95,76.36 142.81,76.22 142.34,76.22 142.2,76.08 142.2,75.61 142.34,75.47 143.67,75.47 143.81,75.33 143.81,74.97 143.67,74.84 142.34,74.84 142.2,74.7 142.2,74.34 142.34,74.2 143.67,74.2 143.81,74.06 143.81,73.7 143.67,73.57 142.34,73.57 142.2,73.43 142.2,73.14 142.38,72.96 143.36,72.96 143.53,72.79 143.53,72.25 143.13,71.85 143.13,71.22 v1(143.59,70.76)
  BOTTOM w0.127: v2(143.59,70.05) v1(143.59,70.76)
M_A_DQ24: length 41.7
  TOP w0.102: XU1.AW37 139.66,94.51 v1(139.66,92.77)
  TOP w0.127: DIMM2.71 140.37,68.17 v1(140.59,67.96)
  IN2 w0.127: v1(139.66,92.77) 139.44,92.55 139.44,92.02 139.29,91.86 138.71,91.86 138.56,91.71 138.56,91.34 138.68,91.21 139.19,91.21 139.32,91.09 139.32,90.71 139.19,90.58 138.68,90.58 138.56,90.45 138.56,90.07 138.68,89.94 139.19,89.94 139.32,89.82 139.32,89.44 139.19,89.31 138.68,89.31 138.56,89.18 138.56,88.8 138.68,88.67 139.19,88.67 139.32,88.55 139.32,88.17 139.19,88.04 138.68,88.04 138.56,87.91 138.56,87.53 138.68,87.4 139.19,87.4 139.32,87.28 139.32,86.9 139.19,86.77 138.68,86.77 138.56,86.64 138.56,86.26 138.68,86.13 139.19,86.13 139.32,86.01 139.32,85.63 139.19,85.5 138.68,85.5 138.56,85.37 138.56,84.99 138.68,84.86 139.19,84.86 139.32,84.74 139.32,84.36 139.19,84.23 138.68,84.23 138.56,84.1 138.56,83.72 138.68,83.59 139.19,83.59 139.32,83.47 139.32,83.09 139.19,82.96 138.68,82.96 138.56,82.83 138.56,82.45 138.68,82.32 139.19,82.32 139.32,82.2 139.32,81.82 139.19,81.69 138.68,81.69 138.56,81.56 138.56,81.18 138.68,81.05 139.19,81.05 139.32,80.93 139.32,80.55 139.19,80.42 138.68,80.42 138.56,80.29 138.56,72.57 139.91,71.22 139.91,68.31 140.26,67.96 v1(140.59,67.96)
  BOTTOM w0.127: v2(139.83,67.96) v1(140.59,67.96)
M_A_DQ25: length 42.9
  TOP w0.102: XU1.AU38 v1(140.02,95.97)
  TOP w0.127: DIMM2.70 140.62,62.31 v1(140.59,62.35)
  IN2 w0.127: v1(140.02,95.97) 140.02,93.8 138.14,91.92 138.14,72.45 139.53,71.07 139.53,67.98 139.7,67.81 139.7,67.07 139.53,66.89 139.53,65.85 139.65,65.73 140.69,65.73 140.82,65.6 140.82,65.22 140.69,65.09 139.65,65.09 139.53,64.96 139.53,64.58 139.65,64.46 140.69,64.46 140.82,64.33 140.82,63.95 140.69,63.82 139.67,63.82 139.53,63.67 139.53,63.22 140.1,62.64 140.3,62.64 v1(140.59,62.35)
  BOTTOM w0.127: v2(140.59,61.64) v1(140.59,62.35)
