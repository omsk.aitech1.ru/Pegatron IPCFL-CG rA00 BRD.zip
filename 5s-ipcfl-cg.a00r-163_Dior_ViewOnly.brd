# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Nets (continued)
M_B_DQS0#: DIMM1.11(DQS0_C) XU1.AF34(DDR1_DQSN[0]/DDR0_DQSN[2])
M_B_DQS1: DIMM1.34(DQS1_T) XU1.AL33(DDR1_DQSP[1]/DDR0_DQSP[3])
M_B_DQS1#: DIMM1.32(DQS1_C) XU1.AK33(DDR1_DQSN[1]/DDR0_DQSN[3])
M_B_DQS2: DIMM1.55(DQS2_T) XU1.AP33(DDR1_DQSP[2]/DDR0_DQSP[6])
M_B_DQS2#: DIMM1.53(DQS2_C) XU1.AN33(DDR1_DQSN[2]/DDR0_DQSN[6])
M_B_DQS3: DIMM1.76(DQS3_T) XU1.AN28(DDR1_DQSP[3]/DDR0_DQSP[7])
M_B_DQS3#: DIMM1.74(DQS3_C) XU1.AN29(DDR1_DQSN[3]/DDR0_DQSN[7])
M_B_DQS4: DIMM1.179(DQS4_T) XU1.AN12(DDR1_DQSP[4]/DDR1_DQSP[2])
M_B_DQS4#: DIMM1.177(DQS4_C) XU1.AN13(DDR1_DQSN[4]/DDR1_DQSN[2])
M_B_DQS5: DIMM1.200(DQS5_T) XU1.AP8(DDR1_DQSP[5]/DDR1_DQSP[3])
M_B_DQS5#: DIMM1.198(DQS5_C) XU1.AR8(DDR1_DQSN[5]/DDR1_DQSN[3])
M_B_DQS6: DIMM1.221(DQS6_T) XU1.AL8(DDR1_DQSP[6])
M_B_DQS6#: DIMM1.219(DQS6_C) XU1.AM8(DDR1_DQSN[6])
M_B_DQS7: DIMM1.242(DQS7_T) XU1.AG7(DDR1_DQSP[7])
M_B_DQS7#: DIMM1.240(DQS7_C) XU1.AG6(DDR1_DQSN[7])
M_B_ODT0: DIMM1.155(ODT0) XU1.AM16(DDR1_ODT[0])
M_B_ODT1: DIMM1.161(ODT1) XU1.AL16(DDR1_ODT[1])
M_B_PAR: DIMM1.143(PARITY) XU1.AL20(DDR1_PAR)
MB_REG_PG: O2Q2.6 O2Q3.6 OR134.1 U104.109((MB_REG_PG)GP057)
MCT0: LU3.15(MCT4) R22.1
MCT1: LU3.18(MCT3) R21.1
MCT2: LU3.21(MCT2) R20.1
MCT3: LU3.24(MCT1) R19.1
ME_CNTL: SR135.1 SR673.2 U1.BF32(GPP_B3/CPU_GP2)
ME_DISABLE#_R: Q1.1(BASE) SR135.2
MEM_REG_PG: O2Q3.3 OR136.1 U104.111((MEM_REG_PG)GP061)
MIC2-VREFO: R36.2 R37.2 U6.29(MIC2-VREFO)
MIC_CAP: AC85.1 U6.19(MIC_CAP)
MQ28_1: MQ27.3(DRAIN) MQ28.1(GATE) SR7994.1
MS_CLK: J68.14 OR70.1 U104.115(MCLK)
MS_DATA: J68.16 OR71.1 U104.116(MDAT)
O2Q2_PIN2: O2Q2.2 RO1.2 RO2.1
O2Q2_PIN5: O2Q2.5 O2R12.2
O2Q4_C1: AC6.1 M1R16.2 O2Q4.5 O2Q4.6
O2Q5_PIN3: ECR160.1 O2Q5.3
O2Q5_PIN56: AC209.1 O2Q5.5 O2Q5.6 R99535.2
O_TR_CPU+: O2C6.1 O2C7.1 O2C8.1 SSD_Q1.2(BASE) SSD_Q1.3(COLLECTOR) SSD_Q2.1(BASE) SSD_Q2.3(COLLECTOR) U104.41(REMOTE1+)
O_TR_CPU-: O2C6.2 O2C7.2 O2C8.2 SSD_Q1.1(EMITTER) SSD_Q2.2(EMITTER) U104.42(REMOTE1-)
O_TR_MB+: AMB_Q1.2(BASE) AMB_Q1.3(COLLECTOR) O2C1.1 O2C2.1 U104.43(REMOTE2A+/REMOTE2B-)
O_TR_MB-: AMB_Q1.1(EMITTER) O2C1.2 O2C2.2 U104.44(REMOTE2A-/REMOTE2B+)
OC0#_R: SR7858.2 XDP3.10(OBSDATA_C0)
OC1#_R: SR750.2 XDP3.12(OBSDATA_C1)
OC2#_R: SR751.2 XDP3.16(OBSDATA_C2)
OC3#_R: SR752.2 XDP3.18(OBSDATA_C3)
P216_2: JMP1.2 R79.1
P217_R: JMP1.5 SR123.1
PC_SPKR_DET: P6.3 SR7979.2
PC_SPKR_DET_R: SR7941.2 SR7979.1 U1.BF21(GPP_C18/I2C1_SDA)
PC_SPKR_DET_SIO: OR118.1 OR153.2 U104.54((PC_SPKR_DET)GP031)
PCBEEP_U6: AC205.2 U6.12(PCBEEP)
PCH_AUD_MUTE: AR36.1 SR280.2 U1.AF47(GPP_H13/SML3CLK)
PCH_C1: ST16.1 U1.BC1(RSVD_3)
PCH_CHAR_CTL3: SR7956.2 U1.N48(GPP_K4)
PCH_CLK_TO_LPC: SR24.2 U1.BB34(GPP_A10/CLKOUT_LPC1)
PCH_CPUPWRGD: SC86.1 SR275.1 U1.AE3(CPUPWRGD)
PCH_D1: ST17.1 U1.AH14(RSVD_1)
PCH_DSW_PWROK: SC83.1 SR286.2 SR289.1 U1.AW41(DSW_PWROK)
PCH_F_CHAR_CTL2: SR237.2 U1.AE47(GPP_H0/SRCCLKREQ6#)
PCH_GPIO26_R_C: Q1.2(EMITTER) SR134.2
PCH_HEATSINK_DET: HEATSINK.3 HEATSINK.4 JP2802.1 JP2802.2 SR7988.1
PCH_HEATSINK_DET_R: SR406.2 SR7988.2 U1.AN37(GPP_F8/SATA_DEVSLP6)
PCH_JTAG_TCK: HR370.2 SR151.1 U1.AJ3(PCH_JTAG_TCK) XDP3.55(TCK1)
PCH_JTAG_TDI: HR372.2 SR173.2 SR765.2 SR775.1 U1.AH2(PCH_JTAG_TDI)
PCH_JTAG_TDI_R: SR775.2 XDP3.56(TDI)
PCH_JTAG_TDO: SR158.2 SR764.2 SR766.2 SR768.1 U1.AH3(PCH_JTAG_TDO)
PCH_JTAG_TDO_R: SR767.2 SR768.2 XDP3.52(TDO)
PCH_JTAG_TMS: HR384.2 SR153.2 SR769.2 SR776.1 U1.AJ4(PCH_JTAG_TMS)
PCH_JTAG_TMS_R: SR776.2 XDP3.58(TMS)
PCH_JTAGX: HR371.2 SR763.2 U1.AH4(PCH_JTAGX)
PCH_M2_SSD_CLKREQ_N: APR112.1 SR912.2 SR7897.2 U1.BB30(GPP_B8/SRCCLKREQ3#)
PCH_PME_N: SR111.2 U1.BE36(GPP_A11/PME#/SD_VDD2_PWR_EN#)
PCH_PWROK: C941649.1 O2Q3.1 Q9535.3(DRAIN) R6.1 R70299.2 SC28.1 SR288.1 SR823.2 U1.AY42(PCH_PWROK)
PCH_PWROK_DISCH_A: Q8.3(DRAIN) R6.2
PCH_SATA_LED_N: Q9436.1(GATE) R70292.1 SR625.1 U1.AK48(GPP_E8/SATALED#)
PCH_SIO_DPWROK: SR286.1 U104.28(DPWROK/GP013)
PCH_SLP_A_N: APR7.2 ECR149.1 SR215.1 U1.BE40(GPD6/SLP_A#)
PCH_SPI_CS1#: ST33.1 U1.AW48(SPI0_CS1#)
PCH_SPI_CS2#: SR7785.2 U1.AT40(SPI0_CS2#)
PCH_SPKR_C: AC84.2 SR7813.2
PCH_SPKR_C_R: AC204.2 AC205.1 SR7813.1 SR7814.2 SR7884.1
PCH_TGR_L900MIL: R2420.1 U1.AK3(TRIGGER_OUT)
PCH_THMTRIP#_R: SC24.1 SR266.1 U1.AD3(THRMTRIP#)
PCH_WAKE#: SR255.2 SR262.1 U1.BB47(WAKE#)
PCH_XDP_PRDY#: HR410.2 XDP3.5(OBSFN_A1)
PCH_XDP_PRDY#_R: HR369.1 HR410.1 U1.AM5(PRDY#)
PCH_XDP_PREQ#: HR373.2 XDP3.3(OBSFN_A0)
PCH_XDP_PREQ#_R: HR368.1 HR373.1 U1.AL2(PREQ#)
PCH_XDP_PRSNT_R: SR760.1 SR778.1 XDP3.60(GND18)
PCIAUX_CTRL_N: OR119.1 U104.91(NC9)
PCIAUX_GATE: OR109.1 U1.AN40(GPP_F23/DDPF_CTRLDATA) U104.92(GP125)
PCIAUX_GATE1: D522.1(ANODE1) SR407.2 U1.AP47(GPP_F9/SATA_DEVSLP7)
PCIE_RCOMPN_W15S15MIL: SR316.1 U1.B12(PCIE_RCOMPN)
PCIE_RCOMPP_W15S15MIL: SR316.2 U1.A13(PCIE_RCOMPP)
PCIE_RXN5_LAN: C4019.1 U1.F20(PCIE5_RXN)
PCIE_RXN5_LAN_C: C4019.2 U114.18(HSON)
PCIE_RXN8_WLAN: J218.43(PERN0) U1.F24(PCIE8_RXN)
PCIE_RXN9_M.2_SSD: TC19.2 U1.G36(PCIE9_RXN)
PCIE_RXN9_M.2_SSD_C: J219.5 TC19.1
PCIE_RXN10_M.2_SSD: TC15.2 U1.K37(PCIE10_RXN)
PCIE_RXN10_M.2_SSD_C: J219.17 TC15.1
PCIE_RXN11_M.2_SSD: TC17.2 U1.G38(PCIE11_RXN/SATA0A_RXN)
PCIE_RXN11_M.2_SSD_C: J219.29 TC17.1
PCIE_RXN12_M.2_SSD: TC13.2 U1.H42(PCIE12_RXN/SATA1A_RXN)
PCIE_RXN12_M.2_SSD_C: J219.43 TC13.1
PCIE_RXP5_LAN: C4018.1 U1.G20(PCIE5_RXP)
PCIE_RXP5_LAN_C: C4018.2 U114.17(HSOP)
PCIE_RXP8_WLAN: J218.41(PERP0) U1.G24(PCIE8_RXP)
PCIE_RXP9_M.2_SSD: TC20.2 U1.F36(PCIE9_RXP)
PCIE_RXP9_M.2_SSD_C: J219.7 TC20.1
PCIE_RXP10_M.2_SSD: TC16.2 U1.J37(PCIE10_RXP)
PCIE_RXP10_M.2_SSD_C: J219.19 TC16.1
PCIE_RXP11_M.2_SSD: TC18.2 U1.F39(PCIE11_RXP/SATA0A_RXP)
PCIE_RXP11_M.2_SSD_C: J219.31 TC18.1
PCIE_RXP12_M.2_SSD: TC14.2 U1.J41(PCIE12_RXP/SATA_1A_RXP)
PCIE_RXP12_M.2_SSD_C: J219.41 TC14.1
PCIE_TXN5_LAN: C4021.1 U1.B21(PCIE5_TXN)
PCIE_TXN5_LAN_C: C4021.2 U114.14(HSIN)
PCIE_TXN8_WLAN: M1C70.1 U1.B24(PCIE8_TXN)
PCIE_TXN9_M.2_SSD: TC1.1 U1.C34(PCIE9_TXN)
PCIE_TXN9_M.2_SSD_C: J219.11 TC1.2
PCIE_TXN10_M.2_SSD: TC5.1 U1.C35(PCIE10_TXN)
PCIE_TXN10_M.2_SSD_C: J219.23 TC5.2
PCIE_TXN11_M.2_SSD: TC3.1 U1.B36(PCIE11_TXN/SATA0A_TXN)
PCIE_TXN11_M.2_SSD_C: J219.35 TC3.2
PCIE_TXN12_M.2_SSD: TC7.1 U1.D38(PCIE12_TXN/SATA1A_TXN)
PCIE_TXN12_M.2_SSD_C: J219.47 TC7.2
PCIE_TXP5_LAN: C4020.1 U1.A22(PCIE5_TXP)
PCIE_TXP5_LAN_C: C4020.2 U114.13(HSIP)
PCIE_TXP8_WLAN: M1C69.1 U1.C24(PCIE8_TXP)
PCIE_TXP9_M.2_SSD: TC2.1 U1.D34(PCIE9_TXP)
PCIE_TXP9_M.2_SSD_C: J219.13 TC2.2
PCIE_TXP10_M.2_SSD: TC6.1 U1.B35(PCIE10_TXP)
PCIE_TXP10_M.2_SSD_C: J219.25 TC6.2
PCIE_TXP11_M.2_SSD: TC4.1 U1.C36(PCIE11_TXP/SATA0A_TXP)
PCIE_TXP11_M.2_SSD_C: J219.37 TC4.2
PCIE_TXP12_M.2_SSD: TC8.1 U1.E37(PCIE12_TXP/SATA1A_TXP)
PCIE_TXP12_M.2_SSD_C: J219.49 TC8.2
PCIRST1#: APR123.1 APR126.1 OR154.1 PQ93028.1(GATE) U104.51(PCI_RST_1#/GP026)
PCIRST2#: OR150.2 U104.52(PCI_RST_2#/GP027)
PD_INT: SR226.2 U1.AU26(GPP_B20/GSPI1_CLK)
PDB: AR36.2 AR38.2 R113.1 U6.47(PDB)
PECI_PCH: HR32.1 SC12.1 SR93.1 U1.AF2(PECI)
PECI_READY: OR3.2 U104.31(PECI_READY/LVSMB_DAT1)
PECI_SIO: HR32.2 O2R1.1 XU1.G7(PECI)
PEDET: APR19.2 ECR141.2 PQ45.3(DRAIN) SR7917.2
PEDET_R: APR19.1 J219.69 PQ45.1(GATE) SR7802.2
PEG_RCOMP_W5S15L600MIL: HR9.2 XU1.L7(PEG_RCOMP)
PIRQA_N: R7219.2 SR7955.2 U1.T45(GPP_K21)
PIRQA_N_R: R7219.1 U7201.18(SPI_IRQ#/GPIO2)
PJP89001: PJP89001.1 PR89020.1
PJP89002: PJP89002.1 PR89032.1
PJP89003: PJP89003.1 PR89048.1
PJP89004: PJP89004.1 PR89056.1
PLT_RST#: APR124.1 APR125.1 C4024.1 Q7201.3(DRAIN) R206.1 R7203.2 SCB119.2 SR271.1 U104.14(LRESET#) U114.19(PERSTB)
PLT_RST_J68_N: J68.23 R206.2
PLTRST_CPU#: HC3.1 HR343.1 U1.AG5(PLTRST_CPU#) XU1.E7(RESET#)
PLTRST_N: SR219.1 SR271.2 U1.AV29(GPP_B13/PLTRST#)
PM_DOWN: HR34.1 SR552.1 U1.AE2(PM_DOWN)
PM_DOWN_L200MIL: HR34.2 XU1.D8(PM_DOWN)
PM_SYNC: SR87.2 XU1.E8(PM_SYNC)
PM_SYNC_R: SR87.1 U1.AF3(PM_SYNC)
POWER_SHARE: SR112.2 U1.AA45(GPP_K15/GSXSRESET#)
PQ1_G: PC1.2 PQ1.4(GATE) PR9.2 PR10.1
PQ21_D: PC107.1 PQ21.1 PR7401.2
PQ21_G: PC108.1 PQ21.3 PR111.2 PR113.1
PQ22_B: PQ22.2(BASE1) PR114.2 PR115.2 PR123.2
PQ22_C: PQ22.4(COLLECTOR2) PR111.1
PQ22_E: PQ22.3(EMITTER2) PR112.2
PQ24_G: PQ24.1(GATE) PQ25.3(DRAIN) PR132.2
PQ101_1: PQ101.1(BASE) SR698.2
PQ102_1: PQ101.3(COLLECTOR) PQ102.1(BASE) SR699.1 SR702.2
PQ6301_G: PD8.3(CATHODE) PQ6301.1(GATE) PR93062.1
PQ93010_D: PQ93010.3(DRAIN) PR93052.1
PQ93012_D: PQ93012.3(DRAIN) PR93055.1
PRIM_XDP_JTAG_TCK_R: HR370.1 XDP1.55(TCK1)
PROC_AUDIO_CLK: AC70.1 SR137.1 XU1.V3(PROC_AUDIO_CLK)
PROC_AUDIO_SDI: SR136.1 XU1.V2(PROC_AUDIO_SDI)
PROC_AUDIO_SDO: HR35.1 U1.AN3(HDACPU_SDI)
PROC_AUDIO_SDO_L200MIL: HR35.2 XU1.U1(PROC_AUDIO_SDO)
PROC_SEL#_R: HR12.2 XU1.AB36(PROC_SELECT#)
PROCHOT#: MQ28.2(SOURCE) PQ6301.3(DRAIN) PR89066.2 PR93063.2 SR7995.2
PROCHOT#_R: HC30.1 HR33.2 XU1.C39(PROCHOT#)
PS_ON_N: OR151.2 PQ93030.1(GATE) PQ93031.1(GATE) SR7890.1 U104.53(PS_ON#/GP030)
PU10_SS1: PC941580.1 PU10.12(SS1)
PU10_SS2: PC941579.1 PU10.10(SS2)
PU10_VIN1: PC76.1 PC941667.1 PR7001.2 PR93157.2 PU10.1(VIN1_1) PU10.2(VIN1_2)
PU10_VIN2: PC79.1 PR7002.2 PR93158.2 PU10.6(VIN2_1) PU10.7(VIN2_2)
PU30_OUT: PR6301.1 PU30.6(OUT)
PU30_OUT_R: PR6301.2 PR93038.1 PR93039.1 PR93060.1
PU30_V+: PC941496.1 PR6399.2 PU30.3(V+)
PU8401_SS1: PC941609.1 PU8401.12(SS1)
PU8401_SS2: PC941604.1 PU8401.10(SS2)
PU8401_VIN1: PC941610.1 PR8401.2 PR8402.2 PU8401.1(VIN1_1) PU8401.2(VIN1_2)
PU8401_VIN2: PC941602.1 PC941671.1 PR8403.2 PR8406.2 PU8401.6(VIN2_1) PU8401.7(VIN2_2)
PU8402_SS1: PC941619.1 PU8402.12(SS1)
PU8402_SS2: PC941613.1 PU8402.10(SS2)
PU8402_VIN1: PC941618.1 PR8404.2 PR8410.2 PR93160.2 PR93161.2 PU8402.1(VIN1_1) PU8402.2(VIN1_2)
PU8402_VIN2: PC941611.1 PR8405.2 PU8402.6(VIN2_1) PU8402.7(VIN2_2)
PU_PCH_CPU_GP1: SR346.2 SR624.1 U1.AM45(GPP_E7/CPU_GP1)
PULSAR_38D4M_REFCLK: R3112.1 U1.R6(CLKIN_XTAL)
PULSAR_38D4M_REFCLK_R: J218.64(RESERVED_64) R3110.1 R3112.2
PW_CLEAR: JMP1.3 SR73.2 SR85.1 U1.V48(GPP_K10)
PWM1_SN_D: PC90009.1 PR90006.2
PWM2_SN_D: PC90020.1 PR90014.2
PWM3_SN_D: PC941623.1 PR93066.2
PWR2_PRSNT: OR37.1 U104.108((PWR2_PRSNT)GP056)
PWR_LED+: D5502.2(CATHODE) Q16.3(DRAIN) R55.2 SW10.L2
PWR_LED-: D5501.2(CATHODE) Q17.3(DRAIN) R59.2 SW10.L1
PWRBTN#_APS: APR10.2 P466.11
PWRBTN_J68_N: J68.21 R205.2
PWRBTN_N: APR10.1 HCB4.1 HR96.2 O2CB15.1 R205.1 R207.2 SC23.1 SR256.2 U1.BE46(GPD3/PWRBTN#) U104.34(PWRBTN#/GP015) XDP3.41(HOOK1)
PWRBTN_R_N: D5503.2(CATHODE) R207.1 SW10.B
PWROK3_1: HR98.2 SR274.1 U104.57(PWR_GOOD_3V/GP033)
Q2Q5_PWRGOD_PS: AC208.1 ECR159.1 O2CB21.1 O2Q5.2 PQ93030.3(DRAIN) R99536.2
Q7201_G: C7208.2 Q7201.1(GATE) R7202.2
Q9434_PIN3: Q9434.3(DRAIN) Q9435.1(GATE) R70291.1
Q9436_PIN3: Q9436.3(DRAIN) Q9437.1(GATE) R70293.1
Q9534_3: C941648.1 Q9534.3(DRAIN) R6502.2 R70300.2 R99528.1 R99529.1
Q93033_PIN2: C941625.1 Q93033.2(BASE1) R93102.2
Q93033_PIN3: Q93033.3(EMITTER2) R93098.2
Q93033_PIN4: Q93033.4(COLLECTOR2) R93101.1
Q93034_P3: Q93034.3 Q93035.3(COLLECTOR) R93106.2 R93107.2 R93108.1
Q93034_P12567: L93006.2 Q93034.1 R93103.1 R93104.1
Q93034_PIN8_4: Q93034.4 Q93034.7 R93103.2 R93109.1
Q93035_PIN1: Q93035.1(BASE) R93104.2 R93105.2
R_HPOUT_L: AR22.2 C4306.1 D4307.2(CATHODE) J301.1
R_HPOUT_R: AR23.2 C4305.1 D4306.2(CATHODE) J301.2
R_SPI_CK: E61.16 F3R11.2 J303.6 U9434.6(SCLK) U9435.16(CLK)
R_SPI_CS0#_E56: E61.7 F3R7.2 J303.1 U9434.1(CS#) U9435.7(CS#)
R_SPI_IO0: E61.15 F3R10.2 J303.8 U9434.5(SI/SIO0) U9435.15(DI/IO0)
R_SPI_IO1: E61.8 F3R8.2 J303.3 U9434.2(SO/SIO1) U9435.8(DO/IO1)
R_SPI_IO2_R: E61.9 F3R9.2 J303.5 U9434.3(WP#/SIO2) U9435.9(WP#/IO2)
R_SPI_IO3_R: E61.1 F3R12.2 J303.4 U9434.7(RESET#/SIO3) U9435.1(HOLD#/IO3)
REGOUT: L4000.1 U114.24(REGOUT)
RING2: C4310.1 L22.1 R37.1 U6.17(MIC2-L(PORT-F-L)/RING)
RING2_B: C4304.1 D4305.2(CATHODE) J301.3 L22.2
RSM_RST#: HR374.1 SC27.1 SR162.2 SR290.1 U1.BA47(RSMRST#) U104.58(RSMRST#)
RSM_RST#_R: SR162.1 XDP3.39(HOOK0)
RTCRST#: APR8.1 C97.1 JMP1.1 R71.2 U1.BE47(RTCRST#)
RTCRST#_APS: APR8.2 P466.9
RTCX_32.768K_IN: F3R29.1 SC29.1 SR320.2 U1.BA49(RTCX1)
RTCX_32.768K_IN_R: F3R29.2 Y5.1
RTCX_32.768K_OUT: SC30.1 SR320.1 U1.BA48(RTCX2) Y5.4
S_FLASH_OVERRIDE#: JMP1.6 Q1.3(COLLECTOR) SR7812.2
SA_VDQ_RC: HC2.2 HR8.1
SATA_DETECT_GPIO: P110.P12(HOST_PLUG_GROUND) SR39.2 U1.AU46(GPP_F12/SATA_SDATAOUT1)
SATA_RXN0_C: P110.S5(SATA_RX-) TC12.2
SATA_RXN0_HDD: TC12.1 U1.C45(PCIE13_RXN/SATA0B_RXN)
SATA_RXP0_C: P110.S6(SATA_RX+) TC11.2
SATA_RXP0_HDD: TC11.1 U1.C46(PCIE13_RXP/SATA0B_RXP)
SATA_TXN0_C: P110.S3(SATA_TX-) TC9.2
SATA_TXN0_HDD: TC9.1 U1.B38(PCIE13_TXN/SATA0B_TXN)
SATA_TXP0_C: P110.S2(SATA_TX+) TC10.2
SATA_TXP0_HDD: TC10.1 U1.C38(PCIE13_TXP/SATA0B_TXP)
SD3_GPPJ__RCOMP: SR7914.1 U1.BD1(GPPJ_RCOMP_1P8_1) U1.BE1(GPPJ_RCOMP_1P8_2) U1.BE2(GPPJ_RCOMP_1P8_3) U1.BE4(SD_RCOMP_3P3) U1.BE5(SD_RCOMP_1P8)
SD_CARD_DET: SR108.2 SR115.1 U1.Y46(GPP_K12/GSXDOUT)
SER_IRQ_LT: ECR67.1 SR34.2 U1.AW35(GPP_A6/SERIRQ/ESPI_CS1#)
SER_SENSE: SR105.2 U1.L48(GPP_K22/IMGCLKOUT0)
SERIAL_DETECT: J68.24 SR7989.2
SERIAL_DETECT_R: SR7943.2 SR7989.1 U1.BD21(GPP_C15/UART1_CTS#/ISH_UART1_CT)
SERIRQ_SIO: ECR67.2 U104.127(SER_IRQ)
SIO_GP053: OR132.1 U104.105(NC10)
SIO_GP055: OR133.1 U104.107(NC11)
SIO_GP060: OR135.1 U104.110(NC12)
SIO_GP062: OR137.1 U104.112(NC13)
SIO_GP104: ECR131.1 OR120.1 U104.86(VSS9)
SIO_GP106: ECR132.1 OR122.1 U104.88(VSS10)
SIO_GP107: ECR141.1 OR123.1 U104.89(GP107)
SIO_GP116: OR112.1 U104.95(BACKFEED_CUT#/GP116)
SIO_GREEN: Q17.1(GATE) R60.2 U104.2(GP000/PWM4) U104.24(GREEN#/GP007)
SIO_O2Q3_PIN2: O2Q3.2 O2R15.2
SIO_O2Q3_PIN5: O2Q3.5 O2R13.1 O2R14.1
SIO_PECI_R: O2R1.2 SC52.2 U104.30(PECI/LVSMB_CLK1)
SIO_PECI_REQ_N: SR110.2 SR121.1 U1.BF36(GPP_A12/BM_BUSY#/ISH_GP6/SX_EXI) U104.20((H_CPURST#)GP005/PECI_REQUEST#)
SIO_PIN82: ECR129.1 U104.82(VSS7)
SIO_PIN83: ECR130.1 U104.83(VSS8)
SIO_PROCHOT_R_N: ECR104.1 U104.36(PROCHOT_IN#/PROCHOT_OUT#/GP016)
SIO_PWRGOD_PS: ECR159.2 ECR160.2 SR7794.1 U104.123(PWRGD_PS)
SIO_SMBCLK1: OR141.2 U104.70(GP036/SMB_CLK1)
SIO_SMBDAT1: OR142.2 U104.72(GP040/SMB_DAT1)
SIO_SPKR: AC206.1 O2R9.1 U104.125(SPEAKER[DIAG_EN#]/GP070)
SIO_SPKR_C: AC206.2 SR7884.2
SIO_SUS3_ON: PC67.1 PQ9823.3(DRAIN) PR66.2 PR70.1
SIO_TRST#: OR34.2 U104.124(TRST#)
SIO_YELLOW: Q16.1(GATE) R56.2 U104.23(YELLOW#/GP006)
SKL_PCUSTB_DN0: HR83.1 XDP1.6(OBSFN_C1) XU1.E14(CFG[16])
SKL_PCUSTB_DN1: HR84.1 XDP1.24(OBSFN_D1) XU1.G18(CFG[18])
SKL_PCUSTB_DP0: HR85.1 XDP1.4(OBSFN_C0) XU1.F14(CFG[17])
SKL_PCUSTB_DP1: HR82.1 XDP1.22(OBSFN_D0) XU1.F18(CFG[19])
SLEEVE: AQ2.3(DRAIN) C4309.1 L21.1 R36.1 U6.18(MIC2-R(PORT-F-R)/SLEEVE)
SLEEVE_B: C4303.1 D4304.2(CATHODE) J301.4 L21.2
SLP_A#_APS: APR7.1 P466.6
SLP_LAN#: ECR157.1 SR216.1 U1.BF40(SLP_LAN#)
SLP_S0_N: F3R70.2 U1.BC28(GPP_B12/SLP_S0#)
SLP_S3#_APS: APR5.1 P466.2
SLP_S3_LED_B: Q9344.1(BASE) R8828.1
SLP_S3_LED_C: Q9344.3(COLLECTOR) R4814.2
SLP_S3_LED_E: CR22.1(ANODE) Q9344.2(EMITTER)
SLP_S3_N: APR5.2 C81.1 D522.2(ANODE2) PR115.1 PR129.1 PR93156.1 PU76.3(SHUTDOWN#) R8828.2 SR212.1 SR8001.1 U1.BF42(GPD4/SLP_S3#) U104.121(SLP_S3#)
SLP_S3_N_PU7: PC7899.1 PR93156.2 PR93170.2 PU7.3(SHUTDOWN#)
SLP_S4#_APS: APR6.2 P466.5
SLP_S4_N: APR6.1 APR130.2 C82.1 ECR148.1 PR114.1 PR118.1 R8829.2 SR116.2 SR213.1 SR7889.1 U1.BE42(GPD5/SLP_S4#) U104.69(SLP_S4#) UU19.4(EN/EN#) UU64.4(EN/EN#) UU65.4(EN/EN#) UU66.4(EN/EN#)
SLP_S4_N_LED_B: Q9345.1(BASE) R8829.1
SLP_S4_N_LED_C: Q9345.3(COLLECTOR) R4815.2
SLP_S4_N_LED_E: CR5.1(ANODE) Q9345.2(EMITTER)
SLP_S4_SIO: ECR148.2 U104.122(SLP_S5#/GP066)
SLP_S5_N: APR127.2 SR214.1 U1.BC42(GPD10/SLP_S5#)
SLP_SUS#: C941635.1 PR64.1 PR7607.1 PU10.3(EN1) Q9308.1(GATE) SCB75.1 SR217.1 U1.BD39(SLP_SUS#) U104.71(SLP_SUS#)
SLP_SUS_LED: CR1.2(CATHODE) R4820.1
SLP_SUS_LED_D: Q9308.3(DRAIN) R4820.2
SLP_WLAN_N: D524.1(CATHODE1) SR218.1 SR7857.2 U1.BD42(GPD9/SLP_WLAN#)
SMB_CLK: APR132.1 APR142.1 ECR137.2 SC17.1 SR160.2 U1.BE26(GPP_C0/SMBCLK)
SMB_CLK_R_SSD: APR142.2 J219.40
SMB_CLK_R_WLAN: APR132.2 J218.60(I2C_CLK) SR7885.2
SMB_CLK_S0: DIMM1.253(SCL) DIMM2.253(SCL) ECR138.2 J69.26 R70280.2 XDP1.53(SCL) XDP3.53(SCL)
SMB_CLK_S0_SIO: ECR138.1 U104.81(SCLK/GP123)
SMB_CLK_SIO: ECR137.1 U104.80(SCLK_1/GP122)
SMB_DATA: APR133.1 APR143.1 ECR136.2 SC18.1 SR161.2 U1.BF26(GPP_C1/SMBDATA)
SMB_DATA_R_SSD: APR143.2 J219.42
SMB_DATA_R_WLAN: APR133.2 J218.58(I2C_DATA) SR7886.2
SMB_DATA_S0: DIMM1.254(SDA) DIMM2.254(SDA) ECR139.2 J69.20 R70279.2 XDP1.51(SDA) XDP3.51(SDA)
SMB_DATA_S0_SIO: ECR139.1 U104.79(SDAT/GP121)
SMB_DATA_SIO: ECR136.1 U104.78(SDAT_1/GP120)
SMBALERT_N: APR144.1 R3139.1 SR171.2 SR185.1 U1.BE25(GPP_C2/SMBALERT#)
SMBALERT_N_R_SSD: APR144.2 J219.44
SMBALERT_N_R_WLAN: J218.62(ALERT) R3139.2
SML0_CLK: SC19.1 SR163.2 U1.BF25(GPP_C3/SML0CLK)
SML0_DATA: SC20.1 SR164.2 U1.BE24(GPP_C4/SML0DATA)
SML0ALERT#: SR170.2 SR184.1 U1.BF24(GPP_C5/SML0ALERT#)
SMLI_CLK: ECR145.1 SC21.1 SR168.2 U1.BF27(GPP_C6/SML1CLK)
SMLI_CLK_R: ECR145.2 U104.26(SMBCLK2/GP011)
SMLI_DATA: ECR144.1 SC22.1 SR169.2 U1.BE27(GPP_C7/SML1DATA)
SMLI_DATA_R: ECR144.2 U104.25(SMBDAT2/GP010)
SP_CTS_N: J68.10 OR77.1 U104.101(CTS1#/GP050)
SP_DCD_N: J68.3 OR72.1 U104.96(DCD1#/GP043)
SP_DSR_N: J68.8 OR73.1 U104.97(DSR1#/GP044)
SP_DTR_N: J68.6 OR78.1 U104.102(DTR1#/GP051)
SP_RI_N: J68.11 OR79.1 U104.103(RI1#/GP052)
SP_RTS_N: J68.9 OR75.1 U104.99(RTS1#/GP046)
SP_RXD_N: J68.4 OR74.1 U104.98(RXD1/GP045)
SP_TXD_SIO: O2Q2.3 R69867.1 U104.100((5V_PRSNT)GP047/TXD1)
SP_TXD_SIO_CON: J68.5 OR76.1 R69867.2
SPI_CLK: F3R11.1 F3R25.1 R7206.2 R99512.2 SR29.1 SR222.1
SPI_CLK_L500MIL: SR29.2 U1.AW47(SPI0_CLK)
SPI_CS0#: F3R6.1 F3R27.1 U1.AY47(SPI0_CS0#)
SPI_IO2: F3R1.1 F3R9.1 F3R22.2 F3R26.1 SR7787.1
SPI_IO2_L500MIL: SR7787.2 U1.AY48(SPI0_IO2)
SPI_IO3: F3R2.1 F3R12.1 F3R21.1 SR30.1
SPI_IO3_L500MIL: SR30.2 U1.BA46(SPI0_IO3)
SPI_MISO: F3R8.1 F3R20.1 R7204.2 R7211.2 SR28.1
SPI_MISO_L500MIL: SR28.2 U1.BA45(SPI0_MISO)
SPI_MISO_PCH_XDP: SR166.1 XDP3.47(HOOK3)
SPI_MOS_CS0#: E16.2 F3R6.2 F3R7.1
SPI_MOSI: F3R10.1 F3R23.2 F3R24.1 F3R71.2 R7205.2 R99514.2 SR27.1
SPI_MOSI_L500MIL: SR27.2 U1.AU41(SPI0_MOSI)
SPK_L+: AR31.2 U6.42(SPK-OUT-L+)
SPK_L+_R: PC941584.2 R204.2
SPK_L-: AR30.2 U6.43(SPK-OUT-L-)
SPK_L-_R: PC941585.2 R203.2
SPKR: AC84.1 M1R15.2 SR258.2 SR916.2 U1.AW29(GPP_B14/SPKR)
SRTCRST#: C98.1 R80.2 U1.BD46(SRTCRST#)
SSD_3V_EN: D522.3(CATHODE) D4309.3(CATHODE) PR93155.2 SR79.1 SR7876.1 SR8001.2
SSD_CLKREQ#_R: APR112.2 J219.52
SSD_HDD#: J219.10 Q9434.1(GATE) R70290.1
SSD_PIN1: APR117.1 APR122.1 J219.1
SSD_PWR_CNL: D4309.1(ANODE1) SR7930.2 U1.U47(GPP_K3)
SSD_RST_N: APR125.2 APR126.2 C12.1 J219.50
SURGE_IN_C: C9478.1 LC3.1 LC9.1 LU3.1(TCT1) LU3.4(TCT2) LU3.7(TCT3) LU3.10(TCT4)
SURGE_OUT_C: R19.2 R20.2 R21.2 R22.2 R23.2 U131.2
SURGE_OUT_R: LC4.1 R23.1
SUS3V_FON_N: ST32.1 U104.56(SUS3V_FON#/GP032)
SUS3V_ON_N: OR143.1 PQ9823.1(GATE) U104.74(SUS3V_ON#/GP076)
SUS5V_ON_N: R70294.2 U104.73(SUS5V_ON#/GP075)
SUS_ACK_EN_N: OR111.1 PQ102.2(EMITTER) SR700.1 U104.94(SUS_ACK_EN#/GP127)
SUS_CLK: ECR143.1 SR7792.2 SR7854.1
SUS_CLK_BUF: SR7791.2 UB1.5(ICLK)
SUS_CLK_BUF_SIO: ECR142.1 UBR1.2
SUS_CLK_BUF_SIO_R: UB1.2(Q0) UBR1.1
SUS_CLK_BUF_SSD: UBR3.2 X3R21.1
SUS_CLK_BUF_SSD_R: UB1.6(Q2) UBR3.1
SUS_CLK_BUF_WLAN: APR115.1 UBR2.2
SUS_CLK_BUF_WLAN_R: UB1.3(Q1) UBR2.1
SUS_CLK_SIO: ECR142.2 ECR143.2 SCB70.2 U104.19(CLK32)
SUS_CLK_SSD: SR7856.2 X3R20.1
SUS_CLK_SSD_R: J219.68 X3R20.2 X3R21.2
SUS_CLK_WLAN: APR115.2 APR116.2 J218.50(SSCLK) S1C81.1
SUS_PWR_ACK: PQ102.3(COLLECTOR) SR120.2 SR701.2 SR703.1 U1.BE35(GPP_A15/SUSACK#)
SUS_WARNB: ECR96.1 SR120.1 SR122.1 SR7844.2 SR7999.1 U1.BC37(GPP_A13/SUSWARN#/SUSPWRDNACK)
SUS_WARNB_R: ECR96.2 U104.68(SUS_WARN#/GP004)
SUS_WLAN_CK: APR116.1 SR7855.2
SUSCLK: SR272.1 SR7791.1 SR7792.1 SR7855.1 SR7856.1 U1.BE45(GPD8/SUSCLK)
SYS_FAN2_CTRL_SIO: OR149.1 U104.49((THERM_THRESH)GP024/PWM3)
SYS_FAN2_TACH_SIO: OR147.1 U104.39(TACH3/GP021)
SYS_FAN_CTRL_SIO: OR148.1 U104.48(GP023/PWM2)
SYS_FAN_TACH_SIO: OR146.1 U104.38(TACH2/GP020)
SYS_PWROK_PCH: SC84.1 SR274.2 SR292.1 U1.AU3(SYS_PWROK)
SYS_RESET#: APR9.1 HR380.2 SR264.2 SR267.2 SR759.1 SW_RST1.1 SW_RST1.2 U1.AU2(SYS_RESET#)
SYS_RESET#_APS: APR9.2 P466.13
TCK0: HR81.1 HR371.1 XDP1.57(TCK0) XU1.F11(PROC_TCK)
TDI: HR372.1 XDP1.56(TDI) XU1.G12(PROC_TDI)
TDO: HR91.2 SR764.1 XDP1.52(TDO) XU1.H13(PROC_TDO)
TMIN_SHIFT: ECR135.1 PQ93028.2(SOURCE) SR7982.2 SR7983.1 U1.BD33(GPP_B23/SML1ALERT#/PCHHOT#)
TMIN_SHIFT_SIO: ECR135.2 O2R10.2 O2R25.1 PQ93028.3(DRAIN) U104.33((TMIN_SHIFT)GP014)
TMS: HR384.1 XDP1.58(TMS) XU1.F13(PROC_TMS)
TP_CHA_XMM3_S2: D4T2.1 DIMM2.162(C0/CS2_N/NC)
TP_CHA_XMM3_S3: D4T1.1 DIMM2.165(C1/CS3_N/NC)
TP_CHB_XMM1_S2: D4T4.1 DIMM1.162(C0/CS2_N/NC)
TP_CHB_XMM1_S3: D4T3.1 DIMM1.165(C1/CS3_N/NC)
TP_CLKOUT_48: ST3.1 U1.BE33(GPP_A16/CLKOUT_48)
TP_CPU_BPM_N2: HT4.1 XU1.G14(BPM#[2])
TP_CPU_BPM_N3: HT5.1 XU1.H14(BPM#[3])
TP_CPU_RSVD_AB35: HT38.1 XU1.AB35(RSVD)
TP_CPU_RSVD_AB37: HT3.1 XU1.AB37(RSVD_1)
TP_CPU_RSVD_AB38: HT22.1 XU1.AB38(RSVD_2)
TP_CPU_RSVD_AC37: HT18.1 XU1.AC37(RSVD_3)
TP_CPU_RSVD_AJ22: HT37.1 XU1.AJ22(RSVD1)
TP_CPU_RSVD_AU9: HT34.1 XU1.AU9(RSVD_18)
TP_CPU_RSVD_AU10: HT39.1 XU1.AU10(RSVD_15)
TP_CPU_RSVD_AV1: HT9.1 XU1.AV1(RSVD4)
TP_CPU_RSVD_AW2: HT11.1 XU1.AW2(RSVD3)
TP_CPU_RSVD_B39: HT20.1 XU1.B39(RSVD_19)
TP_CPU_RSVD_C40: HT33.1 XU1.C40(RSVD_20)
TP_CPU_RSVD_D15: HT32.1 XU1.D15(RSVD_21)
TP_CPU_RSVD_H8: HT40.1 XU1.H8(RSVD2)
TP_CPU_RSVD_J7: HT6.1 XU1.J7(RSVD_TP_7)
TP_CPU_RSVD_J8: HT7.1 XU1.J8(RSVD_TP_8)
TP_CPU_RSVD_J11: HT26.1 XU1.J11(RSVD_28)
TP_CPU_RSVD_J13: HT31.1 XU1.J13(RSVD_29)
TP_CPU_RSVD_J14: HT30.1 XU1.J14(RSVD_30)
TP_CPU_RSVD_J15: HT17.1 XU1.J15(RSVD_31)
TP_CPU_RSVD_J17: HT28.1 XU1.J17(RSVD_32)
TP_CPU_RSVD_J19: HT15.1 XU1.J19(RSVD_33)
TP_CPU_RSVD_K8: HT12.1 XU1.K8(RSVD_TP_9)
TP_CPU_RSVD_K10: HT14.1 XU1.K10(RSVD_36)
TP_CPU_RSVD_K11: HT16.1 XU1.K11(RSVD_37)
TP_CPU_RSVD_K12: HT27.1 XU1.K12(RSVD_38)
TP_CPU_RSVD_K13: HT29.1 XU1.K13(RSVD_39)
TP_CPU_RSVD_L8: HT13.1 XU1.L8(IST_TRIG)
TP_CPU_RSVD_L10: HT8.1 XU1.L10(RSVD_42)
TP_CPU_RSVD_L12: HT10.1 XU1.L12(RSVD_43)
TP_DIMM_DQ0: HT1.1 XU1.AC40(DDR0_VREF_DQ)
TP_EDP_DISP_UTIL: HT2.1 XU1.D14(EDP_DISP_UTIL)
TP_GPP_H_15: R99519.2 SR297.1 U1.AC47(GPP_H15/SML3ALERT#)
TP_GPP_H_18: ST20.1 U1.AE44(GPP_H18/SML4ALERT#)
TP_GPP_H_23: SR7853.2 U1.AJ47(GPP_H23/TIME_SYNC0)
TP_PCH_AL35: TP2601.1 U1.AL35(TP_1)
TP_PCH_AN35: TP2602.1 U1.AN35(TP_2)
TP_TPM_GPIO0: F3R70.1 U7201.29(SDA/GPIO0)
TP_TPM_GPIO1: TP7201.1 U7201.30(SCL/GPIO1)
TP_UART0_RXD: LT12.1 U1.BB24(GPP_C9/UART0_TXD)
TP_UART0_TXD: LT11.1 U1.BE23(GPP_C8/UART0_RXD)
TPM_CLK_R: R7206.1 U7201.19(SCLK)
TPM_CS2#: R7210.2 SR7785.1 U7201.20(SCS#/GPIO5)
TPM_ID: SR25.2 SR7879.2 U1.BA36(GPP_A7/PIRQA#/ESPI_ALERT0#)
TPM_MISO_R: R7204.1 U7201.24(MISO)
TPM_MOSI_R: R7205.1 U7201.21(MOSI/GPIO7)
TPM_PIN2: R99513.2 U7201.2(NC_1)
TPM_PIN8: C7201.1 C7205.1 R7212.1 R7217.2 R7218.2 U7201.8(VHIO_1)
TPM_PIN9: R99511.2 U7201.9(NC_5)
TPM_PIN14: C7204.1 R7212.2 U7201.14(NC_9)
TPM_PIN22: C7209.1 C7210.1 R7215.2 R7216.2 U7201.22(VHIO_2)
TPM_PIN32: R7213.2 U7201.32(NC_16)
TPM_RST#: C7203.1 Q7201.2(SOURCE) R7203.1 R7209.1 U7201.17(RESET#)
TRST#: HR366.2 XDP1.54(TRSTN) XU1.F12(PROC_TRST#)
UART_BT_WAKE_N: R3111.1 SR672.2 U1.BE32(GPP_B2/VRALERT#)
UART_BT_WAKE_R_N: J218.20(UART_WAKE*) R3111.2
UIM_PWR70: J218.70(UIM_PWR_SRC/GPIO1/PEWAKE1*) R3136.2 SR7887.2
USB2_COMP_W4S5L400MIL: SR322.1 U1.F4(USB2_COMP)
USB2ID: R2102.2 R2104.1 U1.G3(USB2_ID)
USB2VBUSSENSE: R2101.2 R2103.1 U1.F3(USB2_VBUSSENSE)
USB3_RXN1_F1: CM3302.3 RN108.1(X) U1.D11(USB31_1_RXN)
USB3_RXN1_F1_R: CM3302.4 D3301.5(TMDS_CH2+) D3301.6(NC1) J133.5(SSRX-) RN108.2(Y)
USB3_RXN2_F2: CM4005.3 RN44.1(X) U1.B9(USB31_2_RXN)
USB3_RXN2_F2_R: CM4005.4 D4003.5(TMDS_CH2+) D4003.6(NC1) J200.5(SSRX-) RN44.2(Y)
USB3_RXN3_B1: CM3601.2 RN93.3(X) U1.B10(USB31_3_RXN)
USB3_RXN3_B1_R: CM3601.1 D3601.1(TMDS_CH1-) D3601.10(NC4) J12.14(SSRX-_2) RN93.4(Y)
USB3_RXN4_B2: CM3605.3 RN90.1(X) U1.K16(USB31_4_RXN)
USB3_RXN4_B2_R: CM3605.4 D3603.1(TMDS_CH1-) D3603.10(NC4) J12.5(SSRX-_1) RN90.2(Y)
USB3_RXP1_F1: CM3302.2 RN108.3(X) U1.C11(USB31_1_RXP)
USB3_RXP1_F1_R: CM3302.1 D3301.4(TMDS_CH2-) D3301.7(NC2) J133.6(SSRX+) RN108.4(Y)
USB3_RXP2_F2: CM4005.2 RN44.3(X) U1.C9(USB31_2_RXP)
USB3_RXP2_F2_R: CM4005.1 D4003.4(TMDS_CH2-) D4003.7(NC2) J200.6(SSRX+) RN44.4(Y)
USB3_RXP3_B1: CM3601.3 RN93.1(X) U1.C10(USB31_3_RXP)
USB3_RXP3_B1_R: CM3601.4 D3601.2(TMDS_CH1+) D3601.9(NC3) J12.15(SSRX+_2) RN93.2(Y)
USB3_RXP4_B2: CM3605.2 RN90.3(X) U1.J15(USB31_4_RXP)
USB3_RXP4_B2_R: CM3605.1 D3603.2(TMDS_CH1+) D3603.9(NC3) J12.6(SSRX+_1) RN90.4(Y)
USB3_TXN1_F1: CM3301.3 RN107.1(X) SC2.2
USB3_TXN1_F1_C: SC2.1 U1.F9(USB31_1_TXN)
USB3_TXN1_F1_R: CM3301.4 D3301.2(TMDS_CH1+) D3301.9(NC3) J133.8(SSTX-) RN107.2(Y)
USB3_TXN2_F2: CM4004.3 RN43.1(X) SC145.2
USB3_TXN2_F2_C: SC145.1 U1.C3(USB31_2_TXN)
USB3_TXN2_F2_R: CM4004.4 D4003.2(TMDS_CH1+) D4003.9(NC3) J200.8(SSTX-) RN43.2(Y)
USB3_TXN3_B1: CM3602.2 RN94.3(X) SC88.2
USB3_TXN3_B1_C: SC88.1 U1.F11(USB31_3_TXN)
USB3_TXN3_B1_R: CM3602.1 D3601.4(TMDS_CH2-) D3601.7(NC2) J12.17(SSTX-_2) RN94.4(Y)
USB3_TXN4_B2: CM3606.3 RN91.1(X) SC8.2
USB3_TXN4_B2_C: SC8.1 U1.B14(USB31_4_TXN)
USB3_TXN4_B2_R: CM3606.4 D3603.4(TMDS_CH2-) D3603.7(NC2) J12.8(SSTX-_1) RN91.2(Y)
USB3_TXP1_F1: CM3301.2 RN107.3(X) SC1.2
USB3_TXP1_F1_C: SC1.1 U1.F7(USB31_1_TXP)
USB3_TXP1_F1_R: CM3301.1 D3301.1(TMDS_CH1-) D3301.10(NC4) J133.9(SSTX+) RN107.4(Y)
USB3_TXP2_F2: CM4004.2 RN43.3(X) SC144.2
USB3_TXP2_F2_C: SC144.1 U1.D4(USB31_2_TXP)
USB3_TXP2_F2_R: CM4004.1 D4003.1(TMDS_CH1-) D4003.10(NC4) J200.9(SSTX+) RN43.4(Y)
USB3_TXP3_B1: CM3602.3 RN94.1(X) SC89.2
USB3_TXP3_B1_C: SC89.1 U1.G12(USB31_3_TXP)
USB3_TXP3_B1_R: CM3602.4 D3601.5(TMDS_CH2+) D3601.6(NC1) J12.18(SSTX+_2) RN94.2(Y)
USB3_TXP4_B2: CM3606.2 RN91.3(X) SC7.2
USB3_TXP4_B2_C: SC7.1 U1.C14(USB31_4_TXP)
USB3_TXP4_B2_R: CM3606.1 D3603.5(TMDS_CH2+) D3603.6(NC1) J12.9(SSTX+_1) RN91.4(Y)
USB_CABLE_DET1_R: SR72.2 SR88.1 U1.R46(GPP_K7)
USB_EN_S4WAKE: SR8000.1 U1.R47(GPP_K17/ADR_COMPLETE)
USB_EN_S4WAKE_R: AQ20.6(D1) SR3701.2 SR8000.2 SR8002.2 UU22.4(EN/EN#)
USB_OC0_R_N: SC146.1 SR9.2 SR7858.1 U1.AH36(GPP_E9/USB2_OC0#) UU66.3(FLAG)
USB_OC1_R_N: SR23.2 SR750.1 U1.AL40(GPP_E10/USB2_OC1#) UU19.3(OC#)
USB_OC2_R_N: SR22.2 SR751.1 U1.AJ44(GPP_E11/USB2_OC2#) UU64.3(FLAG)
USB_OC3_R_N: SR21.2 SR752.1 U1.AL41(GPP_E12/USB2_OC3#) UU22.3(OC#)
USB_OC4_R_N: SR18.2 U1.AV47(GPP_F15/USB2_OC4#)
USB_OC5_R_N: SR17.2 U1.AR35(GPP_F16/USB2_OC5#)
USB_OC7_R_N: SR20.2 U1.AV43(GPP_F18/USB2_OC7#)
USB_PN1_F1: CM3303.1 RN109.1(X) U1.J3(USB2N_1)
USB_PN1_F1_R: CM3303.4 D3302.1(CH1) J133.2(D-) RN109.2(Y)
USB_PN2_F2: CM4003.1 RN149.1(X) U1.N13(USB2N_2)
USB_PN2_F2_R: CM4003.4 D3302.4(CH3) J200.2(D-) RN149.2(Y)
USB_PN3_B1: CM3603.1 RN95.1(X) U1.K4(USB2N_3)
USB_PN3_B1_R: CM3603.4 D3602.6(CH4) J12.11(D-_2) RN95.2(Y)
USB_PN4_B2: CM3604.1 RN89.1(X) U1.M10(USB2N_4)
USB_PN4_B2_R: CM3604.4 D3602.3(CH2) J12.2(D-_1) RN89.2(Y)
USB_PN7_B3: CM3703.2 RN80.3(X) U1.L4(USB2N_7)
USB_PN7_B3_R: CM3703.3 D3702.6(CH4) J13.6 RN80.4(Y)
USB_PN8_B4: CM3704.2 RN86.3(X) U1.G4(USB2N_8)
USB_PN8_B4_R: CM3704.3 D3702.3(CH2) J13.2 RN86.4(Y)
USB_PN14_M.2_BT: L8.1 RN11.3(X) U1.E5(USB2N_14)
USB_PN14_M.2_BT_R: J218.5(USB_D-) L8.2 RN11.4(Y)
USB_PP1_F1: CM3303.2 RN109.3(X) U1.J2(USB2P_1)
USB_PP1_F1_R: CM3303.3 D3302.6(CH4) J133.3(D+) RN109.4(Y)
USB_PP2_F2: CM4003.2 RN149.3(X) U1.N15(USB2P_2)
USB_PP2_F2_R: CM4003.3 D3302.3(CH2) J200.3(D+) RN149.4(Y)
USB_PP3_B1: CM3603.2 RN95.3(X) U1.K3(USB2P_3)
USB_PP3_B1_R: CM3603.3 D3602.1(CH1) J12.12(D+_2) RN95.4(Y)
USB_PP4_B2: CM3604.2 RN89.3(X) U1.L9(USB2P_4)
USB_PP4_B2_R: CM3604.3 D3602.4(CH3) J12.3(D+_1) RN89.4(Y)
USB_PP7_B3: CM3703.1 RN80.1(X) U1.L3(USB2P_7)
USB_PP7_B3_R: CM3703.4 D3702.1(CH1) J13.7 RN80.2(Y)
USB_PP8_B4: CM3704.1 RN86.1(X) U1.G5(USB2P_8)
USB_PP8_B4_R: CM3704.4 D3702.4(CH3) J13.3 RN86.2(Y)
USB_PP14_M.2_BT: L8.4 RN11.1(X) U1.F6(USB2P_14)
USB_PP14_M.2_BT_R: J218.3(USB_D+) L8.3 RN11.2(Y)
V_IN: O2CB19.1 O2R22.2 O2R24.2 U104.46(V_IN)
V_SA0_DIMM0_CHA: D4R5.2 D4R10.1 DIMM2.256(SA0)
V_SA0_DIMM0_CHB: D4R16.2 D4R21.1 DIMM1.256(SA0)
V_SA1_DIMM0_CHA: D4R6.2 D4R11.1 DIMM2.260(SA1)
V_SA1_DIMM0_CHB: D4R17.2 D4R22.1 DIMM1.260(SA1)
V_SA2_DIMM0_CHA: D4R7.2 D4R12.1 DIMM2.166(SA2)
V_SA2_DIMM0_CHB: D4R18.2 D4R23.1 DIMM1.166(SA2)
VCORE1_CSP1_A: PC89008.1 PR89007.1 PR89016.2 PU89001.39(CSP1)
VCORE2_CSP2_A: PC89010.1 PR89010.2 PR89017.1 PU89001.41(CSP2)
VCORE3_CSP3_A: PC89014.1 PR8901.2 PR89021.1 PR89022.2 PU89001.43(CSP3)
VCORE_+19V: PC9001.1 PC9002.1 PC9003.1 PC90001.1 PC90002.1 PC90003.1 PC90012.1 PC90013.1 PC93001.1 PC93002.1 PC93012.1 PC93013.1 PC941587.1 PC941622.1 PC941626.1 PCE31.1 PCE125.1 PL90010.1 PL90011.1 PL90012.1 PL90013.1 PQ90001.3(V+1) PQ90001.4(V+2) PQ90001.10(V+(HSD)) PQ90001.19(V+(HSD)_1) PQ90001.20(V+(HSD)_2) PQ93001.2(D1) PQ93002.2(D1) PQ93008.3(V+1) PQ93008.4(V+2) PQ93008.10(V+(HSD)) PQ93008.19(V+(HSD)_1) PQ93008.20(V+(HSD)_2) PQ93018.3(V+1) PQ93018.4(V+2) PQ93018.10(V+(HSD)) PQ93018.19(V+(HSD)_1) PQ93018.20(V+(HSD)_2) PR112.1
VCORE_ALERT: PR89014.1 PU89001.4(ALERT#)
VCORE_COMP: PC89003.1 PC89013.1 PU89001.48(COMP)
VCORE_COMP_R: PC89003.2 PR89012.2
VCORE_CSCOMP: PC89018.1 PC89020.1 PR89025.1 PR89030.2 PRT89001.1 PU89001.47(CSCOMP)
VCORE_CSCOMP_R: PR89025.2 PR89026.1 PRT89001.2
VCORE_CSN1_A: PC89002.1 PC89008.2 PJP90002.2 PR89007.2 PR89034.2 PU89001.38(CSN1)
VCORE_CSN2_A: PC89010.2 PC89011.1 PJP90004.2 PR89017.2 PR89037.2 PU89001.40(CSN2)
VCORE_CSN3_A: PC89014.2 PC89015.1 PJP93005.2 PR89021.2 PR89039.2 PU89001.42(CSN3)
VCORE_CSP1_A: PJP90001.2 PR89016.1 PR89024.2
VCORE_CSP2_A: PJP90003.2 PR89010.1 PR89027.2
VCORE_CSP3_A: PJP93006.2 PR89022.1 PR89031.2
VCORE_CSREF_A: PC89022.2 PR89034.1 PR89037.1 PR89039.1 PU89001.44(CSREF)
VCORE_CSSUM: PC89018.2 PC89020.2 PR89024.1 PR89026.2 PR89027.1 PR89031.1 PU89001.45(CSSUM)
VCORE_DIFFOUT: PR89011.1 PR89018.1 PU89001.50(DIFF)
VCORE_DIFFOUT_R: PC89012.2 PR89011.2
VCORE_DRON_A: PC89005.1 PR90005.1 PR90013.1 PR93005.1 PR93013.1 PR93071.1 PU89001.35(DRON)
VCORE_FB: PC89012.1 PC89013.2 PR89012.1 PR89018.2 PR89019.1 PU89001.49(FB)
VCORE_ICCMAX1: PR89065.2 PU89001.29(ICCMAX1)
VCORE_ILIM_A: PR89030.1 PU89001.46(ILIM)
VCORE_IMAX: PR89040.2 PU89001.36(ICCMAX2)
VCORE_IOUT: PC89021.1 PR89035.2 PU89001.1(IOUT)
VCORE_PROG: PR89036.1 PU89001.10(PH_CONFIG/FDM/FDA/SR/DDR)
VCORE_PWM1_A: PU89001.34(PWM1) PU90001.2(PWM)
VCORE_PWM2_A: PU89001.33(PWM2) PU90002.2(PWM)
VCORE_PWM3_A: PU89001.32(PWM3) PU93004.2(PWM)
VCORE_SCLK: PR89006.1 PU89001.5(SCLK)
VCORE_SDIO: PR89004.1 PU89001.3(SDIO)
VCORE_TSENSE: PC89036.1 PR89068.2 PU89001.37(TSENSE)
VCORE_TSENSE_R: PR89068.1 PR89071.1 PRT89003.1
VCORE_VBOOT/ADDR: PR89038.1 PU89001.28(VBOOT/ADDR)
VCORE_VBOOTA: PR89064.2 PU89001.27(VBOOTA/ADDRA)
VCORE_VCC_C: PC89006.1 PR8901.1 PR89015.2 PU89001.7(VCC)
VCORE_VRDY_A: PC89009.1 PR89009.2 PR89105.2 PU89001.6(VRDY)
VCORE_VRMP: PC89004.1 PR89005.2 PU89001.9(VRMP)
VCORE_VSN: PC89019.2 PR89029.2 PU89001.52(VSN)
VCORE_VSP: PC89016.1 PC89017.1 PR89020.2 PR89023.2 PU89001.51(VSP)
VD11_1: M1R25.2 VD11.1(CATHODE1)
VD11_2: M1R26.2 VD11.2(CATHODE2)
VD33STB: C941492.1 R182.2 R69693.2 U6.20(VD33_STB)
VF2_1: F1.2 J125.18 M1C73.1 SCB126.1
VGA_CABLE_DET: J69.29 SR7975.2
VGA_CABLE_DET_R: SR103.2 SR7975.1 U1.Y48(GPP_K13/GSXSLOAD)
VIDALERT#: HR15.2 HR23.1 PR89013.2 PR89014.2
VIDSCLK: PR89002.1 PR89006.2 XU1.E38(VIDSCK)
VIDSOUT: HR14.2 PR89001.2 PR89004.2 XU1.E40(VIDSOUT)
VISACH1_D0: SR52.2 SR154.1 SR7816.1 SR7917.1 U1.AJ43(GPP_E1/SATAXPCIE1/SATAGP1)
VISACH1_D0_R: SR154.2 XDP3.9(OBSDATA_A0)
VISACH1_D1_R: SR155.2 XDP3.11(OBSDATA_A1)
VISACH1_D2_PCH_GPP_E_4: SR343.2 SR546.1 U1.AL48(GPP_E4/SATA_DEVSLP0)
VISACH1_D2_PCH_GPP_E_5: SR344.2 SR547.1 SR7915.1 U1.AH35(GPP_E5/SATA_DEVSLP1)
VISACH1_D2_PCH_GPP_E_6: SR345.2 SR548.1 U1.AH40(GPP_E6/SATA_DEVSLP2)
VISACH1_D3_R: SR546.2 XDP3.17(OBSDATA_A3)
VISACH1_D4_R: SR547.2 XDP3.27(OBSDATA_B0)
VISACH1_D5: SR548.2 XDP3.29(OBSDATA_B1)
VISACH1_D6_R: SR624.2 XDP3.33(OBSDATA_B2)
VISACH1_D7_R: SR625.2 XDP3.35(OBSDATA_B3)
VISACH2_CLK_PCH_GPP_F_3: SR402.1 SR756.1 SR7832.1 U1.AM47(GPP_F3/SATAXPCIE6/SATAGP6)
VISACH2_CLK_PCH_GPP_F_4: SR403.1 SR7833.1 U1.AM48(GPP_F4/SATAXPCIE7/SATAGP7) XDP3.6(OBSFN_C1)
VISACH2_D4_PCH_GPP_F_0: SR669.1 SR753.1 SR7829.1 U1.AN47(GPP_F0/SATAXPCIE3/SATAGP3)
VISACH2_D4_PCH_GPP_F_1: SR400.1 SR754.1 SR7830.1 U1.AM46(GPP_F1/SATAXPCIE4/SATAGP4)
VISACH2_D4_PCH_GPP_F_2: SR401.1 SR755.1 SR7831.1 U1.AM43(GPP_F2/SATAXPCIE5/SATAGP5)
VISACH2_D4_R: SR753.2 XDP3.28(OBSDATA_D0)
VISACH2_D5_R: SR754.2 XDP3.30(OBSDATA_D1)
VISACH2_D6_R: SR755.2 XDP3.34(OBSDATA_D2)
VISACH2_D7_R: SR756.2 XDP3.36(OBSDATA_D3)
VR_HOT: PR89066.1 PU89001.12(VR_HOT)
VREF: AC87.1 U6.28(VREF)
VREF_CA_RC: HC1.2 HR7.1
VRM_PWRGD: PC21.1 PR27.2 PR89009.1 PU3.15(EN/DEM) Q9309.1(GATE)
VRM_PWRGD_LED: CR2.2(CATHODE) R4821.1
VRM_PWRGD_LED_D: Q9309.3(DRAIN) R4821.2
WAKE#: APR18.1 APR121.2 SR262.2
WAKE#_R: APR18.2 APR119.2 J219.54 X3R14.2
WAKE_M2_SSD_N: SR342.2 SR549.1 U1.AL47(GPP_E3/CPU_GP0)
WAKE_WLAN#: APR120.1 APR121.1 J218.55(PEWAKE0*)
WLAN_3V_EN: C941636.1 MQ26.3(DRAIN) PU10.5(EN2) SR78.1 SR7877.2 SR7880.2
WLAN_CLKREQ1_N: APR75.1 SR909.2 SR7895.2 U1.BE31(GPP_B6/SRCCLKREQ1#)
WLAN_CLKREQ1_N_R: APR75.2 J218.53(CLKREQ0*)
WLAN_PCIE_DE: APR135.2 J218.51(GND_51) PR93083.1 U1.AR42(GPP_F10/SATA_SCLOCK)
WLAN_PE1_TXN8_C: J218.37(PETN0) M1C70.2
WLAN_PE1_TXP8_C: J218.35(PETP0) M1C69.2
WLAN_PWR_CNL: D524.2(CATHODE2) SR7929.2 U1.U48(GPP_K2)
WLAN_RST_N: APR123.2 APR124.2 J218.52(PERST0*) S1C80.2
WLAN_USB_DETECT: APR134.2 J218.1(GND_1) SR404.2 U1.AP48(GPP_F5/SATA_DEVSLP3)
WLQ5_E: Q4001.2(EMITTER) R4007.2
WLQ5_G: Q4001.1(BASE) R4005.2
XBT1_1: R70.1 XBT1.1(+)
XCLK_BIASREF_W4S15L1000MIL: SR315.1 U1.T3(XCLK_BIASREF)
XDP_DBRESET_N: M1C67.1 SR759.2 SR777.2 XDP3.48(HOOK7/DBR#)
XDP_PLTRST_CPU#: HR343.2 HR378.1
XDP_PRS#: HR367.1 HR383.1 XDP1.60(GND18)
XTAL_24M_IN: F3R28.2 SC32.1 SR321.2 U1.U10(XTAL_IN)
XTAL_24M_IN_R: F3R28.1 Y18.1
XTAL_24M_OUT: SC31.1 SR321.1 U1.U9(XTAL_OUT) Y18.3
N197940330: SR897.2 U1.AR37(GPP_F17/USB2_OC6#)
N198807610: SR70.2 SR86.1 SR7981.1 U1.P48(GPP_K8)

Pads without a net: D525 2; D3101 3 8 11 12 13; D3102 3 8 11 12 13; D4309 2; DIMM1 87 88 91 92 95 97 100 101 104 105; DIMM2 87 88 91 92 95 97 100 101 104 105; E61 3 4 5 6 11 12 13 14; J125 13 14; J218 6 16 66 68; J219 6 8 20 22 24 26 28 30 32 34 36 46 48 56 58 67; NOREF#6 1; NOREF#9 1; NOREF#14 1; NOREF#67 1; NOREF#71 1; NOREF#73 1; NOREF#74 1; NOREF#75 1; NOREF#76 1; P12 5 7 13 14 15 16; P110 P11 P13 P14 P15; PPID1 1; PQ22 5; PU4 19; PU6 5; PU7601 5; Q93033 5; U1 A17 A25 A42 A44 AA1 AB48 AC2 AC3 AC6 AC7 AC9 AC11 AC14 AC15 AC43 AC44 AD47 AD48 AE9 AE11 AE43 AE48 AG45 AH15 AH46 AH47 AH48 AJ6 AJ7 AJ46 AL15 AM7 AN4 AN18 AN29 AP2 AP21 AP24 AR13 AR18 AT10 AU24 AV7 AV16 AW3 AW15 AW24 AW26 B15 B17 B18 B19 B23 B25 B26 B27 B40 B41 B42 B44 BA20 BA24 BA30 BB16 BB20 BC17 BD12 BD16 BD17 BD29 BE12 BE14 BE15 BE17 BE18 BE19 BE21 BF10 BF14 BF15 BF17 BF18 BF19 BF31 C15 C16 C17 C18 C19 C20 C21 C23 C26 C27 C39 C40 C41 C42 C44 C47 D20 D21 D29 D39 D42 D43 D46 E28 E45 F14 F16 F26 F44 F46 G1 G2 G14 G17 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J13 J18 J21 J24 K6 K7 K13 K18 K21 K29 K43 K44 L2 L24 L26 L41 M1 M6 M26 M29 M40 M44 N2 N3 N8 N18 N32 N42 P9 P21 P24 P41 R10 R13 R15 R18 R21 R24 R32 R35 R37 R40 R44 T1 T2 T43 T47 U2 U3 U13 U35 U37 U40 U41 V2 V3 W3 W4 W6 W7 W43 W44 W47 Y2 Y14 Y15 Y35 Y36 Y40 Y41; U6 2 3 15 16 44 45 48; U104 13 67 76 84 85 87 93 106; U7201 3 4 5 6 7 10 11 12 13 15 25 26 27 28 31; U9435 3 4 5 6 11 12 13 14; UB1 7; XDP3 21 22 23 24 42 45 54 57; XU1 A5 A6 AL15 AL25 AL26 AM15 AM25 AM26 AN17 AN20 AN21 AN25 AN26 AP15 AP19 AP20 AP25 AP26 AR25 AR26 AT16 AT33 AU12 AU16 AU29 AU31 AU32 AU33 AV10 AV13 AV16 AV24 AV25 AV31 AV32 AV33 AW16 AW29 AW31 AW33 AY10 AY31 B4 B5 B7 B8 B13 C3 C4 C6 C7 C9 C13 D2 D3 D5 D6 D9 D10 D12 E1 E2 E4 E5 E10 E12 F2 F3 F5 F6 F9 G1 G2 G4 G5 G9 G10 H2 H3 H5 H6 H10 J1 J2 J4 J5 K2 K3 K5 K6 L1 L2 L4 L5 M2 M3 M5 M6 N1 N2 N4 N5 P2 P3 P5 P6 R1 R2 R4 R5 T2 T3 T5 T6 U4 U5; Y5 2 3

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4962 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 1229 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 545 vias
v4: diameter 0.559, hole 0.279, TOP to BOTTOM, 3 vias
v5: diameter 0.762, hole 0.254, TOP to BOTTOM, 10 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+1V_LAN: length 9.3
  IN1 w0.508: v1(22.35,137.86) 21.92,137.86 21.23,137.18 21.23,136.82 19.75,135.34 v1(19.75,135)
  BOTTOM w0.222: v1(19.94,141.11) 19.75,140.93 U114.22 ; U114.8 17.75,135.61 v1(17.45,135.31) ; U114.30 22.18,137.69 v1(22.35,137.86) ; v1(19.75,135) U114.3
  vias: v2(17.37,142.23)
+1V_ST_DISCH_A: length 2.4
  BOTTOM w0.254: v2(118.95,29.94) R93122.2 119.51,30.88 120.09,31.46 Q93038.3
+5V: length 862.4
  TOP w0.254: M1Q8.1 129.81,157.94 130.4,158.54 130.55,158.54 v1(130.73,158.71) 130.94,158.51 130.94,156.52 M1R19.1 ; v1(146.25,158.14) 146.25,158.49 145.97,158.77 VD11.3
  TOP w0.279: v1(52.6,134.66) 52.55,134.71 52.55,134.9 52.27,135.18 PU3.9
  TOP w0.305: R7202.1 7.66,67.15 v1(8.09,67.15)
  TOP w0.381: v1(4.43,17.01) 5.49,15.96 5.49,14 6.33,13.16 10.09,13.16 10.21,13.27 R69695.1
  TOP w0.457: PR27.1 51.01,140.06 51.08,139.99 v1(51.13,139.99) ; 112.31,170.59 SR7903.1 110.68,170.59
  TOP w0.508: v1(31.48,144.83) 30.66,144.01 v1(30.66,141.72) ; Q93025.2 153.33,169.82 153.62,169.53 154.51,169.53 154.61,169.43 155.22,169.43 155.8,168.85 v1(155.8,168.42) 155.83,168.39 C941623.1 ; v1(108.53,157.65) 108.69,157.5 SR7907.1 ; v1(85.06,153.86) 85.65,153.28 85.65,151.09 85.14,150.59 84.48,150.59 84.04,150.15 J68.19 ; v1(87.15,153.86) 87.2,153.86 v2(88.08,154.74) 88.96,155.62 88.96,156.16 90.12,157.31 90.12,160.17 90.38,160.44 90.38,162.25 90.38,162.83 90.91,163.35 90.91,167.15 90.87,167.19 90.87,167.94 91.39,168.46 91.39,169.78 92.44,170.83 110.44,170.83 110.68,170.59 ; v1(116.36,168.09) 116.58,168.09 116.9,168.4 116.9,169.01 115.32,170.59 112.31,170.59 ; v1(161.26,110.33) 158.93,107.99 158.93,74.94 159.64,74.23 161.54,74.23 ; v1(161.42,136.69) 160.55,135.83 160.55,128.31 159.59,127.35 v1(158.95,127.35) ; 91.38,138.61 89.49,138.61 v1(89.25,138.37)
  TOP w0.635: v3(29.87,132.53) 29.87,135.56 31.05,136.74 31.05,139.25 30.66,139.64 v1(30.66,141.72)
  TOP w1.016: 160.16,36.97 161.01,36.97 163.12,39.08 163.12,43.53 165.35,45.77 165.35,54.5 161.99,57.86 161.99,70.9
  IN1 w0.254: v1(7.86,52.26) 7.86,53.77 6.08,55.56 6.08,57.01 8.17,59.1 8.17,67.06 v1(8.09,67.15)
  IN1 w0.508: v1(161.42,136.69) 164.18,139.46 164.18,149.37 161.92,151.63 161.92,157.22 159.21,159.93 157.76,159.93 156.52,161.17 156.52,162.7 154.98,164.24 154.98,167.31 155.8,168.14 v1(155.8,168.42) ; 50.82,140.83 51.13,140.53 51.13,140.05 51.13,140.05 v1(51.13,139.99) ; 50.82,140.83 50.62,141.04 48.66,141.04 46.71,142.99 42.9,142.99 42.26,143.63 v1(41.88,143.63) ; 50.82,140.83 53.41,140.83 55.95,138.28 v1(55.95,137.99) ; v1(162.1,118.05) 161.77,118.05 161.26,117.54 v1(161.26,110.33) ; v1(56.62,137.99) 56.62,137.68 55.93,137 54.31,137 53.8,136.49 53.8,135.61 53.36,135.17 53.11,135.17 v1(52.6,134.66)
  IN1 w0.762: v3(56.34,147.75) 57.06,147.75 59.06,149.75 65.4,149.75 66.65,151 77.4,151 77.47,151.07 84.98,151.07 85.52,151.61 85.52,153.36
  IN1 w1.397: 26.24,28.67 26.79,28.12 27.68,27.22 29.09,27.22 29.42,26.89 32.28,26.89 37.4,32 46.31,32 49.65,28.66 49.65,23.53 48.15,22.03 48.15,20.06
  IN1 w1.651: 25.42,27.12 27.92,24.62 31.75,24.62 32.28,25.15 36.41,25.15 41.58,19.98 46.46,19.98 ; 12.67,129.61 13.12,129.16 17.73,129.16 20.24,131.67 21.89,131.67
  IN2 w0.254: v1(108.53,157.65) 108.88,158 119.54,158 119.66,157.88 126.08,157.88 126.92,158.71 v1(130.73,158.71) 130.99,158.97 134.71,158.97 134.93,158.75 140.88,158.75 141.49,158.14 v1(146.25,158.14)
  IN2 w0.508: v1(41.88,143.63) 41.74,143.63 40.41,142.3 40.41,141.77 39.96,141.32 38.66,141.32 37.44,140.1 35.65,140.1 35.28,140.47 31.28,140.47 30.66,141.09 v1(30.66,141.72) ; v1(119.21,33.07) 121.76,30.52 v1(127.1,30.52) 127.71,30.52 133.7,36.51 141.79,36.51 143.83,34.47 146.44,34.47 148.49,36.52 v1(158.49,36.52) ; v1(82.17,141.19) 82.17,140.92 81.57,140.32 81.13,140.32 74.61,133.81 74.61,131.69 73.73,130.81 71.23,130.81 71.08,130.66 67.72,130.66 66.89,129.82 66.89,129.81 66.54,129.46 66.03,129.46 65.12,130.37 65.12,130.72 v1(64.34,131.51) ; v1(31.48,144.83) 32.07,144.83 33.12,143.79 34.68,143.79 37.06,146.17 38.47,146.17 v1(39.97,147.67) ; v1(6.81,126.84) 6.15,126.84 5.64,126.33 5.64,120.69 6.02,120.31 v1(6.45,120.31)
  IN2 w1.016: 92.48,14.37 94.82,16.7 96.57,16.7 97.64,17.77 104.42,17.77 105.56,16.63 109.83,16.63 111.42,18.22 121.81,18.22 125.15,21.56 130.44,21.56 131.37,22.49 133.26,22.49 135.17,20.58 137.97,20.58 138.46,21.07 144.86,21.07 153.49,29.71 158.77,29.71 159.79,30.72 159.79,36.85
  BOTTOM w0.127: 52.22,139.87 52.22,140.2 52.25,140.22 ; 45.62,132.02 45.97,132.02
  BOTTOM w0.254: v1(4.43,17.01) 5.11,17.7 5.11,20.35 4.14,21.33 4.14,21.83 3.68,22.29 3.68,25.21 3.99,25.52 3.99,33.42 6.6,36.03 6.6,39.4 6.79,39.59 ; PR93046.1 30.33,140.69 PR93051.1 30.72,141.66 v1(30.66,141.72) ; v1(7.86,52.26) 2.08,52.26 1.99,52.17
  BOTTOM w0.356: O2Q2.4 10.01,117.36 9.27,118.1 8.15,118.1 7.26,118.99 7.26,119.5 v1(6.45,120.31)
  BOTTOM w0.457: v1(39.97,147.67) PR93061.1 ; v1(82.17,141.19) 82.45,141.47 SR7994.2 ; v1(31.48,144.83) 31.68,145.04 PR93054.1
  BOTTOM w0.508: v1(89.25,138.37) 88.23,138.37 87.91,138.69 87.07,138.69 86.12,139.64 84.35,139.64 83.54,140.45 82.9,140.45 v1(82.17,141.19) ; 59.46,137.02 59.88,136.6 59.88,136.6 60.1,136.39 60.34,136.39 61.15,135.57 61.15,134.77 64.34,131.59 v1(64.34,131.51) ; v1(119.21,33.07) 118.3,33.07 116.57,34.8 R93107.1 ; v1(127.1,30.52) 127.1,28.97 126.74,28.62 126.74,26.69 125.83,25.77 R69684.1 ; PR90002.1 111.12,151.16 111.12,153.3 109.14,155.29 109.14,156.56 108.53,157.17 v1(108.53,157.65) 106.91,157.65 ; v1(6.81,126.84) 7.32,126.32 Q9433.1 7.63,128.91 8.33,129.61 10.54,129.61 ; 103.17,152.59 103.58,153 103.58,154.32 106.91,157.65 ; v1(162.1,118.05) 162.36,118.3 162.36,120.41 162.95,121.01 162.95,121.77 162.28,122.44 161.46,122.44 PR93002.1 161.21,122.95 161.9,123.64 161.9,124.42 159.18,127.14 ; 106.91,157.65 105.07,159.48 105.07,163.52 106.69,165.14 113.93,165.14 116.36,167.57 v1(116.36,168.09) ; v1(85.06,153.86) v1(87.15,153.86)
  BOTTOM w0.762: v3(56.34,147.75) 56.34,147.41 57.07,146.68 57.07,145 54.46,142.38 54.46,141.01
  BOTTOM w1.27: 34.52,132.88 35.79,131.61 42.49,131.61
  BOTTOM w1.651: 2.03,112.81 2.03,129.53 3.5,131 4.06,131 4.47,131.41 10.74,131.41 ; 2.08,108.35 1.99,108.26 1.99,41.57 3.97,39.59 6.79,39.59 6.8,39.58 17.55,39.58 18.31,38.83 20.75,38.83 25.78,33.8 25.78,29.76
  vias: v1(23.09,28.65) v1(23.68,28.41) v1(24.94,28.92) v1(24.94,28.29) v1(24.97,30.27) v1(24.97,29.56) v1(27.02,132.24) v1(27.61,132.48) v1(158.49,37.18) v3(11.15,129.15) v3(11.78,129.83) v3(23.24,132.22) v3(24.03,132.73) v3(47.12,13.73) v3(48.06,15.94) v3(48.06,14.93) v3(48.06,13.76) v3(90.22,13.99) v3(90.24,13.07) v3(91.16,13.99) v3(91.18,13.07) v3(92.1,13.07)
+5V3VA_IN: length 48.5
  TOP w2.032: 91.06,29.78 92.18,29.78 94.27,31.88 98.27,31.88 100.54,29.6 103.09,29.6 108.34,24.36 114.03,24.36 114.89,23.49 ; 119.19,23.42 127.02,23.42 128.62,21.81 128.62,17.19
  BOTTOM w1.016: 117.1,24.43 116.47,25.07 116.47,29.74
  vias: v1(116.53,23.79) v1(117.58,23.79) v2(87.7,29.2) v3(90.14,29) v3(91.11,29) v3(128.47,19.93) v3(128.5,18.99) v3(128.52,18.05) v3(128.52,17.08)
+5V_3V_VIN_C:
  vias: v2(111.01,29.66)
+5V_DISCH_A: length 5.4
  BOTTOM w0.254: Q9541.3 123.53,25.91 124.49,24.96 R69684.2 124.49,23.87 v2(123.72,23.11)
+5V_DUAL: length 255.9
  TOP w0.254: v1(55.81,129.32) 55.4,128.91 39.15,128.91 38.33,128.08 35.83,128.08 35.12,128.79 34.71,128.79 34.23,128.31 24.27,128.31 22.9,126.94 19.65,126.94 19.3,127.29 18.47,127.29 v1(18.29,127.47)
  TOP w0.508: 84.92,149.15 J68.17 ; 84.94,148.15 J68.15
  TOP w0.635: 85.47,148.33 85.47,146.4 84.63,145.56 84.63,139.36 85.55,138.45 88.01,138.45 88.95,137.51 91.62,137.51 v3(93.64,135.49)
  IN2 w0.254: v1(83.82,154.07) 83.37,153.61 83.37,147.27 83.41,147.23 83.41,142.74 82.42,141.75 81.42,141.75 80.8,141.13 80.8,140.68 72.67,132.55 70.89,132.55 70.53,132.91 67.31,132.91 66.64,133.58 64.31,133.58 63.43,132.69 62.75,132.69 61.1,131.04 61.1,129.08 60.91,128.89 56.24,128.89 v1(55.81,129.32)
  BOTTOM w0.254: v1(18.29,127.47) 18.29,121.48 18.45,121.31 18.45,118.98 16.99,117.51 16.99,116.42 17.59,115.83 OR68.2 OR69.2 OR70.2 OR71.2 ; v1(83.82,154.07) 83.82,153.89 85.19,152.52 85.19,150.33 v1(84.61,149.75)
  BOTTOM w0.635: v3(93.64,135.49) 96.39,132.74 96.39,130.58 99.42,127.55 99.42,125.66 99.57,125.51 99.57,119.29 96.42,116.14 96.42,107.76 90.18,101.53 90.18,96.72 92.36,94.54 92.36,78.41 89.25,75.3 89.25,73.24 87.12,71.11 87.12,56.53 85.32,54.73 85.32,53.2 88.1,50.41 88.1,37.92 89.46,36.57 92.43,36.57 93.95,35.04 v2(93.95,32.76) 93.95,30.72 92.99,29.76 92.99,27.4
+5V_DUAL_OC: length 1.8
  BOTTOM w0.508: UU65.3 100.1,26.71 99.26,27.55 ST26.1
+5V_HDD: length 3.1
  BOTTOM w0.508: P110.P8 49.06,128.51 ; P110.P9 50.33,128.51 ; P110.P7 47.79,128.51
+5V_HDMI:
  vias: v2(155.22,167.54)
+5V_LDOOUT:
  vias: v2(115.05,28.54)
+5VA: length 597.6
  TOP w0.254: v1(8.28,55.34) 5.61,52.67 5.61,46.57 5.19,46.15 5.19,36.94 3.77,35.52 v1(3.2,35.52) ; OR143.2 R70294.1 11.75,97.26 v1(11.78,97.3) 12.01,97.07 13.35,97.07 14.1,97.82 15.44,97.82 OR151.1 16.15,98.53 17.27,98.53 18.9,96.9 19.95,96.9 21.56,98.51 21.56,99.66 22.48,100.58 23.19,100.58 23.59,100.98 25.99,100.98 27.1,102.09 27.1,102.99 28.52,104.41 28.52,104.82 28.69,104.98 28.69,105.95 SR701.1 29.41,106.67 29.41,106.86 29.63,107.08 SR700.2 29.63,107.82 30.49,108.68 30.49,109.96 31.01,110.48 32.28,110.48 32.61,110.15 33.34,110.15 SR702.1 34.35,110.15 35.08,110.15 35.63,109.59 35.63,108.82 36.33,108.12 36.67,108.12 v1(36.68,108.11)
  TOP w0.457: v1(61.49,167.17) D3602.5 v1(61.49,165.32)
  TOP w0.508: v1(41.63,157.98) D3702.5 v1(41.63,160.01) ; v1(68.71,12.47) D3302.5 v1(68.71,14.32) ; v1(94.64,40.75) 94.64,39.14 92.3,36.8 v1(92.3,35.55)
  TOP w1.016: 82.09,19.29 82.09,21.3 84.02,23.23 92.84,23.23 94.08,24.48 v1(94.08,24.78) 94.08,25.62 95.28,26.82 99.36,26.82
  IN1 w0.254: v1(8.28,55.34) 11.12,52.49 11.12,49.62 15.48,45.27 18.29,45.27 21.61,41.95 26.1,41.95 27.45,40.59 27.64,40.4 32.92,40.4 33.12,40.6 33.3,40.78 36.93,40.78 38.14,41.99 42.99,41.99 43.51,41.47 44.88,41.47 v1(45.11,41.7)
  IN1 w0.508: v1(94.08,24.78) 94.08,18.53 99.95,12.66 99.95,10.96 v1(100.94,9.97)
  IN1 w0.762: 60.68,166.33 51.26,166.33 46.12,161.2 42.65,161.2 41.63,160.19 v1(41.63,160.01) ; 2.39,35.63 1.55,36.47 1.55,128.33 4.65,131.43 8.91,131.43 11.87,134.39 v3(13.55,134.39)
  IN1 w1.016: 4.47,22.11 3.78,22.8 3.78,26 1.71,28.07 1.71,29.67 3.96,31.92 3.96,35.27 ; 51.87,24.81 51.87,22.85 50.76,21.74 50.76,19.76 51.38,19.14 51.38,18.43 52.96,16.86 55.57,16.86
  IN2 w0.254: v1(16.18,121.07) 15.95,121.07 10.93,116.05 10.93,113.11 11.97,112.07 11.97,110.15 9.96,108.13 9.96,106.34 9.64,106.02 9.64,101 11.34,99.3 11.34,98.15 11.78,97.71 v1(11.78,97.3)
  IN2 w0.508: v1(94.64,40.75) 93.95,40.75 87.76,46.93 87.76,48.68 87.76,50.54 83.55,54.76 81.67,54.76 80.43,53.52 75.53,53.52 74.89,52.88 71.88,52.88 71.82,52.94 71.29,52.94 69.73,51.38 69.73,48.86 66.5,45.62 65.98,45.62 65.63,45.97 v1(65.63,46.07)
  IN2 w0.762: v3(13.66,148.96) 13.66,149.77 15.21,151.32 16.58,151.32 17.8,150.1 31.72,150.1 34.44,152.82 38.53,152.82 40.74,155.03 40.74,157.34 41.38,157.98 v1(41.63,157.98)
  IN2 w1.016: 54.23,16.86 53.47,16.09 53.47,14.87 53.82,14.52 53.82,13.59 54.81,12.6 63.28,12.6 64.87,14.19 67.11,14.19 67.87,13.43 ; 81.02,19.4 79.5,17.87 78.61,17.87 77.2,16.46 74.12,16.46 70.93,13.27 68.81,13.27 ; 3.91,35.12 4.93,34.1 4.93,32.46 10.67,26.72 15.23,26.72 18.57,30.05 18.57,31.66 19.16,32.26 25.79,32.26 26.88,31.17 28.66,31.17 29.62,32.12 45.92,32.12 50.82,27.22 50.82,25.36 ; 102.32,27.23 102.46,27.37 105.79,27.37 106.26,26.9 111.46,26.9 114.23,29.66
  BOTTOM w0.229: 66.57,45.58 PU10.4
  BOTTOM w0.254: PU8401.4 43.2,43.38 43.25,43.33 44.27,43.33 44.44,43.16 44.72,43.16 45.11,42.76 PC941605.1 v1(45.11,41.7) ; v3(13.55,134.39) 13.55,133.74 13.87,133.42 13.87,131.02 16.42,128.47 16.42,123.57 15.83,122.98 15.83,121.42 v1(16.18,121.07) ; PU8402.4 98.57,11.01 98.64,10.98 ; R93115.2 38.4,108.54 37.1,108.54 36.68,108.12 v1(36.68,108.11)
  BOTTOM w0.432: PR74.1 105.01,35.12 103.99,35.12 102.94,34.08 101.12,34.08 100,32.96 100,28.47 101.29,27.17 101.29,26.66 101.56,26.39 101.78,26.39
  BOTTOM w0.457: v1(65.63,46.07) PC941582.1 65.91,45.43 66.06,45.58 66.57,45.58
  BOTTOM w0.508: v1(100.94,9.97) 99.97,9.97 99.48,10.47 PC941614.1 99.24,10.63 98.89,10.98 98.64,10.98 ; v1(92.3,35.55) 93.19,34.66 93.19,30.98 92.31,30.1 v2(92.31,26.96) 92.31,26.25 93.78,24.78 v1(94.08,24.78)
  BOTTOM w0.762: v3(13.55,134.39) 13.55,141.25 13.1,141.7 13.1,142.39 11.48,144.01 11.48,146.18 12.18,146.88 12.18,148.09 13.05,148.96 v3(13.66,148.96)
  vias: v1(3.53,34.94) v1(5.43,21.94) v1(5.43,21.28) v1(50.9,25.29) v1(50.9,24.63) v1(54.43,16.98) v1(55.07,16.98) v1(81,19.52) v1(81.63,19.52) v1(101.75,26.15) v1(102.49,26.1) v1(114.73,29.87) v1(115.37,29.88)
+5VEN: length 4.2
  BOTTOM w0.254: PU8402.3 98.28,11.41 98.35,11.47 98.98,11.47 99.08,11.57 M1C99.2 ECR155.2 99.48,12.8 100.05,13.38 v2(100.25,13.38)
+5VSB: length 453.5
  TOP w0.254: v1(5.66,67.96) 8.18,70.47 v1(9.8,70.47) ; v1(23.02,62.47) 23.02,63.15 23.76,63.88 23.76,67.93 24.06,68.24 24.06,70.7 25.75,72.38 26.48,72.38 27.36,73.26 27.36,75.2 27.82,75.67 27.82,76.26 R59.1 ; v1(73.76,62.58) 73.81,62.52 73.81,61.92 75.15,60.57 75.15,56.39 v1(74.63,55.87)
  TOP w0.457: PR93097.1 71.66,64.69 v1(71.63,64.66)
  TOP w0.508: v1(93.52,167.35) 93.04,166.87 PR89015.1 ; v1(2.77,25.31) 2.91,25.46 R55.1 ; v1(39.76,142) 39.76,141.05 41.15,139.66 41.15,135.42 42.58,133.99 PR25.1 ; v1(74.63,55.87) 73.05,54.29 73.05,52.24 71.45,50.64 67.41,50.64 66.42,49.65 65.51,49.65 v1(64.97,49.11) ; v1(114.53,26.56) 112.04,29.05 112.04,32.48 109.4,35.12 102.97,35.12 v1(102.59,35.5) ; PR99.1 70,64.69 v1(70,64.53)
  IN1 w0.254: v1(23.02,62.47) 22.3,62.47 19.43,65.34 18.21,65.34 16.38,67.17 16.38,70.76 15.51,71.63 15.24,71.63 14.74,72.14 11.29,72.14 9.8,70.65 v1(9.8,70.47) ; v1(4.37,55.62) 4.37,56.91 6.93,59.47 6.93,60.6 7.5,61.17 7.5,64.76 5.66,66.61 v1(5.66,67.96)
  IN1 w0.508: v1(78.1,154.24) 78.1,155.87 79.86,157.62 79.86,160.94 85.66,166.74 92.91,166.74 v1(93.52,167.35) ; v3(74.57,25.72) 74.57,27.75 75.27,28.45 84.67,28.45 85.77,27.35 87.26,27.35 87.72,27.8 87.72,38.73 84.9,41.54 78.8,41.54 75.03,45.31 75.03,54.51 74.63,54.92 v1(74.63,55.87) ; v1(59.46,47.31) 59.87,46.9 59.87,46.4 60.44,45.82 62.04,45.82 64.97,48.76 v1(64.97,49.11)
  IN1 w0.762: v3(68.05,149.42) 70.1,149.42 70.41,149.11 71.63,149.11 71.93,149.42 72.64,149.42 ; 40.38,159.58 40.38,154.83 41.07,154.14 ; 20.8,149.82 22.35,149.82
  IN1 w1.016: 2.11,135.02 1.67,135.45 1.67,143.73 3.86,145.91 11.15,145.91 ; 114.18,25.4 113.49,24.7 113.49,13.33 112.65,12.49 105,12.49 102.77,14.72
  IN1 w2.032: 11.76,139.33 11.76,136.56 8.64,133.44 5.39,133.44
  IN1 w2.286: 20.12,147.08 22.1,147.08
  IN1 w3.048: 25.58,34.64 34.24,34.64 34.89,35.29 45.26,35.29 ; 34.01,151.63 39.98,151.63
  IN2 w0.254: v1(73.76,62.58) 72.97,62.58 71.63,63.92 v1(71.63,64.66)
  IN2 w0.508: v1(78.1,154.24) 78.1,151.63 76.48,150 74.93,150 ; v1(71.63,64.66) 71.28,65 70.43,65 70,64.57 v1(70,64.53) ; v1(2.77,25.31) 4.62,25.31 4.65,25.34
  IN2 w0.762: 3.86,39.13 3.86,37.4 2.34,35.88 2.34,31.64 3.45,30.52 3.45,26.96 4.52,25.89
  IN2 w1.016: 1.95,135.07 1.67,135.35 1.67,142.26 4.32,144.9 10.39,144.9 11.91,143.37 ; 116.08,28.14 127.75,28.14 134.47,34.86 141.43,34.86 142.31,33.98
  IN2 w2.032: 4.65,133.42 8.61,133.42 12.39,137.2 12.39,139.54
  IN2 w3.048: 2.74,113.38 2.72,113.4 2.72,128.11 ; 2.69,94.96 2.69,107.27 ; 46.02,35.07 46.01,35.08 29.31,35.08 28.97,34.74 24.09,34.74
  BOTTOM w0.432: C8303.1 4.01,73.62 v1(4.06,73.68)
  BOTTOM w0.457: v1(73.76,62.58) 74.14,62.58 74.18,62.61 74.19,62.61 74.53,62.96 74.53,62.97 74.6,63.03 74.6,63.49 74.79,63.68 PR1017.1 ; M1C88.1 73.98,150.78
  BOTTOM w0.508: v1(102.59,35.5) 102.64,35.54 PR117.1 ; v1(43.28,152.01) 41.48,152.01 39.31,149.85 39.31,142.45 v1(39.76,142) ; C8302.1 v1(3.97,129.69) ; PR7608.1 60.4,50.09 60.4,47.6 60.11,47.31 v1(59.46,47.31)
  vias: v1(5.47,24.81) v1(5.46,24.18) v1(66.88,28.34) v1(67.23,149.44) v1(67.49,27.85) v1(73.23,149.7) v1(73.4,149.09) v1(73.94,149.85) v1(74.6,149.85) v1(115.19,26.56) v1(142.66,33.3) v1(143.29,33.3) v2(143.72,32.46) v3(1.67,134.79) v3(1.7,133.9) v3(1.7,133.01) v3(1.7,132.12) v3(2.64,133.92) v3(2.61,133.04) v3(2.61,132.15) v3(3.48,133.44) v3(3.45,132.5) v3(4.34,133.09) v3(4.27,51.42) v3(4.27,50.49) v3(4.27,49.57) v3(4.27,48.66) v3(4.27,47.72) v3(40.41,160.85) v3(40.97,161.58) v3(45.44,34.58) v3(45.46,35.5) v3(46.43,35.5) v3(46.46,34.58) v3(47.39,35.5) v3(47.42,34.58) v3(63.02,33.11) v3(63.04,31.71) v3(63.4,30.85) v3(63.59,32.43) v3(63.78,155.67) v3(63.78,154.75) v3(63.75,146.33) v3(64.64,146.32) v3(64.69,155.67) v3(64.69,154.75) v3(64.69,153.86) v3(65.61,155.67) v3(65.61,154.78) v3(65.61,153.89) v3(66.75,27.57) v3(66.75,26.69) v3(67.49,148.72) v3(67.59,27.09) v3(70.84,25.92) v3(71.83,25.87) v3(74.31,22.56) v3(75.2,22.57) v3(76.08,22.57) v3(76.97,22.57) v3(86.76,18.46) v3(87.04,17.59) v3(87.68,18.46) v3(87.78,16.65) v3(87.98,17.54) v3(88.67,18.3) v3(88.72,16.65) v3(89.1,17.49) v3(89.71,18.3) v3(89.69,16.63) v3(90.07,17.44) v3(99.92,16.73) v3(99.95,15.79) v3(99.97,14.85) v3(100.81,16.7) v3(100.84,15.76) v3(100.86,14.82) v3(101.7,16.7) v3(101.73,15.76) v3(101.75,14.82) v3(102.34,13.83) v3(102.34,12.94) v3(103.22,13.83) v3(103.22,12.94) v3(104.11,13.83) v3(104.11,12.94)
