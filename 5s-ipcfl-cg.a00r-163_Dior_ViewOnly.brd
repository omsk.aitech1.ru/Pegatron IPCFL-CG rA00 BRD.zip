# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XTAL_24M_IN_R: length 1.7
  TOP w0.127: Y18.1 51.6,109.47 F3R28.1
XTAL_24M_OUT: length 12.8
  TOP w0.102: 53.62,105.65 53.62,104.33 53.96,103.99 53.96,103.03 53.78,102.85 53.78,101.37 53.74,101.34 53.74,100.39 U1.U9
  TOP w0.127: 53.62,105.65 53.62,105.96 v2(54.13,106.47) 54.13,107.95 SR321.1 53.92,108.16 53.92,108.51 SC31.1 53.51,109.38 53.62,109.49 53.62,110.99 Y18.3
N197940330: length 17.8
  TOP w0.102: U1.AR37 44.51,86.45 v1(44.4,86.45)
  BOTTOM w0.102: v2(31.42,81.57) 31.42,81.87 31.95,82.4 33.63,82.4 34.32,83.09 34.8,83.09 34.99,82.9 37.56,82.9 38.16,83.5 38.16,83.77 38.4,84 40,84 40.22,83.77 41.2,83.77 41.67,84.24 42.11,84.24 43.35,85.48 44.22,85.48 44.48,85.74 44.48,86.37 v1(44.4,86.45) 44.4,86.75 44.74,87.1 SR897.2
N198807610: length 10.3
  TOP w0.102: U1.P48 55.2,81.23 55.46,80.98 55.46,80.13 v1(55.25,79.92)
  BOTTOM w0.102: v2(52.6,77.61) 52.6,78.02 51.62,79 SR70.2 51.48,79.32 51.48,79.64 51.89,80.04 51.89,80.64 SR7981.1 52.65,80.23 52.65,80.2 52.9,79.95 53.52,79.95 54.02,79.44 54.14,79.44 SR86.1 54.56,79.4 54.56,79.59 54.88,79.92 v1(55.25,79.92)

## Copper pours and planes (outline as drawn)
+1V_LAN on TOP (solid shape): 22.53,138.39 22.53,137.61 22.22,137.3 21.59,137.3 21.49,137.4 21.49,138.75 21.56,138.83 22.1,138.83
+1V_LAN on TOP (solid shape): outline of 208 points within 16.2,134.81 20.98,145.56
+5V on TOP (solid shape): 91.72,140.02 91.72,138.42 91.62,138.32 91.13,138.32 91.03,138.42 91.03,139.92 91.18,140.07 91.67,140.07
+5V on TOP (solid shape): 160.41,36.67 160.23,36.5 159.67,36.5 159.55,36.37 158.35,36.37 158.23,36.5 158.23,37.21 158.47,37.45 160.41,37.45
+5V on TOP (solid shape): 49.07,15.94 49.07,11.01 48.56,10.51 47.11,10.51 46.2,11.42 46.2,14.85 47.88,16.53 48.49,16.53
+5V on TOP (solid shape): 30.48,133.13 30.48,132.08 30.46,132.06 30.46,131.72 30.15,131.41 30.14,131.41 29.95,131.46 29.75,131.41 26.41,131.41 26.01,131 23.71,131 22.76,131.96 22.76,132.53 23.32,133.09 28.98,133.09 29.21,133.31 30.3,133.31
+5V on TOP (solid shape): 57,138.19 57,137.68 56.31,137 53.97,137 53.92,137.05 53.92,137.2 53.97,137.25 55.01,137.25 55.09,137.33 55.09,137.48 55.07,137.51 53.92,137.51 53.9,137.53 53.9,137.73 54.24,137.73 54.34,137.69 54.45,137.68 55.36,137.68 55.95,138.27 56.92,138.27
+5V on TOP (solid shape): 25.17,30.42 25.17,27.32 25.1,27.25 22.39,27.25 22.25,27.39 22.25,28.14 22.35,28.24 22.79,28.24 22.88,28.34 22.88,28.84 22.96,28.92 23.64,28.92 23.7,28.97 23.7,29.96 23.77,30.04 24.69,30.04 24.76,30.11 24.76,30.37 24.84,30.44 25.14,30.44
+5V on TOP (solid shape): 165.81,76.24 165.81,70.75 166.28,70.28 166.87,70.28 167.42,69.73 167.42,68.61 167.34,68.53 165.12,68.53 164.23,69.42 164.23,74.74 164.11,74.87 163.42,74.87 163.12,74.56 163.12,71.14 162.71,70.73 162.08,70.73 161.59,71.21 161.59,72.4 161.08,72.91 161.08,77.59 161.21,77.71 164.34,77.71
+5V on BOTTOM (solid shape): 12.34,131.79 12.34,128.59 12.19,128.44 10.26,128.44 9.83,128.87 9.83,131.97 10.16,132.3 11.83,132.3
+5V on BOTTOM (solid shape): 103.66,152.99 103.79,152.87 103.79,151.94 103.59,151.74 102.77,151.74 102.77,152.84 102.95,153.03 103.66,153.03
+5V on BOTTOM (solid shape): 26.62,30.52 26.62,28.26 26.31,27.96 24.89,27.96 24.83,28.02 24.83,28.16 24.76,28.23 24.76,30.47 24.97,30.67 26.47,30.67
+5V on BOTTOM (solid shape): 159.41,127.62 159.41,127.12 159.28,126.99 159.03,126.99 158.39,127.62 157.86,127.62 157.81,127.68 157.81,128.18 157.83,128.21 158.82,128.21
+5V on BOTTOM (solid shape): 49.1,16.37 49.1,15.31 49.11,15.29 49.11,12.32 48.44,11.65 46.89,11.65 46.28,12.26 46.28,15.24 46.58,15.55 46.85,15.76 46.85,16.1 46.85,16.48 47.15,16.78 48.69,16.78
+5V on BOTTOM (solid shape): 92.85,14.21 94.75,14.21 95.39,13.58 95.73,13.58 96.06,13.25 96.06,12.1 95.53,12.1 95.5,12.07 95.5,11.93 95.53,11.91 96.06,11.91 96.06,11.7 93.95,11.7 93.82,11.83 93.61,11.83 93.42,12.02 93.08,12.14 92.78,11.95 92.7,11.9 92.62,11.92 91.27,12.58 89.81,12.26 89.38,12.69 89.38,14.53 89.39,14.53 89.39,14.85 89.69,15.15 91.91,15.15
+5V on BOTTOM (solid shape): outline of 81 points within 1.22,108.2 4.34,113.63
+5V on BOTTOM (solid shape): outline of 688 points within 26.27,130.28 59.76,141.67
+5V on IN1 (solid shape): 87.4,153.91 87.4,153.33 86.87,152.8 84.96,152.8 84.71,153.05 84.71,153.69 85.04,154.02 87.3,154.02
+5V on IN1 (solid shape): 24.51,132.7 24.51,132.14 23.24,130.88 21.51,130.88 21.26,131.13 21.26,132.07 21.66,132.48 22.25,132.48 22.34,132.47 22.43,132.48 22.83,132.48 23.49,133.14 24.08,133.14
+5V on IN1 (solid shape): 14.04,130.19 14.04,129.57 13.27,128.8 13.12,128.7 13.03,128.55 11.14,128.55 10.79,128.89 10.79,129.35 11.99,130.55 13.69,130.55
+5V on IN1 (solid shape): 27.76,28.36 27.76,28.06 26.41,26.71 23.32,26.71 22.99,27.04 22.99,28.55 23,28.67 22.99,28.8 22.99,29.61 23.9,30.52 25.6,30.52
+5V on IN1 (solid shape): outline of 1466 points within 45.31,5.78 95.46,21.02
+5V on IN2 (solid shape): 160.3,37.24 160.3,36.4 159.92,36.02 158.55,36.02 158.2,36.38 158.2,37.27 158.5,37.57 159.97,37.57
+5V on IN2 (solid shape): outline of 198 points within 19.5,26.46 26.86,31.26
+5V on IN2 (solid shape): outline of 1114 points within 46.28,6.19 95.73,16.43
+5V3VA_IN on TOP (solid shape): 91.55,30.52 91.55,28.77 91.35,28.56 89.88,28.56 89.64,28.79 89.64,30.58 89.84,30.77 91.3,30.77
+5V3VA_IN on TOP (solid shape): 121.01,24.33 121.01,22.83 120.48,22.3 114.18,22.3 113.78,22.7 113.78,24.2 114.18,24.61 120.74,24.61
+5V3VA_IN on TOP (solid shape): 129.82,20.16 129.82,16.5 129.61,16.29 129.61,13.63 129.77,13.48 130.28,13.48 130.35,13.4 130.35,12.94 130.3,12.89 127.51,12.89 127.18,13.22 127.18,14.72 126.85,15.05 126.85,20.05 127.13,20.34 129.64,20.34
+5V3VA_IN on BOTTOM (solid shape): 117.87,24.48 117.87,23.42 117.56,23.11 116.34,23.11 115.78,23.67 115.78,25.19 115.93,25.35 117,25.35
+5V3VA_IN on BOTTOM (solid shape): 117.08,30.95 117.08,29.87 116.9,29.69 115.88,29.69 115.81,29.77 115.81,30.12 115.43,30.5 115.43,31.8 115.54,31.92 116.11,31.92
+5V3VA_IN on BOTTOM (solid shape): 129.59,19.84 129.59,15.56 129.13,15.1 128.12,15.1 127.86,15.36 127.86,16.37 127.51,16.73 127.51,16.74 127.24,17.01 127.24,20.16 127.35,20.27 129.16,20.27
+5V3VA_IN on BOTTOM (solid shape): 85.19,31.94 85.18,31.92 84.6,31.92 84.54,31.87 84.54,30.93 84.76,30.71 85.18,30.22 85.67,30.64 90.94,30.64 91.44,30.14 91.44,28.89 91.13,28.58 82.95,28.58 82.69,28.85 82.69,32.35 82.84,32.5 85.19,32.5
+5V_3V_VIN_C on BOTTOM (solid shape): 114.43,31.78 114.43,31.31 114.43,31.3 114.43,30.69 114.22,30.48 111.69,30.48 111.36,30.15 111.36,29.59 111.03,29.26 109.53,29.26 109.51,29.28 109.51,29.44 109.53,29.46 110.17,29.46 111.62,30.92 111.62,31.38 111.85,31.61 113.54,31.61 113.8,31.87 114.33,31.87
+5V_DUAL on TOP (solid shape): 85.92,149.88 85.92,147.92 85.71,147.72 84.76,147.72 84.49,147.99 84.49,150.02 84.57,150.1 85.7,150.1
+5V_DUAL on BOTTOM (solid shape): 97.56,27.65 98.5,27.65 98.65,27.5 98.65,25.64 98.5,25.49 97.53,25.49 97.18,25.85 93.29,25.85 92.94,26.2 92.94,27.75 93.09,27.9 97.31,27.9
+5V_HDD on BOTTOM (solid shape): outline of 107 points within 47.5,128.25 50.8,135.67
+5V_HDMI on TOP (solid shape): 153.55,168.19 153.71,168.15 153.88,168.18 153.89,168.19 155.07,168.19 155.47,167.78 155.47,167.4 155.29,167.22 154.99,167.22 154.76,166.99 154.76,166.31 154.33,165.88 153.08,165.88 152.86,166.11 152.86,167.53 153.52,168.19
+5V_LDOOUT on BOTTOM (solid shape): 113.34,28.74 114.48,28.74 114.7,28.97 115.28,28.97 115.48,28.78 115.48,28.29 115.35,28.17 112.71,28.17 112.68,28.14 111.57,28.14 110.85,28.85 109.58,28.85 109.51,28.93 109.51,29.03 109.53,29.05 113.03,29.05
+5VA on TOP (solid shape): 5.7,22.17 5.7,20.47 5.62,20.39 5.19,20.39 4.89,20.7 4.89,22.17 5.01,22.3 5.57,22.3
+5VA on TOP (solid shape): 82.76,20.03 82.76,18.71 82.59,18.54 81.12,18.54 80.58,19.08 80.58,19.84 80.99,20.25 82.54,20.25
+5VA on TOP (solid shape): 102.72,26.99 102.72,26 102.56,25.85 99.36,25.85 98.87,26.34 98.87,27.17 99.04,27.35 102.35,27.35
+5VA on BOTTOM (solid shape): 42.07,159.98 42.07,157.91 41.88,157.72 41.28,157.72 41.08,157.92 41.08,160.05 41.25,160.22 41.83,160.22
+5VA on BOTTOM (solid shape): 115.53,29.99 115.53,29.64 115.33,29.44 114.64,29.44 114.47,29.6 113.51,29.6 113.45,29.66 113.45,30.15 113.5,30.2 115.33,30.2
+5VA on BOTTOM (solid shape): 102.72,26.3 102.72,25.35 102.68,25.31 102.68,24.84 102.61,24.77 102.09,24.77 101.47,25.39 101.47,26.28 101.76,26.56 102.46,26.56
+5VA on IN1 (solid shape): 4.16,35.68 4.16,34.79 3.55,34.18 1.98,34.18 1.6,34.56 1.6,35.47 2.08,35.96 3.88,35.96
+5VA on IN1 (solid shape): 42.07,159.98 42.07,157.91 41.88,157.72 41.28,157.72 41.08,157.92 41.08,160.05 41.25,160.22 41.83,160.22
+5VA on IN1 (solid shape): 52.42,25.39 52.42,24.37 52.02,23.97 51.05,23.97 50.65,24.37 50.65,25.49 50.8,25.64 52.17,25.64
+5VA on IN1 (solid shape): 61.82,167.27 61.82,165.22 61.57,164.96 60.58,164.96 60.2,165.34 60.2,167.25 60.37,167.43 61.67,167.43
+5VA on IN1 (solid shape): 55.78,17.75 56.84,17.75 57.07,17.52 57.07,16.35 56.81,16.08 54.66,16.08 54.25,16.49 54.25,17.6 54.41,17.76 55.78,17.76
+5VA on IN1 (solid shape): 5.04,23.41 5.24,23.15 5.56,23.12 5.74,22.95 5.74,21.13 5.61,21 4.03,21 3.78,21.25 3.78,23.18 4.01,23.41
+5VA on IN2 (solid shape): 4.95,35.63 4.95,34.58 4.44,34.08 3.33,34.08 2.87,34.53 2.87,35.63 3.25,36.01 4.57,36.01
+5VA on IN2 (solid shape): 41.97,160.07 41.97,157.82 41.88,157.72 41.28,157.72 41.08,157.92 41.08,160.05 41.25,160.22 41.83,160.22
+5VA on IN2 (solid shape): 51.61,25.44 51.61,24.75 51.23,24.37 50.49,24.37 50.29,24.58 50.29,25.62 50.42,25.75 51.31,25.75
+5VA on IN2 (solid shape): 69.14,14.34 69.14,12.69 68.71,12.26 67.69,12.26 67.44,12.51 67.44,14.24 67.71,14.52 68.96,14.52
+5VA on IN2 (solid shape): 82.23,19.68 82.23,18.84 82.06,18.67 80.71,18.67 80.38,19 80.38,19.61 80.6,19.84 82.07,19.84
+5VA on IN2 (solid shape): 115.68,30.27 115.68,29.54 114.87,28.72 113.98,28.72 113.47,29.23 113.47,29.77 114.11,30.4 115.55,30.4
+5VA on IN2 (solid shape): 55.57,17.41 55.57,16.35 55.27,16.04 54.44,16.04 53.69,16.05 53.39,16.35 53.39,17.24 53.67,17.52 55.47,17.52
+5VA on IN2 (solid shape): 102.84,27.63 102.84,26.08 102.61,25.85 101.32,25.85 100.89,26.29 100.89,27.59 101.04,27.74 101.07,27.73 101.32,27.69 101.55,27.81 102.67,27.81
+5VSB on TOP (solid shape): 40.94,163.41 40.94,162.52 41.32,162.14 41.32,161.38 40.41,160.47 40.21,160.47 39.99,160.68 39.99,161.32 39.9,161.41 39.9,163.26 40.11,163.46 40.89,163.46
+5VSB on TOP (solid shape): 6.69,24.13 6.69,22.29 6.58,22.18 6.58,21.35 6.45,21.05 6.58,20.76 6.58,20.44 6.56,20.39 5.95,20.39 5.9,20.44 5.9,22.32 5.68,22.55 5.23,22.55 5.09,22.69 5.09,23.29 5.84,23.51 5.09,23.73 5.09,24.79 5.33,25.03 5.79,25.03
+5VSB on TOP (solid shape): outline of 90 points within 95.84,9.39 119.01,22.12
+5VSB on TOP (solid shape): outline of 114 points within 62.71,22.04 77.39,33.62
+5VSB on TOP (solid shape): outline of 246 points within 60.88,145.94 68.45,156.17
+5VSB on BOTTOM (solid shape): 115.45,27.78 115.45,26.06 115.31,25.92 114.37,25.92 114.26,26.03 114.26,27.61 114.51,27.86 115.38,27.86
+5VSB on BOTTOM (solid shape): 65.05,146.62 65.05,146.01 64.64,145.61 64.64,144.21 64.44,144.01 63.6,144.01 63.4,144.21 63.4,146.52 63.65,146.78 64.9,146.78
+5VSB on BOTTOM (solid shape): 144.41,33.58 144.41,30.53 144.15,30.27 143.24,30.27 143.21,30.3 143.21,32.32 142.42,33.12 142.42,33.57 142.66,33.8 144.18,33.8
+5VSB on BOTTOM (solid shape): 5.15,51.63 5.15,46.8 4.98,46.62 3.07,46.62 3.05,46.65 3.05,51.6 3.22,51.78 5,51.78
+5VSB on BOTTOM (solid shape): 74.98,150.82 74.98,149.65 74.65,149.32 73.84,149.32 73.71,149.19 73.71,149.09 73.51,148.89 73.29,148.89 73.24,148.94 73.24,149.33 73.06,149.51 73.06,149.76 73.24,149.94 73.24,149.95 73.25,149.96 73.25,150.71 73.51,150.97 74.83,150.97
+5VSB on BOTTOM (solid shape): 67.69,155.38 67.69,153.74 68.76,152.67 68.76,152.34 68.35,151.93 68.76,151.53 68.76,148.91 68.22,148.38 67.32,148.38 65.59,150.1 65.59,151.43 64.2,152.82 64.2,153.05 63.22,154.03 63.22,155.79 63.47,156.04 67.02,156.04
+5VSB on BOTTOM (solid shape): outline of 427 points within 62.6,12.44 107.08,33.69
+5VSB on IN1 (solid shape): 41.43,161.86 41.43,160.98 40.74,160.29 40.74,159.12 40.64,159.02 40.28,159.02 39.93,159.37 39.93,161.89 40.18,162.14 41.15,162.14
+5VSB on IN1 (solid shape): 105,16.73 105,13.2 104.37,12.56 102.21,12.56 100.67,14.1 100.49,14.1 99.46,15.13 99.46,17.34 99.67,17.54 104.19,17.54
+5VSB on IN1 (solid shape): 115.44,26.63 115.44,25.72 114.64,24.91 114.26,24.91 113.65,25.52 113.65,25.55 114.03,25.93 114.03,26.59 114.25,26.81 115.26,26.81
+5VSB on IN1 (solid shape): 75.31,149.7 75.31,149.1 75.3,149.1 75.06,148.86 72.39,148.86 72.16,149.09 72.16,149.85 72.45,150.14 74.87,150.14
+5VSB on IN1 (solid shape): 2.28,134.97 5.08,134.97 5.56,134.48 5.56,132.1 5.43,131.97 4.32,131.97 4.08,131.73 1.29,131.73 1.29,134.61 1.31,134.62 1.31,135.05 1.5,135.24 2,135.24
+5VSB on IN1 (solid shape): 77.33,23.64 77.52,23.64 78.14,23.01 84.42,23.01 85.29,22.14 89.86,22.14 90.47,21.53 90.47,17.03 89.71,16.27 87.48,16.27 86.3,17.45 86.3,18.56 85.75,19.12 82.04,19.12 81.95,19.17 81.96,19.28 81.9,19.83 81.35,19.82 81.32,19.8 81.28,19.82 80.73,19.83 80.67,19.28 80.68,19.17 80.59,19.12 79.81,19.12 78.84,20.08 76.11,20.08 76,20.2 75.99,20.21 75.71,20.45 75.34,20.36 73.18,20.36 72.97,20.57 72.97,23.4 73.23,23.65 77.31,23.65
+5VSB on IN1 (solid shape): outline of 160 points within 44.35,27.8 63.9,38.53
+5VSB on IN1 (solid shape): outline of 647 points within 2.69,33.07 26.85,52.34
+5VSB on IN1 (solid shape): outline of 1296 points within 7.52,138.39 66.06,156.05
+5VSB on IN2 (solid shape): 116.7,28.65 116.7,27.61 115.41,26.32 115.41,26.32 115.3,26.21 114.43,26.21 114.13,26.51 114.13,27.35 115.55,28.78 116.57,28.78
+5VSB on IN2 (solid shape): 143.82,33.73 143.82,33.04 143.7,32.92 142.66,32.92 141.92,33.65 141.92,33.8 142.66,34.54 143.01,34.54
+5VSB on IN2 (solid shape): 2.59,134.97 5.08,134.97 5.56,134.48 5.56,132.1 4.21,130.75 4.21,127.13 3.92,126.84 1.49,126.84 1.22,127.11 1.22,134.81 1.22,134.81 1.22,135.14 1.34,135.27 2.28,135.27
+5VSB on IN2 (solid shape): 48.57,35.4 59.93,35.4 63.65,35.4 66.3,32.74 66.3,30.16 66.47,29.99 66.47,29.92 67.97,28.42 67.97,26.95 67.38,26.36 63.5,26.36 60.25,29.61 49.72,29.61 46.18,33.15 43.42,33.15 42.92,33.64 42.92,36.34 43.33,36.74 47.23,36.74
+5VSB on IN2 (solid shape): 5.46,25.89 5.16,25.55 5.35,25.14 5.46,24.92 5.66,24.78 5.7,24.77 5.7,23.98 5.69,23.97 4.38,23.97 4.17,24.17 4.17,25.65 4.43,25.9 5.44,25.9
+5VSB on IN2 (solid shape): outline of 100 points within 1.25,107.11 5.24,114.3
+5VSB on IN2 (solid shape): outline of 100 points within 66.76,148.34 75.63,151.73
+5VSB on IN2 (solid shape): outline of 1309 points within 10.37,138.42 66.06,161.97
+5VSB on IN2 (solid shape): outline of 1383 points within 1.22,33.14 26.64,96.05
+5VSB on VCC (solid shape): 64.49,32.55 64.49,30.19 64.5,30.14 64.53,30.1 64.75,29.87 64.8,29.84 64.84,29.83 90.88,29.83 91.72,28.99 91.72,24.48 91.45,24.21 91.42,24.17 91.41,24.12 91.41,17.06 90.47,16.12 87.5,16.12 84.2,19.42 84.2,19.98 84.19,20.03 84.16,20.07 82.61,21.62 82.57,21.65 82.52,21.66 68.48,21.66 68.43,21.65 68.39,21.62 67.92,21.15 65.38,21.15 65.33,21.14 65.29,21.11 65,20.82 63.27,20.82 60.64,23.45 60.6,23.48 60.55,23.48 54.33,23.48 47.23,30.59 47.19,30.61 47.14,30.62 44.2,30.62 43.43,31.39 43.43,37.33 43.69,37.58 59.46,37.58
+5VSB on VCC (solid shape): outline of 174 points within 1.24,46.57 5.56,134.99
+5VSB_BST on BOTTOM (solid shape): 108.94,27.87 108.94,26.22 109.39,25.77 109.39,24.59 109.31,24.51 108.23,24.51 108.03,24.71 108.03,26.1 108.74,26.82 108.74,27.85 108.78,27.89 108.91,27.89
+5VSB_BST_RC on BOTTOM (solid shape): 109.52,23.26 109.52,22.6 109.24,22.32 107.73,22.32 107.29,22.76 106.93,22.76 106.77,22.92 106.77,23.27 106.95,23.45 107.06,23.45 109.33,23.45
+5VSB_HG on TOP (solid shape): 133.89,20.55 133.89,18.7 134.2,18.39 134.2,17.73 134.14,17.67 132.79,17.67 132.56,17.9 132.56,20.28 132.03,20.82 132.03,21.35 132.28,21.61 132.84,21.61
+5VSB_HG on BOTTOM (solid shape): 109.35,27.78 109.35,27.3 111.44,25.22 111.44,24.51 109.81,24.51 109.73,24.6 109.73,25.76 109.14,26.35 109.14,27.82 109.19,27.87 109.27,27.87
+5VSB_HG_R on TOP (solid shape): 134.28,15.91 133.41,15.04 131.26,15.04 131.19,14.98 131.19,14.32 130.55,13.68 129.89,13.68 129.82,13.76 129.82,15.53 130.13,15.85 132.46,15.85 132.83,16.22 132.83,16.58 134.28,16.58
+5VSB_LG on BOTTOM (solid shape): 110.12,28.16 110.12,28.06 111.9,26.29 112.46,26.29 113.42,25.32 113.42,24.56 113.37,24.51 112.52,24.51 109.59,27.44 109.59,28.17 109.65,28.23 110.04,28.23
+5VSB_LG_R_D on TOP (solid shape): 131.37,10.53 131.37,9.91 131.92,9.36 133.09,9.36 133.27,9.17 133.27,8.56 132.24,7.53 130.84,7.53 130.74,7.62 130.74,9.05 130.61,9.18 130.61,10.02 129.82,10.81 129.82,11.29 129.87,11.34 130.55,11.34
+5VSB_PHASE on TOP (solid shape): 126.8,14.62 126.8,12.99 127.15,12.64 130.56,12.64 131.01,13.09 131.03,13.09 131.85,13.9 131.85,14.66 131.95,14.76 133.37,14.76 133.37,14.07 130.85,11.55 127.61,11.55 126.52,10.45 121.52,10.45 121.23,10.73 121.23,14.23 121.87,14.86 126.55,14.86
+5VSB_PHASE on BOTTOM (solid shape): 125.5,14.59 126.82,14.59 127.02,14.39 127.02,11.14 126.87,10.99 122.93,10.99 122.55,10.61 121.79,10.61 121.61,10.78 121.61,14.7 121.87,14.95 125.14,14.95
+5VSB_PHASE on BOTTOM (solid shape): 108.54,27.81 108.54,26.91 107.62,25.99 107.62,24.35 107.63,24.35 107.63,24.03 107.56,23.95 107.05,23.95 106.74,23.95 106.3,23.52 106,23.52 105.83,23.7 105.83,24.25 106.04,24.46 106.05,24.47 106.35,24.62 106.5,24.92 106.51,24.93 107.03,25.46 107.03,25.99 108.09,27.05 108.23,27.05 108.34,27.15 108.34,27.85 108.37,27.89 108.46,27.89
+5VSB_SN_C on BOTTOM (solid shape): 127.32,9.85 127.32,9.26 127.3,9.24 127.03,9.24 127.02,9.24 126.92,9.24 126.67,9.49 123.52,9.49 123.32,9.69 123.32,10.68 123.34,10.71 126.47,10.71
+5VSB_VO1 on BOTTOM (solid shape): 111.47,27.89 114.01,27.89 114.04,27.85 114.04,27.04 113.99,26.99 113.44,26.99 113.23,27.2 111.4,27.2 110.14,28.46 109.54,28.46 109.49,28.5 109.49,28.58 109.55,28.65 110.71,28.65
+19V_VIN on TOP (solid shape): 163.68,163.41 163.77,163.37 163.77,163.26 163.72,163.12 163.7,162.97 163.7,162.36 164.03,161.82 164.78,161.88 164.83,161.79 164.83,160.84 164.95,160.72 166.59,160.72 166.7,160.61 166.7,159.32 166.89,159.12 168.66,159.12 168.72,159.06 168.72,158.37 168.65,158.31 167.41,158.31 167.36,158.26 167.36,158.24 167.33,158.22 161.31,158.22 161.05,158.59 160.76,158.95 159.94,159.77 159.94,161.74 159.99,161.83 160.7,161.84 161,162.36 161,162.97 160.98,163.12 160.93,163.26 160.93,163.36 161.02,163.41 161.26,163.41 161.34,163.37 161.35,163.28 161.32,163.13 161.31,162.98 161.31,162.36 162.35,161.32 163.39,162.36 163.39,162.97 163.38,163.13 163.34,163.28 163.36,163.37 163.44,163.41
+19V_VIN on BOTTOM (solid shape): outline of 219 points within 159.05,157.37 167.49,164.3
+19VA on TOP (solid shape): 168.78,155.54 168.78,148.17 168.48,147.87 166.59,147.87 166.11,147.39 166.11,146.52 165.91,146.32 164.01,146.32 163.93,146.4 163.93,150.31 166.11,152.49 166.11,155.54 166.27,155.69 168.63,155.69
+19VA on BOTTOM (solid shape): 168.78,151.83 168.78,148.53 168.5,148.25 166.27,148.25 166.06,148.45 166.06,151.93 166.22,152.09 168.53,152.09
+19VA_IN on TOP (solid shape): 167.51,157.37 167.51,156.43 167.33,156.25 165.81,156.25 165.56,156 165.56,153.56 165.43,153.43 162.41,153.43 162.23,153.61 162.23,157.47 162.28,157.53 167.35,157.53
+19VA_IN on BOTTOM (solid shape): 167.84,156.28 168.63,156.28 168.78,156.12 168.78,154.22 168.68,154.12 163.07,154.12 162.81,154.37 162.81,156.53 163.07,156.78 167.33,156.78
+19VA_IN_R_C on BOTTOM (solid shape): 168.78,153.38 168.78,152.72 168.68,152.62 165.78,152.62 165.53,152.36 165.53,151.04 165.48,150.99 164.26,150.99 164.13,151.12 164.13,153.36 164.26,153.48 168.68,153.48
+V3P3A_V1P8A_VCCPGPPD on BOTTOM (solid shape): 45.86,94.05 45.86,92.79 45.8,92.73 45.35,92.73 44.96,93.12 44.96,93.87 45.26,94.17 45.74,94.17
+VCCAMPHYPLL_1P05 on TOP (solid shape): 60.86,80.69 60.86,80.15 60.63,79.92 60.27,79.92 59.61,80.58 59.61,80.66 59.71,80.76 60.78,80.76
+VCCAMPHYPLL_1P05 on BOTTOM (solid shape): 62.94,79.98 62.94,79.49 63.34,79.09 63.34,78.91 63.24,78.81 62.55,78.81 62.53,78.84 62.53,80 62.59,80.06 62.85,80.06
+VCCDPHY_1P24V on TOP (solid shape): 48.16,94.12 48.16,93.03 47.87,92.74 47.77,92.69 47.69,92.6 47.44,92.6 47.37,92.68 47.28,92.74 47.01,93 47.01,93.51 46.81,93.72 46.81,94.15 46.89,94.22 48.06,94.22
+VCCDPHY_1P24V on IN1 (solid shape): outline of 241 points within 41.2,100.45 43.97,103.52
+VCCGT on TOP (solid shape): outline of 2758 points within 127.97,109.18 168.68,149.11
+VCCGT on BOTTOM (solid shape): outline of 2354 points within 127.47,102.54 167.04,140.86
+VCCGT on IN1 (solid shape): outline of 2813 points within 128.61,109.12 156.81,140.72
+VCCGT on IN2 (solid shape): outline of 2108 points within 128.09,108.9 152.4,124.58
+VCCIO_LDRV_C on TOP (solid shape): 79.97,106.22 79.97,106.19 79.99,105.95 80.14,105.76 80.11,105.65 80.11,105.54 80.19,105.23 80.46,105.07 80.48,105.07 80.52,105.03 81.19,105.03 81.25,104.97 81.25,104.26 80.58,104.26 80.58,103.52 80.41,103.52 79.45,104.49 79.45,105.65 79.17,105.93 78.87,105.93 78.74,106.06 78.74,106.26 78.84,106.37 79.83,106.37
+VCCIO_LDVR on TOP (solid shape): 82.42,105.91 82.42,104.69 82.29,104.56 81.68,104.56 81.61,104.64 81.61,105.04 81.82,105.26 81.86,105.26 81.86,105.91 81.94,105.98 82.35,105.98
+VCCPDSW_3P3V on TOP (solid shape): 35.87,77.51 35.87,77.21 35.74,77.08 35.39,76.64 35.8,76.27 35.84,76.27 35.87,76.27 35.95,76.25 35.99,76.17 35.99,74.66 34.75,73.42 33.71,73.42 33.44,73.14 32.98,73.14 32.83,73.32 32.6,73.38 32.39,73.32 32.25,73.16 32.05,73.16 30.92,72.03 30.92,71.81 31.2,71.53 31.2,70.26 31.18,70.24 31.18,70.22 30.43,69.47 30.43,68.67 30.2,68.44 29.44,68.44 29.18,68.7 29.18,69.6 30.03,70.45 30.29,70.45 30.29,71.26 30.14,71.41 30.14,72.7 30.36,72.93 30.5,72.93 30.93,72.93 31.53,73.53 31.53,73.55 31.86,73.88 31.88,73.88 32,73.9 32.1,73.96 32.18,73.98 32.25,73.93 32.67,73.72 33.01,74.05 33.02,74.06 33.34,74.38 33.4,74.41 33.48,74.38 33.94,74.32 34.16,74.74 34.15,74.77 34.23,74.85 34.62,74.85 34.77,75 34.81,75 34.81,75.5 34.82,75.51 34.82,77.32 35.11,77.61 35.76,77.61
+VCCPHVLDO_1P8V on BOTTOM (solid shape): 49.05,95.35 49.11,95.36 49.16,95.35 49.19,95.34 49.4,95.34 49.4,94.93 49.48,94.85 49.48,94.16 49.49,94.16 49.49,93.92 49.43,93.86 49.43,93.46 49.31,93.35 48.7,93.35 48.41,93.06 47.98,93.06 47.75,93.29 47.75,93.72 47.78,93.75 47.78,94.81 47.81,94.83 47.83,94.85 48.08,94.85 48.51,94.8 48.74,95.17 48.74,95.34 49.02,95.34
+VCCPRIM_1P05 on TOP (solid shape): 61.87,104.87 61.87,104.66 61.26,104.05 61.26,103.6 61.29,103.57 61.28,103.41 61.29,103.35 61.29,103.09 61.16,102.96 61.11,102.96 60.88,103.19 60.89,103.31 60.88,103.44 60.83,103.49 60.8,103.53 60.77,103.55 60.68,103.65 60.48,103.65 60.43,103.7 60.43,103.75 60.3,103.88 59.94,103.88 59.74,104.08 59.64,104.25 59.64,104.51 60.17,105.04 61.7,105.04
+VCCPRIM_1P05 on TOP (solid shape): 64.59,96.5 66.13,96.5 68.68,93.94 68.68,91.18 68.55,91.05 68.3,91.05 68.07,90.82 68.07,85.66 67.97,85.56 67.44,85.56 67.38,85.51 67.38,84.01 67.31,83.94 66.65,83.94 66.64,83.95 66.08,83.95 65.73,84.29 65.73,84.65 65.74,84.66 65.76,84.83 65.74,85 65.73,85.01 65.73,86.42 65.77,86.49 65.84,86.52 66.26,86.86 65.97,87.32 65.9,87.39 65.93,87.49 65.96,87.52 65.96,87.98 66,87.99 66.31,88.38 66,88.78 65.96,88.79 65.96,89.9 66.01,89.91 66.37,90.31 66.01,90.72 65.96,90.72 65.96,90.76 65.91,90.81 63.48,90.81 63.09,91.2 62.58,91.2 62.23,91.56 62.23,92.29 62.38,92.45 62.61,92.45 63.65,93.49 63.65,94.1 62.94,94.81 62.61,94.81 62,95.42 62,96.51 62.01,96.52 62.01,97.16 62.28,97.42 63.66,97.42
+VCCPRIM_1P05 on TOP (solid shape): outline of 560 points within 48.54,87.75 54.53,95.74
+VCCPRIM_1P05 on BOTTOM (solid shape): outline of 2378 points within 49.39,88.99 66.8,105.65
+VCCPRIM_1P05 on IN2 (solid shape): outline of 1959 points within 48.87,85.99 68.44,96.59
+VCCPRIM_1P8_3P3 on TOP (solid shape): 49.93,87.65 50.6,87.65 50.75,87.8 50.95,87.8 51.05,87.7 51.05,87.62 50.85,87.31 50.98,86.97 51.01,86.9 50.98,86.82 50.94,86.78 50.9,86.73 49.31,86.73 49.13,86.92 48.86,86.95 48.85,86.95 48.64,87.16 48.64,87.67 48.77,87.8 49.78,87.8
+VCCPRIM_1P8_3P3 on BOTTOM (solid shape): 49.5,87.65 50.49,87.65 50.6,87.54 50.6,87.09 50.49,86.98 48.03,86.98 47.98,87.04 47.98,87.52 47.88,87.62 47.88,88.38 48.06,88.56 48.59,88.56
+VCCPRIM_1P8_3P3 on IN2 (solid shape): outline of 271 points within 44.57,86.78 50.77,93.32
+VCCPRIM_1P8V on BOTTOM (solid shape): 42.21,99.32 43.36,99.32 43.46,99.21 43.93,99.21 44.38,98.76 44.54,98.76 45.09,98.2 45.29,98.04 45.55,98.02 45.7,98.11 45.81,98.25 45.97,98.41 47.02,98.41 47.3,98.13 47.3,98.12 47.39,98 47.51,97.92 47.52,97.91 47.62,97.81 47.62,96.92 47.75,96.79 48.31,96.79 48.41,96.69 48.41,96.23 47.84,96.23 47.8,96.27 47.75,96.3 47.72,96.32 47.47,96.35 47.25,96.23 46.96,95.94 46.96,93.54 47.17,93.33 47.17,92.95 47.04,92.83 46.55,92.83 46.41,92.87 46.26,92.87 46.23,92.86 46.12,92.97 46.12,93.96 46.07,94.02 46.07,94.14 45.83,94.38 45.01,94.38 44.93,94.45 44.93,94.83 44.98,94.88 45.2,94.88 45.2,94.88 45.73,94.88 45.97,95.13 45.99,95.14 45.99,96.36 45.9,96.45 45.9,96.47 45.74,96.76 45.42,96.83 45.39,96.83 45.21,97.02 45.05,97.43 44.62,97.54 44.53,97.53 44.45,97.51 44.21,97.75 43.08,97.75 42.98,97.85 42.98,98.86 42.87,98.97 41.96,98.97 41.76,99.18 41.76,99.68 41.91,99.83 42.06,99.82 42.21,99.85
+VCCSA on TOP (solid shape): outline of 248 points within 108.84,109.79 114.23,119.51
+VCCSA on TOP (solid shape): outline of 366 points within 41.68,109.51 66.2,123.97
+VCCSA on BOTTOM (solid shape): outline of 479 points within 99.26,109.2 112.62,116.18
+VCCSA on IN2 (solid shape): outline of 3709 points within 63.66,100.62 111.3,121.34
+VCCSA_HG_D on TOP (solid shape): 33.65,121.53 33.65,119.32 33.55,119.22 33.07,119.22 32.89,119.4 32.89,121.45 33.07,121.63 33.55,121.63
+VCCSA_HG_R_D on TOP (solid shape): 35.29,120.54 35.29,118.28 35.2,118.2 33.82,118.2 33.72,118.3 32.85,118.3 32.84,118.31 32.84,118.81 32.9,118.88 34.3,118.88 34.56,119.14 34.56,120.55 34.6,120.6 35.23,120.6
+VCCSA_LG_D on TOP (solid shape): 31.34,113.1 31.77,113.1 31.88,112.99 31.88,111.78 31.77,111.67 31.22,111.67 31.14,111.75 31.14,112.23 30.68,112.69 30.53,112.69 30.3,112.92 30.3,113.48 30.43,113.6 30.83,113.6
+VCCSA_LG_R_D on TOP (solid shape): 33.63,115.5 33.63,114.26 34.14,113.76 34.14,111.78 34.06,111.7 33.09,111.7 33.02,111.78 33.02,112.23 33.19,112.56 33.02,112.9 33.02,113.01 32.81,113.22 32.81,115.92 32.84,115.96 33.17,115.96
+VCCSA_PHASE_D on TOP (solid shape): 38.64,117.77 38.64,116.38 39.51,115.5 39.51,114.39 39,113.88 36.37,113.88 34.52,115.74 34.06,115.74 33.61,116.19 30.71,116.19 30.07,116.83 30.07,117.08 30.22,117.24 30.68,117.24 30.73,117.19 30.75,117.19 33.25,117.19 33.82,117.76 35.11,117.76 35.13,117.77 35.4,117.77 35.83,118.2 38.21,118.2
+VCCSA_PHASE_D on BOTTOM (solid shape): 31.8,118.3 31.8,118.05 31.78,118.02 31.78,116.37 31.04,115.64 30.55,115.64 30.55,116.32 30.1,116.78 30.1,117.97 30.51,118.38 31.72,118.38
+VCCSA_SN on BOTTOM (solid shape): 28.83,119.42 28.83,115.94 28.68,115.79 27.99,115.79 27.68,116.09 27.68,119.09 27.35,119.42 27.35,120.36 27.51,120.51 27.74,120.51
+VCCSA_VIN on TOP (solid shape): 27.15,118.48 28.42,118.48 28.68,118.74 32.55,118.74 32.55,118.12 32.58,118.09 33.25,118.09 33.29,118.05 33.29,117.54 33.26,117.51 30.33,117.51 30.26,117.44 25.12,117.44 25.02,117.54 25.02,118.07 25.09,118.15 26.49,118.15 26.54,118.2 26.54,118.58 26.7,118.74 26.89,118.74
+VCCST on BOTTOM (solid shape): 97.19,121.86 97.19,119.48 97.05,119.34 96.49,119.34 96.3,119.53 96.3,120.97 95.6,121.66 95.6,122.19 95.73,122.32 96.74,122.32
+VCCST on BOTTOM (solid shape): 73.15,103.14 73.15,101.72 72.97,101.54 72.16,101.54 72.03,101.67 72.03,102 71.98,102.05 70.59,102.05 70.25,102.38 70.25,102.94 70.64,103.32 72.97,103.32
+VCCST on BOTTOM (solid shape): outline of 250 points within 101.75,114.85 108.8,121.55
+VCCST on IN1 (solid shape): 97.23,122.27 97.23,121.35 97.05,121.17 96.16,121.17 95.63,121.71 95.63,122.34 95.78,122.49 97,122.49
+VCCST on IN2 (solid shape): 73.23,101.97 73.23,100.88 73.1,100.75 72.16,100.75 72.01,100.9 72.01,101.95 72.13,102.07 73.13,102.07
AVDD1 on TOP (solid shape): 8.99,16.12 8.99,15.18 8.91,15.1 8.25,15.1 7.69,15.66 7.69,16.3 7.75,16.36 8.76,16.36
AVDD1 on TOP (solid shape): 15.56,18.2 15.56,17.48 15.42,17.33 15.42,17.29 15.24,17.11 15.24,16.14 15.02,15.92 14,15.92 13.93,15.99 13.93,16.41 14.22,16.69 14.28,16.75 14.33,16.81 14.37,16.85 14.37,16.89 14.4,17 14.39,17.1 14.55,17.26 14.69,17.26 14.94,17.51 14.94,18.16 15.03,18.24 15.52,18.24
AVDD1 on BOTTOM (solid shape): 11.2,16.63 11.84,16.63 11.85,16.62 12.08,16.61 12.28,16.73 14.65,16.73 15.02,16.36 15.02,15.63 14.81,15.41 13.85,15.41 13.74,15.31 8.66,15.31 8.51,15.46 8.51,16.32 8.91,16.73 11.1,16.73
AVDD2 on TOP (solid shape): 25.09,21.2 25.09,20.36 25.12,20.34 25.12,19.88 25.09,19.85 24.36,19.85 24.33,19.88 24.33,21.22 24.36,21.25 25.04,21.25
DVDD on TOP (solid shape): 22.01,28.34 22.01,27.86 21.7,27.56 21.04,27.56 20.8,27.32 20.8,26.42 20.52,26.14 20.52,25.36 20.19,25.03 20.19,24.41 20.18,24.4 20,24.4 19.99,24.4 19.99,25.04 19.83,25.19 19.83,25.52 19.92,25.83 19.76,26.11 19.76,27.7 20.41,28.35 21.09,28.35 21.19,28.44 21.9,28.44
GND on TOP (solid shape): 31.3,19.87 31.3,18.92 30.25,18.92 30.19,18.98 30.19,19.31 30.83,19.95 31.22,19.95
GND on TOP (solid shape): 100.81,20.18 100.81,19.55 97.51,19.55 97.13,19.93 97.13,20.82 97.51,21.2 99.8,21.2
GND on TOP (solid shape): 5.81,106.63 5.81,106.02 5.02,105.22 4.52,105.22 4.44,105.3 4.44,106.64 4.55,106.74 5.69,106.74
GND on TOP (solid shape): 23.87,117.01 23.87,113.73 23.77,113.63 22.71,113.63 22.66,113.68 22.66,117.11 22.91,117.36 23.52,117.36
GND on TOP (solid shape): 43.1,164.38 43.1,162.8 42.7,162.4 41.81,162.4 41.3,162.91 41.3,164.4 41.38,164.48 43,164.48
GND on TOP (solid shape): 46.25,120.72 46.25,120.06 46.18,119.98 44.65,119.98 44.55,120.08 44.55,120.51 44.78,120.74 46.23,120.74
GND on TOP (solid shape): 58.06,134.23 58.06,132.53 57.3,131.77 56.31,131.77 55.09,132.98 55.09,134.18 55.24,134.33 57.96,134.33
GND on TOP (solid shape): 68.11,83.45 68.11,82.32 67.92,82.13 66.67,82.13 66.57,82.24 66.57,83.48 66.67,83.58 67.97,83.58
GND on TOP (solid shape): 76.66,41.49 76.66,40.63 76.55,40.53 74.98,40.53 74.93,40.58 74.93,41.32 75.28,41.67 76.48,41.67
GND on TOP (solid shape): 81.91,153.69 81.91,153.08 81.61,152.77 79.32,152.77 79.07,153.02 79.07,153.76 79.32,154.02 81.58,154.02
GND on TOP (solid shape): 81.91,140.32 81.91,139.56 81.63,139.28 78.41,139.28 78.1,139.59 78.1,140.38 78.23,140.5 81.74,140.5
GND on TOP (solid shape): 89.28,142.08 89.28,141.71 89.1,141.53 86.86,141.53 86.71,141.68 86.71,142.28 86.76,142.32 89.03,142.32
GND on TOP (solid shape): 92.39,42.9 92.39,38.64 91.54,37.79 89.9,37.79 89.09,38.6 89.09,42.87 89.21,43 92.29,43
GND on TOP (solid shape): 118.78,107.63 118.78,105.85 118.66,105.72 118.02,105.72 117.9,105.85 117.9,107.63 118.02,107.75 118.66,107.75
GND on TOP (solid shape): 123.14,142.38 123.14,141.49 123.01,141.37 121.64,141.37 121.56,141.44 121.56,141.8 122.25,142.48 123.04,142.48
GND on TOP (solid shape): 137.53,171.62 137.53,168.75 137.4,168.62 136.61,168.62 136.38,168.85 136.38,171.62 136.43,171.67 137.48,171.67
GND on TOP (solid shape): 144.85,153.13 140.41,153.13 140.36,153.18 140.36,154.85 140.45,154.94 144.85,154.94
GND on TOP (solid shape): 151.97,171.62 151.97,168.75 151.84,168.62 151.05,168.62 150.82,168.85 150.82,171.62 150.87,171.67 151.92,171.67
GND on TOP (solid shape): 163.68,152.11 163.68,150.82 163.6,150.74 162.53,150.74 162.51,150.76 162.51,152.19 162.53,152.21 163.57,152.21
GND on TOP (solid shape): 168.53,82.06 168.53,80.03 168.3,79.8 166.95,79.8 166.8,79.95 166.8,82.16 166.95,82.31 168.27,82.31
GND on TOP (solid shape): 67.97,32.3 67.97,29.53 67.31,28.87 65.48,28.87 65.2,29.15 65.2,32.55 65.3,32.65 67.61,32.65
GND on TOP (solid shape): 91.17,142.85 91.17,142.33 90.55,141.71 89.68,141.71 89.58,141.8 89.58,142.12 90.41,142.95 91.08,142.95
GND on TOP (solid shape): 3.12,116.19 3.12,113.73 3.07,113.68 0.76,113.68 0.56,113.88 0.56,115.76 0.79,115.99 0.81,115.99 1.14,116.32 3,116.32
GND on TOP (solid shape): 8.74,14.21 8.74,13.99 8.61,13.86 7.52,13.86 7.44,13.93 7.44,14.85 7.49,14.9 8.05,14.9
GND on TOP (solid shape): 31.67,48.25 31.67,46.7 31.42,46.45 30.07,46.45 29.95,46.57 29.95,48.22 30.02,48.3 31.62,48.3
GND on TOP (solid shape): 48.36,9.31 48.36,8.7 48.31,8.65 46.79,8.65 46.68,8.75 46.68,9.36 46.71,9.39 48.28,9.39
GND on TOP (solid shape): 117.45,20.11 117.45,19.42 117.19,19.17 115.68,19.17 114.15,20.69 114.15,21.36 114.3,21.5 116.05,21.5
GND on TOP (solid shape): 123.23,106.86 123.23,105.72 123.1,105.59 121.9,105.59 121.71,105.78 121.71,106.8 121.9,106.99 123.1,106.99
GND on TOP (solid shape): 130.68,171.59 130.68,167.68 130.4,167.4 129.89,167.4 129.65,167.64 129.65,171.57 129.7,171.62 130.66,171.62
GND on TOP (solid shape): 160.78,73.55 160.78,72.3 161.34,71.74 161.34,71.47 161.06,71.19 160.5,71.19 159.56,72.13 159.56,73.42 159.76,73.62 160.7,73.62
GND on TOP (solid shape): 161.3,42.94 161.3,40.18 160.15,39.03 157.5,39.03 157.47,39.06 157.06,39.06 156.73,39.39 156.73,43 157.13,43.41 160.84,43.41
GND on TOP (solid shape): 162.1,144.39 162.1,143.93 161.95,143.78 159.41,143.78 159.26,143.93 159.26,144.36 159.41,144.52 161.97,144.52
GND on TOP (solid shape): 168.76,147.34 168.76,143.04 168.55,142.84 166.52,142.84 166.32,143.04 166.32,147.31 166.67,147.67 168.43,147.67
GND on TOP (solid shape): 32,52.76 32,52.44 31.65,52.09 31.65,51.81 31.6,51.76 31.11,51.76 30.99,51.88 30.99,52.34 31.55,52.9 31.86,52.9
GND on TOP (solid shape): 78.21,66.89 78.21,66.64 78.1,66.54 77.81,66.54 77.74,66.61 77.74,66.69 77.39,66.69 77.06,67.02 77.06,67.5 77.11,67.55 77.54,67.55
GND on TOP (solid shape): 135.33,14.74 135.33,13.61 135.25,13.52 133.81,13.52 133.69,13.64 133.69,15 135.07,15
GND on TOP (solid shape): 54.86,60.29 54.86,57.85 54.76,57.75 53.54,57.75 53.08,58.21 53.08,58.59 53.14,58.64 53.54,58.64 53.67,58.77 53.67,60.31 53.74,60.39 54.76,60.39
GND on TOP (solid shape): 59.84,152.34 59.84,151.73 59.61,151.5 58.95,151.5 58.11,152.34 55.75,152.34 55.12,151.7 54.99,151.7 54.79,151.91 54.79,153.25 55.35,153.81 58.37,153.81
GND on TOP (solid shape): 61.72,169.56 61.72,168.44 62,168.16 62,167.93 61.87,167.81 61.03,167.81 60.91,167.93 60.91,168.11 61.26,168.47 61.26,169.56 61.34,169.64 61.64,169.64
GND on TOP (solid shape): 83.45,97.46 84,97.46 84.57,96.89 84.57,95.86 84.48,95.77 83.51,95.77 82.88,96.41 80.85,96.41 80.69,96.56 80.69,97.42 80.9,97.63 83.29,97.63
GND on TOP (solid shape): 85.08,68.05 85.08,67.63 85.07,67.62 85.07,64.89 84.91,64.73 84.45,64.73 84.33,64.86 84.33,68.06 84.43,68.16 84.96,68.16
GND on TOP (solid shape): 111.23,162.09 111.96,162.09 112.09,161.97 112.09,161.74 111.73,161.38 109.85,161.38 109.52,161.71 109.52,162.83 109.65,162.96 110.36,162.96
GND on TOP (solid shape): 120.05,117.91 120.05,111.3 119.24,110.49 118.47,110.49 118.35,110.61 118.35,117.98 118.66,118.29 119.67,118.29
GND on TOP (solid shape): 126.45,20.03 126.45,15.37 126.33,15.25 125.42,15.25 125.32,15.34 125.32,17.58 125.12,17.79 124.61,17.79 124.53,17.87 124.53,20.07 124.89,20.43 126.05,20.43
GND on TOP (solid shape): 138.53,19.63 138.53,15.22 138.1,14.79 136.37,14.79 136.37,16.53 136.19,16.7 136.19,19.14 136.83,19.78 138.39,19.78
GND on TOP (solid shape): 47.45,10.18 48.31,10.18 48.39,10.1 48.39,9.64 48.33,9.59 46.76,9.59 46.68,9.67 46.68,10.25 46.73,10.3 47.32,10.3
GND on TOP (solid shape): 51.15,120.51 51.15,120.18 51.66,119.67 51.66,118.71 51.65,118.7 51.65,118.11 51.03,117.49 49.05,117.49 49,117.54 49,120.56 49.05,120.61 51.05,120.61
GND on TOP (solid shape): 71.8,20.6 71.8,18.58 71.73,18.51 71.73,16.78 71.68,16.73 70.92,16.73 70.53,17.11 70.53,19.37 70.63,19.47 70.63,20.34 70.99,20.7 71.71,20.7
GND on TOP (solid shape): 75.31,19.65 76.3,19.65 76.4,19.55 76.4,17.64 75.67,16.91 74.19,16.91 74.12,16.98 74.12,19.5 74.6,19.98 74.98,19.98
GND on TOP (solid shape): 129.6,9.79 130.45,8.94 130.45,7.74 130.35,7.64 125.45,7.64 125.27,7.81 125.27,9.18 125.73,9.64 127.05,9.64 127.4,10 127.4,10.96 127.79,11.34 129.6,11.34
GND on TOP (solid shape): 164.33,53.74 164.33,49.76 164.33,49.75 164.33,49.54 164.06,49.27 163.17,49.27 161.31,51.13 161.31,54.78 161.48,54.94 163.13,54.94
GND on TOP (solid shape): 163.77,125.09 163.57,124.89 163.45,124.89 163.3,124.74 163.3,122.74 163.13,122.57 162.66,122.57 162.52,122.71 162.52,124.51 163.27,125.25 163.27,125.27 163.34,125.34 163.77,125.34
GND on TOP (solid shape): 34.21,60.21 34.21,57.88 34.47,57.62 34.47,56.73 34.38,56.64 34.31,56.64 34.2,56.53 33.88,56.53 33.45,56.96 33.45,57.32 33.02,57.75 33.02,60.21 33.15,60.34 34.09,60.34
GND on TOP (solid shape): 47.12,17.26 47.12,16.47 46.74,16.09 46.74,15.76 46.62,15.64 46.38,15.64 46.22,15.79 46.22,16.25 46.02,16.45 46.02,17.24 46.15,17.36 47.01,17.36
GND on TOP (solid shape): 59.16,119.88 59.16,119.5 59.03,119.37 58.65,119.37 58.52,119.24 58.52,117.59 58.39,117.46 56.55,117.46 55.73,118.29 55.73,120 56.36,120.64 58.39,120.64
GND on TOP (solid shape): 60.35,151.2 60.35,149.27 59.42,148.34 59.42,147.63 58.8,147.01 57.96,147.01 57.68,147.28 57.68,148.1 57.67,148.11 57.67,148.19 57.1,148.76 57.1,150.64 57.72,151.26 60.29,151.26
GND on TOP (solid shape): 60.21,140.44 60.21,139.78 60.08,139.65 60.07,139.65 59.43,139.01 59.43,136.54 59.21,136.31 58.06,136.31 57.91,136.46 57.91,139.46 59.23,140.78 59.87,140.78
GND on TOP (solid shape): 92.48,58.99 92.48,58.74 92.16,58.42 91.04,58.42 90.66,58.04 90.66,56.69 89.42,55.45 85.99,55.45 85.79,55.65 85.79,58.89 91.59,58.89 91.82,59.12 92.35,59.12
GND on TOP (solid shape): 111.35,17.52 111.35,15.99 109.02,13.66 106.4,13.66 106.15,13.91 106.15,14.34 107.43,15.62 107.43,17.63 107.51,17.71 107.63,17.72 107.73,17.77 111.1,17.77
GND on TOP (solid shape): 23.16,105.81 23.61,105.81 23.68,105.73 23.68,105.39 23.62,105.32 21.94,105.32 21.91,105.36 21.91,105.72 21.97,105.78 22.5,105.78 22.71,105.98 22.99,105.98
GND on TOP (solid shape): 28.8,69.97 28.8,68.95 28.62,68.77 26.72,68.77 26.39,69.11 26.39,69.11 26.39,69.97 26.52,70.09 27.75,70.09 27.75,70.09 28.68,70.09
GND on TOP (solid shape): 77.37,27.85 77.37,27.27 77.09,26.99 76.38,26.99 75.94,26.56 75.91,26.56 75.8,26.57 75.7,26.56 75.51,26.56 75.44,26.63 75.44,28.03 75.51,28.11 77.11,28.11
GND on TOP (solid shape): 135.48,154.52 135.48,153.02 135.47,153.01 135.47,152.63 135.21,152.37 135.2,152.37 135.02,152.19 132.93,152.19 132.72,152.4 132.72,152.85 131.86,153.71 131.86,154.48 132.05,154.68 135.33,154.68
GND on TOP (solid shape): 26.63,115.77 26.63,114.5 26.77,114.37 26.77,113.3 27.74,112.33 27.74,111.57 26.92,110.76 26.92,108.27 26.52,107.86 25.93,107.86 25.88,107.91 25.88,112.23 25.53,112.59 25.53,115.71 25.63,115.81 26.59,115.81
GND on TOP (solid shape): 39.62,81.19 39.62,81.07 39.47,80.91 39.47,80.61 39.17,80.3 39.17,80 38.89,79.72 38.74,79.72 38.63,79.83 38.63,80.08 38.84,80.29 38.84,81.08 38.9,81.14 39.17,81.14 39.3,81.28 39.53,81.28
GND on TOP (solid shape): 57.31,54.73 57.35,54.72 57.4,54.73 58.14,54.73 58.27,54.6 58.27,54.4 58.01,54.14 58.01,51.88 57.58,51.45 57.12,51.45 57.02,51.55 57.02,54.5 57.25,54.73
GND on TOP (solid shape): 138.56,8.88 138.56,8.27 138.49,8.21 137.63,8.21 137.42,8 137.17,8 137.02,7.85 136.69,7.85 136.51,7.67 136,7.67 135.89,7.56 133.76,7.56 133.51,7.8 133.51,8.21 133.58,8.27 133.58,8.85 133.82,9.09 138.35,9.09
GND on TOP (solid shape): 38.97,104.43 39.17,104.38 39.36,104.43 39.46,104.33 39.46,103.98 39.6,103.85 39.6,103.14 39.22,102.76 38.93,102.76 38.43,103.27 38.3,103.27 38.2,103.37 38.2,104 38.62,104.43 38.65,104.43
GND on TOP (solid shape): 154.43,162.44 154.43,162.26 154.71,161.98 154.71,161.52 154.59,161.39 154.46,161.41 154.34,161.38 154.25,161.38 154.18,161.46 152.8,161.46 152.68,161.33 152.47,161.33 152.42,161.38 152.42,161.64 152.97,162.18 153.38,162.18 153.69,162.49 154.37,162.49
GND on TOP (solid shape): 20.97,139.75 22.45,139.75 22.52,139.68 22.52,139.28 22.39,139.15 21.36,139.15 21.11,138.9 21.11,137.23 21.28,137.05 21.28,136.49 21.16,136.36 17.85,136.36 17.25,136.97 17.25,137.45 17.32,137.53 17.7,137.53 17.96,137.78 17.96,139.08 17.19,139.84 17.19,140.17 17.25,140.22 20.49,140.22
GND on TOP (solid shape): 43.48,170.73 43.48,170.4 43.46,170.37 40.08,170.37 39.65,169.94 39.65,169.2 41.32,169.2 41.48,169.05 41.48,168.26 41.45,168.24 39.98,168.24 39.7,167.96 39.7,167.05 39.65,167.05 39.42,166.82 38.78,166.82 38.29,167.31 38.28,167.46 38.23,167.6 38.23,169.94 39.29,171.01 43.2,171.01
GND on TOP (solid shape): 156.13,165.14 156.13,163.39 155.95,163.21 155.95,162.14 156.08,162.02 156.08,161.18 155.83,160.92 155.12,160.92 154.94,161.1 154.94,162.17 154.74,162.37 154.74,162.7 154.86,162.83 154.86,164.61 155.45,164.61 155.45,163.57 155.5,163.52 155.75,163.52 155.8,163.57 155.8,164.58 155.73,164.66 155.5,164.66 155.45,164.61 154.86,164.61 154.86,165.09 155.19,165.42 155.85,165.42
GND on TOP (solid shape): 24.51,27.02 24.79,27.02 25.07,26.74 25.07,23.72 24.28,22.94 24.28,22.49 23.76,21.97 23.76,21.47 23.62,21.33 23.29,21.33 23.24,21.38 23.24,22.48 23.35,22.6 23.35,25.27 23.99,25.9 23.99,26.95 24.06,27.02 24.51,27.02
GND on TOP (solid shape): 131.11,151.83 131.11,151.53 130.68,151.09 129.09,151.09 128.6,150.59 128.6,150.08 128.28,149.76 127.14,149.76 127.14,148.7 126.96,148.52 123.71,148.52 123.53,148.33 123.53,147.51 123.35,147.34 122.67,147.34 122.08,147.93 122.08,150.06 122.96,150.94 123.56,150.94 123.88,151.27 124.28,151.27 124.37,151.36 128.22,151.36 128.57,151.71 130.36,151.71 130.57,151.92 131.02,151.92
GND on TOP (solid shape): 20.2,11.01 20.21,10.91 20.21,10.8 20.21,6.81 22.59,6.81 22.59,6.31 20.2,6.31 19.85,6.45 19.71,6.8 19.71,10.8 19.7,10.9 19.73,10.98 19.81,11.01
GND on TOP (solid shape): 21.89,27.32 21.89,25.16 21.77,25.03 21.41,25.03 21.1,24.92 20.98,24.6 20.93,24.55 20.6,24.55 20.52,24.63 20.52,25.06 20.74,25.27 20.74,25.93 21.08,26.28 21.08,26.44 21.09,26.54 21.08,26.64 21.08,27.29 21.13,27.35 21.87,27.35
GND on TOP (solid shape): 73.49,106.45 73.49,105.64 73.96,105.17 73.96,104.46 75.16,103.27 75.69,103.27 76.05,102.91 76.05,97.04 75.72,96.71 72.9,96.71 72.64,96.97 72.64,96.99 72.57,97.07 72.57,101.03 72.98,101.44 73.27,101.63 73.3,101.99 73.3,104.64 72.87,105.07 72.87,106.39 73.02,106.54 73.4,106.54
GND on TOP (solid shape): 162.11,108.77 162.11,108.23 162.68,107.65 163.07,107.65 163.07,104.56 163.06,104.56 163.06,104.5 162.43,104.5 162.13,104.2 162.13,101.28 161.62,100.77 161.62,97.68 162.37,96.93 163.21,96.93 164.06,97.78 164.57,97.78 164.69,97.65 164.69,97.14 163.8,96.26 161.14,96.26 160.01,97.38 160.01,106.67 161.66,108.32 161.66,108.77 161.69,108.79 162.09,108.79
GND on TOP (solid shape): 17.25,144.92 17.25,144.82 17.19,144.62 17.25,144.42 17.25,144.31 17.37,144.18 17.37,142.94 17.22,142.79 16.41,142.79 16.36,142.84 16.36,143.27 16.53,143.45 16.53,143.82 16.57,143.92 16.59,144.03 16.57,144.13 16.54,144.22 16.53,144.23 16.53,144.34 16.41,144.47 16.08,144.47 15.92,144.62 15.92,145.07 16.05,145.2 16.97,145.2
GND on TOP (solid shape): 30.2,116.32 30.2,116.12 30.33,115.99 32.58,115.99 32.58,115.41 32.41,115.24 32.41,113.58 32.36,113.53 32.13,113.53 32.12,113.54 31.51,113.54 31.2,113.85 30.71,113.85 30.61,113.85 30.51,113.85 30.33,113.85 30.32,113.83 30.3,113.83 30.04,113.72 29.87,113.5 29.39,113.5 29.39,114.12 28.47,114.12 28.47,113.93 28.37,114.04 28.37,115.1 27.89,115.59 27.19,115.59 27.07,115.71 27.07,116.28 27.24,116.45 30.07,116.45
GND on TOP (solid shape): 66.94,9.29 66.94,8.75 65.4,8.75 65.4,5.1 65.45,5.1 65.45,4.55 65.24,4.37 65.06,4.16 64.86,3.75 64.79,3.3 64.79,1.57 64.79,1.56 64.79,1 64.65,0.65 64.3,0.51 52.06,0.51 46.86,0.51 46.86,1.01 51.55,1.01 52.13,1.6 52.13,7.72 52.14,7.73 52.14,9.79 52.48,10.13 66.1,10.13
GND on TOP (solid shape): 119.37,145.79 119.37,142.32 119.25,142.2 117.72,142.2 117.57,142.36 112.88,142.36 112.75,142.48 112.75,144.9 112.89,145.04 113.68,145.04 113.73,144.96 113.8,144.89 114.79,144.85 114.99,145.82 115.03,145.94 115.06,146.07 115.06,146.16 115.19,146.29 118.88,146.29
GND on TOP (solid shape): 52.75,91.76 52.75,91.61 52.61,91.46 52.61,91.12 52.96,90.77 53.1,90.77 53.11,90.74 53.17,90.68 53.24,90.63 53.26,90.61 53.26,90.41 53.24,90.4 53.16,90.34 53.1,90.26 53.09,90.24 52.93,90.24 52.78,90.08 52.75,90.06 52.69,90.01 52.63,89.94 52.48,89.78 52.48,89.63 52.45,89.62 52.38,89.57 52.33,89.5 52.32,89.47 52.17,89.47 51.89,89.19 51.71,89.19 51.66,89.25 51.66,89.42 51.79,89.55 51.79,89.93 51.66,90.06 51.66,90.21 51.74,90.29 51.74,90.74 51.66,90.82 51.66,90.97 51.71,91.02 51.71,91.56 51.66,91.61 51.66,91.73 51.76,91.84 52.68,91.84
GND on TOP (solid shape): 74.17,92.09 74.17,88.36 75.93,86.59 75.93,77.3 79.36,73.87 79.36,71.61 79.47,71.5 79.47,70.47 79.35,70.35 76.17,70.35 76.12,70.4 76.12,70.83 76.09,70.86 74.65,70.86 74.64,70.87 74.64,71.27 74.64,71.27 74.4,71.27 74.39,71.27 74.39,70.86 74.15,70.86 74.14,70.87 74.14,71.27 74.14,71.27 73.89,71.27 73.89,71.27 73.89,70.86 73.65,70.86 73.64,70.87 73.64,71.27 73.64,71.28 73.4,71.28 73.39,71.27 73.39,70.87 73.39,70.86 73.15,70.86 73.14,70.87 73.14,72.25 73.28,72.39 73.77,72.39 73.9,72.51 73.9,81.91 73.77,82.04 73.09,82.04 72.78,82.34 72.78,87.09 72.46,87.41 72.46,87.44 72.29,87.62 72.29,91.96 72.87,92.55 73.71,92.55
GND on TOP (solid shape): 130.18,111.82 130.56,111.82 130.57,111.81 130.58,111.82 131.5,111.82 131.61,111.8 131.73,111.82 132.21,111.82 132.82,112.44 132.94,112.44 133.15,112.23 133.3,111.89 133.67,111.82 133.71,111.82 133.83,111.7 133.83,111.11 133.26,110.55 128.22,110.55 127.97,110.79 127.97,111.82 128.69,111.82 128.72,111.81 128.89,111.8 128.96,111.82 129.18,111.82 129.18,112.06 129.21,112.18 129.2,112.3 129.34,112.44 129.56,112.44
GND on TOP (solid shape): 125.77,117.65 125.75,117.53 125.77,117.42 125.77,116.12 125.75,116.01 125.77,115.89 125.77,114.73 125.75,114.61 125.77,114.5 125.77,113.33 125.75,113.21 125.77,113.1 125.77,111.93 125.75,111.82 125.77,111.7 125.77,110.53 125.75,110.42 125.77,110.3 125.77,109.26 125.75,109.15 125.77,109.03 125.77,108.64 125.64,108.51 123.61,108.51 123.48,108.64 123.48,118.04 123.61,118.17 125.77,118.17
GND on TOP (solid shape): 134.34,147.48 134.34,146.51 132.94,146.51 132.81,146.5 132.69,146.46 132.68,146.45 132.51,146.45 132.35,146.29 132.35,146.09 132.34,146.09 132.31,145.87 132.34,145.66 132.35,145.66 132.35,145.26 132.34,145.25 132.31,145.04 132.34,144.82 132.35,144.82 132.35,144.69 132.52,144.52 132.58,144.52 132.59,144.51 132.76,144.43 132.94,144.4 133.98,144.4 134.17,144.43 134.35,144.52 137.97,144.52 138.05,144.44 138.05,144.06 137.95,143.96 137.72,143.96 137.56,143.8 137.56,143.12 137.03,143.12 136.91,143 136.91,142.42 136.64,142.15 130.69,142.15 130.28,142.56 130.28,146.86 131.03,147.61 134.21,147.61
GND on TOP (solid shape): 62.97,104.46 62.97,103.36 62.94,103.36 62.01,102.43 61.9,102.43 61.83,102.35 61.81,102.35 61.78,102.33 61.36,102.33 61.21,102.18 61.18,102.19 61.04,102.2 60.9,102.15 60.58,102.15 60.49,102.28 60.37,102.37 60.37,102.56 60.4,102.57 60.58,102.71 60.64,102.93 60.7,102.95 60.76,102.97 60.8,102.99 60.89,102.89 60.94,102.84 61.03,102.76 61.25,102.76 61.29,102.8 61.3,102.81 61.51,103.02 61.5,103.33 61.49,103.34 61.49,103.37 61.49,103.44 61.49,103.66 61.47,103.67 61.48,103.7 61.49,103.8 61.47,103.9 61.47,103.91 61.47,103.97 62.06,104.56 62.86,104.56
GND on TOP (solid shape): 130.31,116.71 130.39,116.7 130.47,116.71 130.78,116.71 130.92,116.68 131.06,116.71 133.54,116.71 133.61,116.63 133.61,114.96 133.52,114.86 133.19,114.86 132.95,114.93 132.71,114.86 132.56,114.86 132.32,114.93 132.08,114.86 131.73,114.86 131.61,114.88 131.5,114.86 131.16,114.86 130.92,114.93 130.68,114.86 130.33,114.86 130.21,114.88 130.1,114.86 129.65,114.86 129.54,114.88 129.42,114.86 128.93,114.86 128.82,114.88 128.7,114.86 128.31,114.86 128.3,114.86 128.13,114.86 128,114.98 128,116.71
GND on TOP (solid shape): 63.12,82.59 63.12,82.28 62.41,81.57 62.32,81.12 62.71,80.88 62.76,80.88 62.81,80.89 62.89,80.87 62.92,80.79 62.92,80.4 62.81,80.29 61.33,80.29 61.06,80.56 61.06,80.77 60.87,80.97 59.54,80.97 59.41,81.09 59.41,81.27 59.5,81.36 59.51,81.37 59.63,81.46 59.68,81.59 59.68,81.61 59.84,81.77 60.03,81.77 60.06,81.75 60.08,81.73 60.15,81.69 60.22,81.67 60.24,81.67 60.28,81.62 60.28,81.59 60.38,81.37 60.61,81.29 60.77,81.34 60.87,81.48 60.89,81.54 60.89,81.59 60.89,81.66 60.87,81.72 60.87,81.76 60.9,81.78 61.02,81.9 61.07,82.06 61.06,82.13 61.03,82.21 61.03,82.69 61.09,82.74 62.97,82.74
GND on TOP (solid shape): 59.87,90.36 59.93,90.33 60,90.31 60.07,90.26 60.08,90.18 60.07,90.03 60.12,89.9 60.14,89.87 59.98,89.56 60.12,89.29 60.13,89.28 60.15,89.24 60.14,89.21 60.12,88.97 60.27,88.78 60.27,88.5 60.24,88.44 60.23,88.37 60.14,88.28 60.07,88.28 60.06,88.28 59.89,88.33 59.72,88.3 59.61,88.19 59.61,88.08 59.59,87.98 59.61,87.88 59.61,87.84 59.83,87.63 59.84,87.62 59.94,87.52 59.94,87.44 59.89,87.39 59.79,87.39 59.75,87.43 59.75,87.48 59.54,87.7 59.49,87.7 59.33,87.85 59.33,87.95 59.45,88.2 59.36,88.47 59.36,88.76 59.03,89.1 59.04,89.13 59.07,89.25 59.08,89.37 59.1,89.45 59.18,89.48 59.29,89.5 59.39,89.55 59.56,89.55 59.66,89.65 59.66,90.29 59.74,90.36
GND on TOP (solid shape): 107.29,48 107.55,47.39 108.04,47.83 108.07,47.91 108.14,47.95 111.17,47.95 111.17,46.89 110.99,46.7 95.53,46.7 95.22,47.01 92.6,47.01 92.51,47.11 92.51,47.87 92.58,47.95 94.24,47.95 94.63,47.41 95.02,47.95 96.75,47.95 97.13,47.41 97.52,47.94 98.76,47.94 99.15,47.39 99.5,47.97 102.76,47.97 103.15,47.4 103.49,48
