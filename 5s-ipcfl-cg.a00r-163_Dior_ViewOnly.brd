# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML0ALERT#: length 9.8
  TOP w0.089: U1.BF24 39.14,92.98 38.82,93.3 38.18,93.3 37.75,93.73 37.2,93.73
  TOP w0.102: 37.2,93.73 36.36,93.73 36.17,93.54 34.91,93.54 34.61,93.25 34.17,93.25 33.95,93.47 33.4,93.47 SR184.1 33.25,94.27 33.25,94.52 SR170.2 34.36,94.88 v2(34.54,95.06)
SMLI_CLK: length 17.6
  TOP w0.127: v1(30.47,97.53) v2(29.71,97.53) ; v1(35.28,90.62) 34.89,90.62 SC21.1 35.1,91.28 37.95,91.28 37.97,91.31 39.36,91.31 39.41,91.26 U1.BF27
  IN1 w0.127: v1(30.47,97.53) 31.03,96.97 31.03,96.66 31.3,96.4 31.53,96.4 32.14,95.79 32.14,95.14 32.76,94.52 32.76,92.68 34.83,90.62 v1(35.28,90.62)
  BOTTOM w0.127: v1(35.28,90.62) 35.15,90.49 SR168.2 ; v1(30.47,97.53) 30.47,97.49 30.31,97.33 ECR145.1
SMLI_CLK_R: length 7.2
  BOTTOM w0.127: U104.26 24.67,96.76 25.55,97.64 26.89,97.64 26.89,97.64 27.36,97.64 28.13,96.87 28.13,96.42 v2(28.66,95.89) 28.78,95.89 ECR145.2
SMLI_DATA: length 21.2
  TOP w0.127: U1.BE27 39.75,90.92 39.39,90.92 39.24,91.08 38.05,91.08 37.95,90.97 36.28,90.97 v2(35.98,90.67) 35.71,90.4 35.71,89.79 35.47,89.55 35.02,89.55 SC22.1 34.93,90.17 35.09,90.17 v1(35.28,89.98)
  IN1 w0.127: v1(35.28,89.98) 35.11,89.98 32.51,92.58 32.51,94.41 31.88,95.05 31.88,95.69 31.43,96.14 30.56,96.14 30.04,96.66 30.04,97.78 30.43,98.17 v1(30.68,98.17)
  BOTTOM w0.127: SR169.2 35.03,89.98 v1(35.28,89.98) ; v1(30.68,98.17) 30.14,98.17 ECR144.1
SMLI_DATA_R: length 5.2
  BOTTOM w0.127: U104.25 24.67,97.16 25.52,98.01 v2(27.76,98.01) 28.12,98.01 ECR144.2
SP_CTS_N: length 106.4
  TOP w0.102: J68.10 78.23,145.15 78.77,144.61 78.77,143.57 v1(79.09,143.25)
  IN2 w0.102: v1(14.91,106.16) 15.7,106.94 15.7,111.72 19.95,115.98 20.36,115.98 22.17,117.79 22.17,118.96 22.77,119.55 22.77,119.99 24.31,121.53 24.31,121.67 24.31,122.01 25.87,123.57 25.87,126.1 25.24,126.73 25.24,127.88 25.87,128.51 29.46,128.51 31.55,130.6 31.55,131.7 32.19,132.34 36.34,132.34 39.65,135.65 40.69,135.65 41.35,136.31 41.35,137.12 43.78,139.55 46.57,139.55 47.89,140.87 51.38,140.87 51.44,140.93 54.2,140.93 54.44,140.69 58.42,140.69 58.97,141.24 66.01,141.24 67.69,142.92 70.84,142.92 71.68,143.75 75.59,143.75 75.83,143.51 77.15,143.51 77.42,143.25 v1(79.09,143.25)
  BOTTOM w0.102: OR77.1 9.6,114.45 9.52,114.45 v2(9.16,114.81) 8.76,114.42 8.76,112.88 9.41,112.23 9.41,110.93 9.75,110.59 9.75,110.45 10.23,109.97 10.41,109.97 10.79,109.59 11.02,109.59 11.51,109.1 U104.101 11.51,107.74 12.16,107.09 12.73,107.09 13,106.82 13,105.91 13.46,105.45 14.2,105.45 v1(14.91,106.16)
SP_DCD_N: length 115.1
  TOP w0.102: v1(80.77,142.38) 81,142.15 J68.3 ; OR72.1 12.12,103.65 12.2,103.65 v1(12.42,103.87)
  IN2 w0.102: v1(12.42,103.87) 11.56,104.74 11.56,108.04 12.91,109.4 12.91,112.56 14.12,113.76 14.12,114.96 15.42,116.26 15.42,117.01 16.74,118.33 16.74,119.2 17.04,119.5 17.39,119.5 17.66,119.23 18.13,119.23 18.62,119.72 18.62,119.84 19.69,120.92 20.22,120.92 21.56,122.26 21.56,122.66 23.13,124.22 23.13,126.53 23.21,126.61 23.21,128.72 25.87,131.38 28.07,131.38 28.71,132.03 28.71,133.01 29.39,133.68 30.36,133.68 31.29,134.61 32.36,134.61 33.7,135.95 35.89,135.95 38.23,138.28 38.23,138.72 38.61,139.11 40.25,139.11 43.49,142.34 44.65,142.34 45.35,143.04 46.12,143.04 46.8,143.72 52.23,143.72 52.5,143.45 52.93,143.45 53.29,143.09 54.48,143.09 55,143.62 59.82,143.62 60.3,144.1 62.35,144.1 62.98,144.72 67.84,144.72 69.03,145.91 71.31,145.91 72.83,147.44 77.02,147.44 78.43,146.03 81.24,146.03 81.61,145.66 82.32,145.66 82.75,145.23 82.75,143.35 81.86,142.46 80.85,142.46 v1(80.77,142.38)
  BOTTOM w0.102: v1(12.42,103.87) 12.41,103.87 10.82,105.46 10.82,105.71 9.61,106.92 9.24,106.92 9.08,106.76 U104.96 ; v1(80.77,142.38) 80.77,141.97 v2(81.04,141.71)
SP_DSR_N: length 99.3
  TOP w0.102: J68.8 77.28,144.15 76.07,145.36 74.34,145.36 v1(74.14,145.56) v2(74.14,146.83)
  IN2 w0.102: v1(74.14,145.56) 72.19,145.56 70.43,143.8 66.33,143.8 64.88,142.36 58.26,142.36 58.23,142.39 55.22,142.39 54.89,142.07 52.85,142.07 52.48,142.43 51.68,142.43 51.01,141.76 47.26,141.76 45.96,140.46 43.27,140.46 40.44,137.63 40.26,137.63 39.47,136.85 38.2,136.85 36.57,135.22 36.57,134.12 36.02,133.56 31.97,133.56 30.53,132.12 30.53,131.02 29.04,129.53 25.45,129.53 24.22,128.3 24.22,126.19 24.14,126.1 24.14,123.8 22.58,122.23 22.58,121.84 20.8,120.06 20.8,119.94 18.71,117.85 18.02,117.85 15.49,115.31 15.49,114.23 14.36,113.1 14.36,109.88 13.05,108.57 13.05,105.94 12.52,105.4 v1(12.39,105.4)
  BOTTOM w0.102: OR73.1 8.85,110.2 9.91,109.14 U104.97 9.91,107.43 11.94,105.4 v1(12.39,105.4)
SP_DTR_N: length 100.6
  TOP w0.102: J68.6 76.6,143.15 75.67,144.08 v1(75.67,144.9)
  IN2 w0.102: v1(75.67,144.9) 74.83,144.06 71.69,144.06 70.75,143.12 67.59,143.12 65.91,141.44 58.88,141.44 58.34,140.9 54.69,140.9 54.45,141.14 52.47,141.14 52.46,141.14 51.35,141.14 51.29,141.07 47.79,141.07 46.47,139.75 43.62,139.75 41.15,137.28 41.15,136.39 40.61,135.85 39.56,135.85 36.26,132.55 32.11,132.55 31.34,131.78 31.34,130.68 29.38,128.72 25.79,128.72 25.04,127.96 25.04,126.65 25.67,126.02 25.67,123.66 24.11,122.09 24.11,121.81 24.11,121.61 22.57,120.07 22.57,119.64 21.97,119.04 21.97,118.35 21.06,117.44 19.76,117.44 17.14,114.82 17.14,114.3 16.32,113.48 15.92,113.48 15.23,112.78 15.23,107.88 14.48,107.14 14.48,106.76 v1(14.07,106.36)
  BOTTOM w0.102: OR78.1 9.78,113.4 9.57,113.4 v2(9.26,113.08) 9.26,112.71 9.61,112.36 9.61,111.01 9.95,110.67 9.95,110.54 10.32,110.18 10.49,110.18 10.88,109.79 11.22,109.79 11.91,109.1 U104.102 11.91,107.74 12.35,107.3 13.13,107.3 14.07,106.37 v1(14.07,106.36)
SP_RI_N: length 105.5
  TOP w0.102: J68.11 82.91,146.15 82.27,145.51 81.89,145.51 81.46,145.07 81.46,144.08 v1(81.15,143.77)
  IN2 w0.102: v1(14.06,106.99) 14.06,107 15.02,107.97 15.02,112.94 15.76,113.68 16.23,113.68 16.94,114.38 16.94,114.91 19.68,117.65 20.99,117.65 21.77,118.43 21.77,119.12 22.36,119.72 22.36,119.75 22.36,120.16 23.9,121.7 23.9,121.89 23.9,121.89 23.9,122.18 25.47,123.74 25.47,125.93 24.83,126.56 24.83,128.05 25.71,128.92 29.29,128.92 31.14,130.77 31.14,131.87 32.02,132.75 36.17,132.75 39.48,136.06 40.53,136.06 40.89,136.42 40.89,137.34 43.51,139.96 46.29,139.96 47.61,141.28 51.21,141.28 51.27,141.34 52.38,141.34 52.38,141.34 54.53,141.34 54.77,141.1 58.25,141.1 58.8,141.65 65.83,141.65 67.5,143.32 70.67,143.32 71.61,144.26 74.4,144.26 75.72,145.58 77.21,145.58 78.38,144.41 80.51,144.41 v1(81.15,143.77)
  BOTTOM w0.102: v1(81.15,143.77) 81.14,143.78 81.14,144.09 v2(80.75,144.49) ; v1(14.06,106.99) 13.54,107.5 12.55,107.5 12.31,107.74 U104.103 12.31,109.1 11.92,109.49 11.81,109.49 11.3,109.99 10.96,109.99 10.58,110.38 10.4,110.38 10.15,110.62 10.15,110.75 9.81,111.1 9.81,111.96 OR79.1
SP_RTS_N: length 105.4
  TOP w0.102: v1(81.99,144.92) 82.22,145.15 J68.9
  IN2 w0.102: v1(81.99,144.92) 81.77,144.92 81.07,145.62 78.26,145.62 76.85,147.03 73.03,147.03 70.31,144.32 66.26,144.32 64.71,142.77 58.43,142.77 58.28,142.92 55.16,142.92 54.73,142.48 53.02,142.48 52.65,142.84 52.25,142.84 52.12,142.97 47.14,142.97 46.61,142.43 45.6,142.43 44.89,141.72 44.66,141.72 43.72,140.78 43.25,140.78 40.31,137.84 40.17,137.84 39.39,137.05 38.12,137.05 36.41,135.34 35.32,135.34 33.75,133.77 31.89,133.77 30.33,132.2 30.33,131.11 28.95,129.73 25.37,129.73 24.02,128.39 24.02,126.27 23.94,126.19 23.94,123.88 22.38,122.32 22.38,121.92 20.6,120.15 20.6,120.03 18.62,118.05 17.94,118.05 15.29,115.4 15.29,114.32 14.16,113.18 14.16,110.04 12.53,108.41 v1(12.53,106.67)
  BOTTOM w0.102: v1(81.99,144.92) 82.96,145.89 v2(83.13,145.89) ; v1(12.53,106.67) 11.55,106.67 10.71,107.51 U104.99 10.71,109.1 10.24,109.57 10.06,109.57 9.34,110.29 9.34,110.42 9,110.76 9,111.61 OR75.1
SP_RXD_N: length 117.9
  TOP w0.102: v1(81.47,142.9) 81.37,142.8 80.6,142.8 80.29,142.5 80.29,141.99 80.05,141.75 79.7,141.75 79.3,142.15 J68.4
  IN2 w0.102: v1(12.53,106.03) 11.76,106.81 11.76,107.94 13.96,110.14 13.96,113.31 14.32,113.68 14.32,114.87 15.62,116.17 15.62,116.93 16.08,117.39 16.99,117.39 17.86,118.25 18.54,118.25 20.39,120.11 20.39,120.23 22.17,122.01 22.17,122.4 23.73,123.96 23.73,126.27 23.82,126.36 23.82,128.47 25.28,129.94 27.48,129.94 29.32,131.78 29.32,132.75 29.64,133.07 30.62,133.07 31.52,133.97 33.67,133.97 35.24,135.54 36.06,135.54 38.45,137.93 39.05,137.93 39.36,138.24 39.96,138.24 43.64,141.93 44.8,141.93 45.51,142.64 46.29,142.64 46.97,143.31 52.06,143.31 52.33,143.04 52.75,143.04 53.11,142.69 54.65,142.69 55.08,143.12 60.42,143.12 60.98,143.68 63.11,143.68 63.22,143.79 63.69,143.79 64.23,143.25 64.91,143.25 66.18,144.52 70.21,144.52 72.92,147.23 76.93,147.23 78.34,145.82 81.16,145.82 81.52,145.46 82.24,145.46 82.55,145.14 82.55,143.43 82.02,142.9 v1(81.47,142.9)
  BOTTOM w0.102: OR74.1 8.74,110.96 8.74,110.73 9.14,110.33 9.14,110.2 9.98,109.36 10.11,109.36 10.31,109.16 U104.98 10.31,107.46 11.73,106.03 v1(12.53,106.03) ; v2(85.19,145.79) 85.19,145.02 83.4,143.23 82.24,143.23 81.91,142.9 v1(81.47,142.9)
SP_TXD_SIO: length 14.6
  BOTTOM w0.102: v2(6.17,119.17) 6.6,119.17 7.12,118.65 7.12,118.06 R69867.1 7.82,117.36 O2Q2.3 9.04,117.36 9.34,117.06 9.34,115.81 8.56,115.04 8.56,112.79 9.2,112.15 9.2,110.84 9.55,110.5 9.55,110.37 10.15,109.77 10.33,109.77 10.76,109.34 10.87,109.34 11.11,109.1 U104.100
SP_TXD_SIO_CON: length 104.3
  TOP w0.102: J68.5 81.82,143.15 81.65,143.32 81.01,143.32 80.71,143.62 80.71,146.07 81.4,146.76 v1(81.4,147.3)
  IN1 w0.102: v1(30,137.54) 30,136.49 28.46,134.95 27.61,134.95 21.64,128.99 21.64,127.81 21.2,127.36 19.36,127.36 18.54,128.18 15.13,128.18 14.8,127.85 v1(13.52,127.85)
  IN2 w0.102: v1(81.4,147.3) 80.96,147.74 80.47,147.74 79.45,146.71 78.78,146.71 77.31,148.19 70.23,148.19 69.47,147.42 63.06,147.42 63.01,147.47 61.67,147.47 60.29,146.09 59.18,146.09 58.49,145.4 54.53,145.4 54.32,145.61 52.21,145.61 51.24,144.64 44.76,144.64 44.28,144.16 43.35,144.16 42.56,143.38 42.56,142.97 39.8,140.2 38.12,140.2 36.05,138.13 35.2,138.13 35,137.93 32.21,137.93 31.81,137.54 v1(30,137.54)
  BOTTOM w0.102: v1(13.52,127.85) 12.99,127.85 12.72,127.57 11.12,127.57 10.46,126.91 v2(8.91,126.91) 8.33,126.32 8.33,125.67 7.96,125.3 7.3,125.3 5.33,123.33 5.33,119.3 5.84,118.8 5.84,118.5 R69867.2 6.75,117.59 6.75,117.43 OR76.1
SPI_CLK: length 143.6
  TOP w0.127: F3R11.1 63.23,72.43 62.47,72.43 62.17,72.13 50.81,72.13 50.5,71.82 50.5,71.41 49.89,70.81 49,70.81 48.21,70.02 47.7,70.02 SR222.1 46.96,69.28 46.96,68.99 46.09,68.13 v1(45.71,68.13) 45.64,68.19 F3R25.1 ; v1(11.28,70.88) 11.21,70.82 v2(11.21,70.14)
  IN1 w0.127: v1(11.28,70.88) 12.04,70.12 12.04,69.63 13.1,68.56 13.1,65.73 11.48,64.1 11.48,57.69 12.11,57.07 12.11,55.87 13.37,54.61 16.55,54.61 18.02,53.14 21.06,53.14 22.45,51.74 25.17,51.74 25.67,52.24 30.18,52.24 30.74,51.68 33.97,51.68 34.53,51.12 37.35,51.12 39.24,49.23 42.44,49.23 42.73,48.94 50.61,48.94 51.07,49.39 51.81,49.39 v1(52.47,50.05)
  IN2 w0.127: v1(41.64,73.78) 42.11,73.78 43.11,72.78 43.11,71.85 43.9,71.06 43.9,70.65 46.14,68.41 46.14,67.49 46.56,67.07 47.23,67.07 48.49,65.81 49.39,65.81 51.69,63.52 51.69,60.54 52.58,59.65 52.58,58.56 52.91,58.23 52.91,57.27 52.15,56.51 52.15,54.62 52.81,53.97 52.81,53.05 52.22,52.47 52.22,52.14 52.96,51.4 52.96,50.54 v1(52.47,50.05)
  BOTTOM w0.127: v1(41.64,73.78) 41.64,76.56 42.21,77.13 42.21,78.2 42.47,78.45 SR29.1 42.77,78.06 42.77,76.6 42.48,76.31 v2(42.48,75.43) 42.67,75.24 42.67,73.62 42.29,73.24 39.68,73.24 39.29,72.86 39.29,71.57 39.6,71.26 44.01,71.26 44.56,70.71 44.56,69.6 44.78,69.38 45.16,69.38 45.48,69.06 45.48,68.35 v1(45.71,68.13) ; R99512.2 13.46,73.69 12.89,73.69 12.22,73.02 12.22,72.6 R7206.2 11.28,71.66 v1(11.28,70.88)
SPI_CLK_L500MIL: length 3.5
  TOP w0.089: U1.AW47 43,81.62 42.89,81.52 42.89,80.17 v1(42.95,80.12)
  BOTTOM w0.127: v2(42.24,79.97) 42.38,80.12 v1(42.95,80.12) 43.15,79.91 SR29.2
SPI_CS0#: length 24.8
  TOP w0.089: U1.AY47 42.19,81.46 42.19,81.09 42.41,80.87 42.41,80.42 42.34,80.35 42.34,79.88 42.75,79.47 42.75,79.39
  TOP w0.127: 42.75,79.39 42.75,74.54 44.04,73.24 44.04,71.95 v1(44.84,71.15) ; F3R27.1 45.1,63.73 45.28,63.55 46.92,63.55 47.04,63.67 47.04,64.07 46.91,64.2 46.02,64.2 45.54,64.68 45.22,64.68 45.1,64.81 F3R6.1 v1(45.79,65.17)
  BOTTOM w0.127: v1(44.84,71.15) 45.07,70.92 45.07,70.29 45.99,69.38 45.99,68.56 46.15,68.4 46.15,66.64 45.79,66.28 v2(45.79,65.88) v1(45.79,65.17)
SPI_IO2: length 43.7
  TOP w0.127: SR7787.1 43.76,74.79 43.89,74.67 44.17,74.67 44.3,74.79 44.3,75.05 44.52,75.28 44.8,75.28 44.93,75.15 44.93,74.16 44.8,74.03 44.55,74.03 44.42,73.9 44.42,73.52 44.55,73.4 44.73,73.4 44.85,73.27 44.85,73.03 44.72,72.89 44.55,72.89 44.42,72.76 44.42,72.13 44.8,71.74 45.19,71.74 45.69,72.25 45.69,72.56 45.82,72.69 v1(46.91,72.69) 45.59,71.36 45.59,71 F3R26.1 ; F3R9.1 64.96,66.15 65.09,66.03 65.65,66.03 65.8,66.18 v1(65.8,66.76) 65.44,67.12 64.57,67.12 64.15,67.54 F3R22.2 F3R1.1
  BOTTOM w0.127: v1(65.8,66.76) 65.48,66.76 65.36,66.88 65.36,67.2 65.26,67.3 64.62,67.3 64.5,67.19 64.5,66.86 64.36,66.72 62.94,66.72 62.73,66.51 61.14,66.51 60.55,67.1 59.84,67.1 59.11,66.37 v2(59.1,66.37) 58.82,66.37 58.65,66.54 54.13,66.54 53.6,67.07 50.87,67.07 50.6,66.79 50.6,66.46 50.34,66.21 49.91,66.21 49.78,66.33 49.78,66.66 50.28,67.16 50.28,67.34 50.11,67.5 49.97,67.5 49.66,67.82 49.66,68.12 49.03,68.75 49.03,68.95 48.54,69.44 48.54,70.14 48.1,70.58 48.1,70.94 47.81,71.23 47.63,71.23 47.36,71.51 47.36,71.94 46.91,72.38 v1(46.91,72.69)
SPI_IO2_L500MIL: length 6.1
  TOP w0.089: 42.98,79.4 42.98,79.51 42.53,79.95 42.53,80.28 42.6,80.34 42.6,80.95 42.49,81.06 U1.AY48
  TOP w0.127: 42.98,79.4 42.98,78.93 43.65,78.26 43.65,77.41 v2(43.27,77.03) 43.27,76.59 SR7787.2
SPI_IO3: length 35.7
  TOP w0.127: F3R21.1 44.97,69.46 v1(44.97,68.85) 46.1,68.85 46.46,69.2 46.46,69.51 46.23,69.74 F3R2.1 46.81,70.21 F3R12.1
  BOTTOM w0.127: v1(44.97,68.85) 44.97,68.02 45.77,67.22 45.77,66.87 45.11,66.21 45.11,64.75 44.98,64.62 44.58,64.62 44.45,64.75 44.45,68.95 44.19,69.21 39.42,69.21 39.22,69.41 39.22,70.81 38.78,71.25 38.78,74.08 39.34,74.64 39.6,74.64 39.9,74.34 39.9,73.95 40,73.85 40.94,73.85 41.13,74.04 41.13,74.55 41.01,74.68 40.27,74.68 40.12,74.83 40.12,75.19 40.24,75.32 41.01,75.32 41.13,75.44 41.13,77.05 v2(41.24,77.16) 41.71,77.63 41.71,79.61 SR30.1
SPI_IO3_L500MIL: length 3.8
  TOP w0.127: U1.BA46 41.55,82.4 v1(41.55,82.74)
  BOTTOM w0.127: v1(41.55,82.74) 41.55,82.37 41.55,82.36 41.55,82.01 41.55,82 41.55,81.99 41.35,81.79 SR30.2 40.79,80.8 40.74,80.75 v2(40.33,80.75)
SPI_MISO: length 130.9
  TOP w0.127: F3R8.1 48,65.74 48,65.57 47.88,65.45 46.94,65.45 46.61,65.78 46.61,65.91 v1(46.84,66.13) 46.43,66.54 45.97,66.54 45.72,66.79 45.53,66.79 F3R20.1
  IN1 w0.127: v1(51.1,50.75) 50.53,50.75 49.98,50.21 46.08,50.21 45.05,51.23 39.8,51.23 39.54,51.5 38.9,51.5 38.01,52.39 35.05,52.39 34.43,53.01 32.77,53.01 32.18,53.61 31.78,53.61 30.81,54.57 29.39,54.57 28.32,53.51 26.27,53.51 25.35,54.43 20.26,54.43 18.59,56.1 16.69,56.1 16.47,55.88 14.41,55.88 13.93,56.37 13.93,57.02 13.38,57.57 13.38,57.59 13.27,57.7 13.27,60.89 14.71,62.32 14.71,65.17 14.37,65.5 14.37,70.47 14.71,70.8 15.13,70.8 v1(15.52,70.42)
  IN2 w0.127: v1(51.1,50.75) 51.1,51.13 50.19,52.04 50.19,53.05 50.88,53.74 50.88,54.62 50.37,55.13 50.37,55.45 49.93,55.88 49.93,56.46 50.82,57.35 50.82,58.87 49.79,59.9 49.79,62.24 47.7,64.33 v1(47.7,64.63)
  BOTTOM w0.127: R7204.2 17.17,70.23 R7211.2 16.39,70.64 16.17,70.42 v1(15.52,70.42) ; v1(47.7,64.63) 47.5,64.43 47.01,64.43 46.67,64.77 46.67,64.87 46.3,65.24 46.3,66.25 46.53,66.48 46.53,68.56 46.37,68.72 46.37,69.54 45.45,70.45 45.45,71.15 44.37,72.23 44.37,72.77 43.2,73.93 43.2,77.05 43.62,77.47 43.62,77.71 43.71,77.8 43.71,80.62 44.12,81.03 SR28.1 44.5,81.96 44.63,81.83 45.01,81.83 45.13,81.7 45.13,81.5 45.01,81.37 44.7,81.37 44.58,81.24 44.58,80.63 44.47,80.53 44.15,80.53 44.02,80.41 44.02,79.28 44.32,78.98 44.32,78.75 44.02,78.45 44.02,77.78 43.85,77.62 43.85,77.35 43.61,77.1 43.61,76.06 43.74,75.94 43.97,75.94 44.12,75.78 44.12,75.53 44.02,75.43 43.69,75.43 43.56,75.3 43.56,75.1 43.66,75 43.84,75 43.97,74.87 43.97,74.67 43.63,74.33 43.63,74.11 43.94,73.8 44.04,73.8 44.3,74.06 44.47,74.06 44.62,73.92 44.62,73.4 44.75,73.26 44.75,72.39 45.83,71.31 45.83,70.63 46.75,69.71 46.75,69.15 47.55,68.35 47.55,67.76 47.42,67.63 46.96,67.63 46.86,67.53 46.86,67 47.04,66.82 v2(47.37,66.82) 47.73,66.82 47.73,66.81 48.36,66.17 48.36,65.17 48.24,65.04 48.06,65.04 47.93,65.17 47.93,66 47.75,66.18 47.45,66.18 47.35,66.08 47.35,65.57 47.5,65.42 47.5,65.09 47.37,64.96 47.19,64.96 46.71,65.44 46.71,66 v1(46.84,66.13)
SPI_MISO_L500MIL: length 4.9
  TOP w0.127: v1(42.57,82.28) 42.59,82.28 42.59,82.29 42.21,82.29 42.08,82.41 U1.BA45
  BOTTOM w0.127: v1(42.57,82.28) 42.19,82.28 42.04,82.13 v2(42.04,81.75) 42.04,80.84 42.16,80.71 42.47,80.71 42.62,80.86 42.62,81.68 42.9,81.96 SR28.2
SPI_MISO_PCH_XDP: length 6.4
  BOTTOM w0.127: XDP3.47 10.15,46.35 SR166.1 9.03,45.23 7.55,45.23 7.38,45.41 6.32,45.41 v2(6.07,45.15)
SPI_MOS_CS0#: length 22.3
  TOP w0.127: F3R7.1 47.56,67.24 47.14,67.66 46.84,67.66 46.38,67.2 45.87,67.2 45.39,67.68 43.48,67.68 43.11,68.05 43.11,68.59 42.4,69.31 41.76,69.31 41.32,69.74 41.02,69.74 40.63,69.34 40.63,69.17 41.38,68.41 41.38,67.79 41.73,67.44 41.73,67.25 41.53,67.05 41.25,67.05 40.94,67.35 40.61,67.35 40.46,67.2 40.46,66.54 40.63,66.37 41.11,66.37 41.35,66.13 41.35,65.83 41.17,65.65 40.87,65.65 40.25,65.03 E16.2 40.65,64.21 41.39,64.95 41.39,65 41.49,65.1 41.53,65.1 41.79,65.35 42.61,65.35 42.83,65.57 43.85,65.57 F3R6.2
SPI_MOSI: length 151.6
  TOP w0.127: F3R24.1 45.62,66.23 46.79,65.06 48.47,65.06 49.03,65.63 49.03,66.17 49.27,66.41 v1(49.27,66.96) 51.26,64.96 57.22,64.96 57.53,65.27 59.66,65.27 59.81,65.12 61.19,65.12 61.49,64.81 v1(62.89,64.81) ; v1(66.01,65.42) 66.01,65.01 F3R71.2 ; R99514.2 13.79,70.89 v1(13.89,70.79) ; v1(67.07,70.39) 66.65,70.8 66.65,71.15 65.71,72.09 65.71,72.34 F3R10.1 65.21,72.84 F3R23.2
  IN1 w0.127: v1(13.89,70.79) 13.88,70.8 12.92,70.8 12.67,70.55 12.67,69.72 13.61,68.77 13.61,65.51 11.99,63.89 11.99,57.91 12.62,57.28 12.62,56.51 13,56.12 13.08,56.12 14.08,55.12 16.8,55.12 18.28,53.64 21.27,53.64 22.66,52.25 24.96,52.25 25.45,52.75 30.4,52.75 30.95,52.19 34.18,52.19 34.74,51.63 37.56,51.63 39.45,49.73 42.65,49.73 42.94,49.44 50.4,49.44 50.85,49.9 51.6,49.9 v1(52.38,50.69) ; v1(67.07,70.39) 67.89,69.56 67.89,67.12 66.19,65.42 v1(66.01,65.42) 65.88,65.55 63.63,65.55 v1(62.89,64.81)
  IN2 w0.127: v1(49.19,65.05) 49.19,64.33 51.02,62.5 51.02,60.2 51.95,59.27 51.95,58.47 52.4,58.02 52.4,57.65 51.38,56.63 51.38,55.2 51.43,55.14 51.64,54.93 51.64,53.43 51.51,53.29 51.51,53.12 51.23,52.84 51.23,52.26 52.4,51.09 52.4,50.7 v1(52.38,50.69)
  BOTTOM w0.127: 49.25,66.16 49.25,65.11 v1(49.19,65.05) ; 49.25,66.16 v2(49.25,66.16) ; 49.25,66.16 49.25,66.37 48.74,66.87 48.74,67.96 48.31,68.39 48.31,68.66 47.78,69.2 47.78,69.76 46.59,70.95 46.59,71.63 45.51,72.71 45.51,73.58 45.38,73.71 45.38,76.04 45.58,76.25 45.58,78.71 45.97,79.1 45.97,80.31 46.25,80.58 46.48,80.58 47.32,81.42 SR27.1 47.75,81.09 47.6,80.94 47.42,80.94 47.01,80.52 47.01,80.12 46.2,79.31 46.2,79 45.81,78.61 45.81,76.15 45.61,75.95 45.61,75.24 45.76,75.09 45.76,73.92 45.89,73.78 45.89,72.86 46.97,71.78 46.97,71.35 47.6,70.73 47.6,70.5 48.16,69.94 48.16,69.28 48.65,68.79 48.65,68.59 49.27,67.97 v1(49.27,66.96) ; v1(13.89,70.79) 14.2,71.1 14.2,71.81 R7205.2
SPI_MOSI_L500MIL: length 9.7
  TOP w0.127: v1(43.95,85.06) 43.86,84.97 U1.AU41
  BOTTOM w0.127: v1(43.95,85.06) 44.1,85.06 44.69,85.65 44.69,85.65 44.88,85.84 45.62,85.84 46.17,85.29 46.44,85.29 46.69,85.04 46.69,83.84 46.2,83.35 46.2,82.95 46.43,82.72 47.32,82.72 SR27.2 47.27,81.8 46.89,81.8 v2(46.48,81.4)
SPK_L+: length 172.2
  TOP w0.203: v3(21.81,21.76) 21.69,21.64 U6.42
  IN2 w0.762: v3(21.81,21.76) 21.6,21.76 20.99,22.37 20.99,23.15 22.13,24.29 22.13,25.16 24.08,27.1 26.47,27.1 28.17,25.4 29.66,25.4 30.24,25.99 36.65,25.99 41.72,20.92 46.18,20.92 47.1,21.83 47.83,21.83 49.48,23.48 59.73,23.48 60.95,22.27 64.06,22.27 64.31,22.51 70.53,22.51 72.74,24.73 85.93,24.73 87.56,23.09 98.39,23.09 99.25,22.23 105.26,22.23 105.73,22.7 105.74,22.7 106.07,23.04 119.06,23.04 122.19,26.16 128.32,26.16 129.13,26.97 131.07,26.97 131.95,27.86 133.62,27.86 134.16,28.39 134.16,28.84 136.12,30.8 146.61,30.8 149.05,33.25 v3(158.44,33.25)
  BOTTOM w0.635: AR31.2 164.23,45.46 163.49,46.2 v2(163.1,46.2)
  BOTTOM w0.762: v2(163.1,46.2) 162.56,45.66 161.14,45.66 158.99,43.5 158.99,38.46 159.24,38.2 159.24,33.94 158.55,33.25 v3(158.44,33.25)
SPK_L+_R:
  vias: v2(162.75,48.38)
SPK_L-: length 171.6
  TOP w0.203: v3(21.87,22.73) 21.18,22.04 U6.43
  IN2 w0.762: v3(21.87,22.73) 22.53,22.73 23.66,23.86 23.66,24.89 24.61,25.83 25.94,25.83 27.64,24.13 30.19,24.13 30.76,24.7 36.13,24.7 41.19,19.65 46.7,19.65 47.62,20.56 48.44,20.56 50.09,22.21 59.21,22.21 59.68,21.74 60.65,20.77 64.44,20.77 64.9,21.22 71.12,21.22 71.63,21.73 72.21,21.73 73.94,23.46 85.4,23.46 87.04,21.82 97.86,21.82 98.72,20.96 105.79,20.96 106.5,21.68 106.51,21.68 106.6,21.77 119.59,21.77 122.71,24.89 128.85,24.89 129.66,25.7 131.59,25.7 132.48,26.59 134.15,26.59 135.46,27.89 135.46,28.34 136.55,29.43 147.27,29.43 149.76,31.92 v3(158.42,31.92)
  BOTTOM w0.762: v3(158.42,31.92) 159.02,31.92 160.51,33.42 160.51,39.24 v2(160.26,39.49) 160.26,42.82 161.76,44.33 163.28,44.33 163.36,44.25 165.86,44.25 166.75,45.14 AR30.2
SPK_L-_R: length 7.3
  TOP w0.254: v2(164.53,41.97) 164.53,42.91 166.85,45.23 166.85,46.44 v1(168.16,47.75)
SPKR: length 114.6
  TOP w0.102: SR916.2 6.75,27.14 6.93,26.96 AC84.1 7.75,27.47 7.75,29.23 7.13,29.84 7.13,34.64 10.54,38.05 17.11,38.05 v1(17.52,37.63) ; U1.AW29 42.64,90.46 v1(42.64,90.78) ; v1(31.47,96.83) 29.06,96.83 28.87,97.02 28.53,97.02 28.28,96.77 28.28,96.22 28.86,95.64 28.86,95.25 28.42,94.81 28.42,94.44 27.91,93.93 26.6,93.93 26.05,93.37 26.05,90.93 25.09,89.97 25.09,88.1 23.97,86.99 23.97,86.36 22.02,84.41 22.02,78.46 18.57,75 18.57,72.3 19.81,71.06 21.28,71.06 21.75,70.58 21.75,69.68 22.38,69.06 v2(22.38,68.75) 22.06,68.43 22.06,66.73 21.98,66.65 21.98,59.36 22.66,58.68 22.66,57.69 22.49,57.52 22.49,55.07 22.26,54.84 22.26,52.44 22.69,52.01 22.69,50.3 22.21,49.82 22.21,45.29 22.67,44.83 22.67,43.92 22.49,43.74 22.49,37.47 21.39,36.36 v1(21.39,35.96)
  BOTTOM w0.102: v1(21.39,35.96) 21.39,36.4 20.15,37.63 v1(17.52,37.63) ; v1(31.47,96.83) 31.47,96.83 31.47,96.43 31.89,96 34.14,96 34.98,95.16 36.14,95.16 36.54,94.77 37.06,94.77 37.16,94.67 37.32,94.67 37.6,94.39 SR258.2 37.6,93.93 38.44,93.1 39.52,93.1 M1R15.2 40.18,92.43 40.18,92.17 40.61,91.73 40.61,91.31 40.87,91.06 42.18,91.06 42.46,90.78 v1(42.64,90.78)
SRTCRST#: length 108.7
  TOP w0.127: U1.BD46 40.5,82.18 v1(41.12,82.18) ; v1(15.98,148.76) 16.55,148.19 18.22,148.19 18.68,147.73 C98.1 18.8,147.44 19.21,147.44 R80.2
  IN1 w0.127: v1(15.92,125.87) 16.36,125.87 17.27,124.96 17.27,123.56 19.65,121.17 20.32,121.17 20.84,120.65 20.84,119 20.1,118.26 20.1,116.75 20.29,116.57 20.29,115.72 20.13,115.56 20.13,113.99 18.9,112.76 18.9,111.44 19.28,111.06 19.28,108.94 19.99,108.22 19.99,102.86 20.88,101.98 20.88,95.71 21.5,95.08 21.5,91.95 22.33,91.13 23.24,91.13 23.78,90.58 23.78,88.39 24.5,87.68 24.5,85.58 24.14,85.23 24.14,83.09 24.48,82.75 24.48,81.75 24.14,81.41 24.14,80.02 24.95,79.21 29.42,79.21 29.83,79.62 30.86,79.62 31.14,79.34 32.23,79.34 32.68,79.78 34.22,79.78 34.52,80.08 35.77,80.08 36.34,79.5 37.37,79.5 37.66,79.79 37.91,80.04 37.91,80.5 39.94,82.53 40.78,82.53 v1(41.12,82.18)
  BOTTOM w0.127: v1(15.92,125.87) 15.42,126.38 15.42,128.67 v2(15.01,129.07) 13.3,130.79 13.3,133.18 12.7,133.78 12.7,140.93 12.27,141.36 12.27,142.04 10.62,143.7 10.62,146.48 11.36,147.23 11.36,148.59 12.67,149.9 14.83,149.9 v1(15.98,148.76)
SSD_3V_EN: length 58
  TOP w0.102: SR8001.2 33.78,46.79 v1(33.93,46.64) 34.15,46.64 36.33,44.46 36.33,41.91 36.86,41.38 42.02,41.38 43.73,43.08 44.57,43.08 44.91,42.75 44.91,42.49 45.64,41.76 45.64,40.62 SR7876.1 PR93155.2 47.01,39.14 47.01,38.52 v1(48.89,36.64)
  IN2 w0.102: v1(29.11,47.39) 29.11,47.81 29.6,48.3 31.14,48.3 32.15,47.29 33.29,47.29 v1(33.93,46.64) ; v1(27.96,29.76) 28.24,30.04 31.19,30.04 31.7,30.55 37.46,30.55 v1(37.82,30.19)
  BOTTOM w0.102: v1(29.11,47.39) 29.38,47.13 D4309.3 ; SR79.1 v1(27.96,29.76) ; v1(33.93,46.64) 33.81,46.77 D522.3 ; v1(37.82,30.19) 43.99,36.36 v2(47.14,36.36) 47.81,36.36 48.09,36.64 v1(48.89,36.64)
SSD_CLKREQ#_R: length 19.6
  TOP w0.127: APR112.2 v2(27.71,108.19) 27.71,107.97 27.58,107.84 27.58,107.1 27.25,106.77 26.47,106.77 26.03,106.34 26.03,106.03 23.42,103.42 21.78,103.42 21.53,103.16 18.57,103.16 17.94,103.8 17.07,103.8 16.78,104.09 16.78,104.72 16.87,104.81 16.87,106.68 16.58,106.97 16.58,106.97 16.44,107.11 J219.52
SSD_HDD#: length 100.8
  TOP w0.102: J219.10 5.94,109.62 6.73,110.4 v1(6.88,110.4) ; v1(27.85,46.73) 27.85,48.32 28.27,48.74 28.27,51.81 28.66,52.2 28.66,54.27 v2(28.3,54.63) 28.91,55.24 28.91,55.25 R70290.1 28.76,56.23 28.76,56.3 28.55,56.52 28.55,56.89 28.68,57.01 28.95,57.01 29.87,57.93 29.87,59.91 29.66,60.12 Q9434.1
  IN2 w0.102: v1(6.88,110.4) 6.28,109.8 6.28,105.05 5.82,104.59 5.82,101.55 6.28,101.08 6.28,96.41 5.82,95.94 5.82,93.84 6.28,93.38 6.28,85.99 5.63,85.35 5.63,79.19 8.54,76.29 8.54,69.91 8.63,69.81 8.63,66.77 8.34,66.47 8.34,65.96 8.43,65.87 8.43,64.73 8.55,64.61 9.94,63.21 9.94,60.42 9.19,59.66 9.19,57.07 9.45,56.81 9.45,55.86 10.63,54.68 14.55,54.68 16.38,52.85 16.38,50.42 18.96,47.84 22.32,47.84 22.93,47.23 27.35,47.23 v1(27.85,46.73)
SSD_PIN1: length 5.8
  TOP w0.102: J219.1 3.69,114.85 3.95,114.6 v1(5.32,114.6)
  BOTTOM w0.102: v1(5.32,114.6) 5.32,114.45 v2(5.79,113.99) 6,114.2 APR122.1 6.63,113.78 6.73,113.68 7.01,113.68 APR117.1
SSD_PWR_CNL: length 102.6
  TOP w0.102: U1.U47 54.01,81.42 54.01,80.9 53.81,80.7 53.81,79.34 54.91,78.25 55.7,78.25 56.43,77.52 59.13,77.52 59.93,78.32 62.97,78.32 63.25,78.61 v1(63.62,78.61) 64.1,78.61 64.6,78.1 64.6,76.95 64.8,76.75 65.15,76.75 65.51,76.39 SR7930.2
  IN2 w0.102: v1(63.62,78.61) 63.83,78.4 64.49,78.4 66.08,76.81 66.08,72.25 66.48,71.85 66.9,71.85 67.78,70.96 67.78,67.47 67.12,66.81 67.12,64.33 65.66,62.87 65.66,58.44 65.21,57.99 65.21,56.42 64.37,55.58 64.37,54.35 62.89,52.87 62.41,52.87 61.6,52.06 61,52.06 59.97,51.03 59.97,48.46 58.79,47.28 57.29,47.28 55.95,45.95 55.95,44.91 55.67,44.63 53.78,44.63 53.53,44.38 48.34,44.38 48.09,44.63 47.98,44.63 46.38,46.23 46.38,46.54 42.89,50.03 42.89,50.2 42.24,50.85 41.14,50.85 39.48,52.51 37.33,52.51 34.35,55.49 34.11,55.49 32.43,57.16 32.43,57.44 v1(31.67,58.21)
  BOTTOM w0.102: v1(31.67,58.21) 30.97,57.5 30.97,57.08 30.21,56.32 30.21,53.12 31.22,52.11 v2(31.22,51.42) 31.22,50.76 29.29,48.83 29.24,48.83 D4309.1
SSD_RST_N: length 5
  TOP w0.127: v2(15.98,103.49) 16.27,103.79 APR125.2 16.27,104.93 16.36,105.02 APR126.2 C12.1 15.94,106.75 J219.50
SURGE_IN_C: length 9.7
  TOP w0.508: LU3.1 3.21,147.91 v1(3.83,148.53) ; v1(6.37,148.28) 6.21,148.12 LU3.4 ; LU3.10 12.21,147.56 11.5,148.28 v1(10.18,148.28) ; v1(9.37,148.28) 9.21,148.12 LU3.7
  vias: v2(10.01,149.37)
SURGE_OUT_C: length 4
  TOP w0.508: R22.2 12.17,160.85 ; R20.2 6.2,160.9 ; R21.2 10.39,160.77 ; R19.2 4.42,160.72
  vias: v1(8.41,161.05) v1(9.88,161.05) v1(11.45,161.08) v2(10.74,160.77)
SURGE_OUT_R:
  vias: v2(5.23,162.91)
SUS3V_FON_N: length 3
  TOP w0.102: ST32.1 13.36,94.6 v1(13.44,94.68)
  BOTTOM w0.102: U104.56 13.11,93.66 12.95,93.82 12.95,94.2 v1(13.44,94.68)
SUS3V_ON_N: length 36.2
  TOP w0.102: OR143.1 9.66,98.23 v1(9.45,98.44)
  IN2 w0.102: v1(11.3,124.54) 11.3,123.49 7.36,119.56 7.36,113.68 7.19,113.5 7.19,112.59 7.37,112.41 7.37,112.1 8.47,111 8.47,109.6 7.5,108.64 7.5,101.02 8.25,100.27 8.25,99.63 v1(9.45,98.44)
  BOTTOM w0.102: U104.74 8.97,97.96 v1(9.45,98.44) ; v2(12.39,125.9) 12.39,125.64 v1(11.3,124.54) 10.92,124.93 10.92,125.59 10.58,125.94 PQ9823.1
SUS5V_ON_N: length 3.1
  TOP w0.102: R70294.2 9.82,97.78 v1(9.45,97.78) v2(8.74,97.78)
  BOTTOM w0.102: U104.73 9.23,97.56 v1(9.45,97.78)
SUS_ACK_EN_N: length 33.6
  TOP w0.102: v1(17.96,99.15) 18.03,99.23 19.35,99.23 19.73,98.85 v2(20.45,98.85) 20.65,99.05 20.65,100.04 21.35,100.74 21.35,100.96 22.38,101.98 25.6,101.98 28.19,104.57 28.19,106.19 28.79,106.78 SR700.1 29.15,107.48 PQ102.2 ; v1(10.4,104.23) 10.1,104.23 OR111.1
  BOTTOM w0.102: v1(17.96,99.15) 17.83,99.28 16.65,99.28 16.15,99.78 16.15,100.08 15.04,101.2 14.19,101.2 13.34,100.35 12.52,100.35 11.15,101.72 11.15,103.48 v1(10.4,104.23) 9.43,105.2 9.43,105.56 9.04,105.96 U104.94
SUS_CLK: length 25.9
  IN1 w0.127: v1(35.03,81.64) 35.03,82.74 34.67,83.1 33.81,83.1 31.72,85.19 31.72,86.24 30.5,87.45 30.5,88.48 30.39,88.6 30.39,90.67 30.55,90.83 30.55,94.96 29.39,96.12 29.39,98.67 29.57,98.85 v1(29.57,99.89)
  BOTTOM w0.127: ECR143.1 29.73,101.86 29.89,101.69 v2(29.89,100.68) 29.89,100.21 v1(29.57,99.89) ; SR7792.2 35.14,81.76 v1(35.03,81.64) 34.72,81.64 SR7854.1
SUS_CLK_BUF: length 169.4
  TOP w0.127: v1(72.24,106.21) 70.78,106.21 70.25,106.74 70.25,107.7 68.64,109.31 66.83,109.31 66.42,109.72 66.42,114.93 64.9,116.45 64.03,116.45 63.32,117.16 63.32,120.16 61.87,121.61 v1(61.16,121.61)
  IN1 w0.127: v1(72.24,106.21) 73.45,106.21 75.18,104.49 75.18,103.7 76.91,101.97 76.91,101.34 76.15,100.57 75.82,100.24 75.82,98.37 78.19,96 81.66,96 86.89,90.77 86.89,84.27 83.55,80.92 83.55,76.84 84.86,75.53 v1(84.86,73.8) ; v1(26.22,63.23) 26.22,62.62 27.25,61.58 37.31,61.58 37.88,61.01 44.26,61.01 44.94,61.69 49.77,61.69 50.4,62.32 51.24,62.32 51.69,62.77 54.45,62.77 55.28,63.6 56.27,63.6 57.33,64.66 57.76,64.66 58.06,64.35 58.55,64.35 58.72,64.18 60.29,64.18 61.52,65.4 61.52,66.47 61.82,66.77 61.82,66.95 62.46,67.58 63.24,67.58 64.67,69 v1(66.34,69)
  BOTTOM w0.127: SR7791.2 30.05,75.82 30.05,75.28 29.9,75.13 29.9,73.07 30.36,72.61 30.36,71.37 30.21,71.21 30.21,68.54 29.89,68.23 29.89,65.78 27.5,63.39 26.38,63.39 v1(26.22,63.23) ; v1(61.16,121.61) 61.16,121.3 60.54,120.68 60.18,120.68 v2(59.79,120.28) 59.79,119.75 57.56,117.52 55.78,117.52 55.27,117.01 53.87,117.01 53.39,117.49 51.33,117.49 50.65,116.81 UB1.5 ; v1(84.86,73.8) 80.92,69.87 80.92,69.02 80.64,68.74 80.64,68.74 79.92,68.01 69.8,68.01 69.47,67.68 67.89,67.68 66.57,69 v1(66.34,69)
SUS_CLK_BUF_SIO: length 76.4
  TOP w0.102: v1(24.97,124.55) 24.52,125 24.52,125.36 25.62,126.46 31.46,126.46 42.9,126.46 43.36,126 54.66,126 55.16,126.5 57.92,126.5 59.74,124.68 59.74,124.42 v1(60.26,123.89)
  IN1 w0.102: v1(32.43,103.18) 32.06,103.55 32.06,103.73 29.97,105.81 29.97,107.89 29.73,108.13 29.73,108.96 29.33,109.36 29.33,110.34 28.26,111.42 28.26,117.61 27.39,118.47 27.39,121.96 26.8,122.56 26.63,122.56 26.33,122.56 25.19,123.7 25.19,124.33 v1(24.97,124.55)
  BOTTOM w0.102: v1(32.43,103.18) 32.4,103.14 31.39,103.14 31.24,103.29 30.38,103.29 30.25,103.42 ECR142.1 29.61,103.42 29.18,103.85 28.24,103.85 v2(28.01,103.62) ; v1(60.26,123.89) 60.26,123.59 57.38,120.7 55.6,120.7 UBR1.2
SUS_CLK_BUF_SIO_R: length 5.3
  BOTTOM w0.102: v2(57.22,121.25) 55.56,121.25 54.53,120.22 UBR1.1 54.01,120.22 53.14,119.35 UB1.2
SUS_CLK_BUF_SSD: length 52.9
  TOP w0.127: v1(41.25,120.26) 39.72,121.78 39.09,121.78 38.45,122.42 38.45,123.98 36.93,125.5 31.61,125.5 30.52,124.41 30.52,123.44 29.15,122.08 25.72,122.08 23.85,120.21 23.85,117.36 24.18,117.03 24.18,116.53 24.66,116.04 26.69,116.04 26.85,115.89 26.85,114.95 27.1,114.7 27.46,114.7 28.09,114.06 28.09,111.57 27.15,110.63 27.15,108.19 26.11,107.15 25.31,107.15 24.71,106.56 24.71,106.07 23.75,105.11 21.84,105.11 21.65,104.92 20.8,104.92 20.75,104.87 20.25,104.87 X3R21.1
  BOTTOM w0.127: v1(41.25,120.26) v2(41.98,120.26) 43.69,120.26 44.81,119.14 UBR3.2
SUS_CLK_BUF_SSD_R: length 2.7
  BOTTOM w0.127: UB1.6 46.07,118.08 45.85,118.3 UBR3.1 v2(44.39,118.3)
SUS_CLK_BUF_WLAN: length 118.9
  TOP w0.127: v1(59.18,44.07) APR115.1
  IN1 w0.127: v1(55.05,117.46) 55.05,117.44 54.98,117.37 54.98,114.12 v1(55.01,114.09)
  IN2 w0.127: v1(59.18,44.07) 65.04,49.93 66.24,49.93 66.64,50.33 66.64,53.2 71.88,58.43 77.29,58.43 83.51,64.66 83.51,71.21 84.43,72.13 84.43,77.08 83.54,77.97 83.54,79.93 87.45,83.84 87.45,89.14 81.54,95.04 78.16,95.04 77.09,93.97 73.2,93.97 72.87,93.64 72.18,93.64 70.89,94.93 70.89,95.37 67.72,98.54 66.47,98.54 65.65,99.37 62.54,99.37 60.91,101 60.91,101.99 60.49,102.41 60.49,103.38 60.1,103.77 57.19,103.77 56.69,104.27 56.69,108.47 56.21,108.96 56.21,112.89 v1(55.01,114.09)
  BOTTOM w0.127: UBR2.2 v1(55.05,117.46) 55.46,117.87 56.69,117.87 v2(57.1,118.28)
SUS_CLK_BUF_WLAN_R: length 2.6
  BOTTOM w0.127: v2(54.34,117.52) 54.21,117.65 UBR2.1 53.54,118.43 53.19,118.08 UB1.3
SUS_CLK_SIO: length 8.9
  BOTTOM w0.127: U104.19 25.35,99.56 v2(25.8,100.02) 26.11,100.32 SCB70.2 27.11,100.75 29.22,100.75 29.64,101.18 29.64,101.58 28.89,102.33 ECR143.2 ECR142.2
SUS_CLK_SSD: length 33
  TOP w0.127: v1(25.2,105.81) 24.9,105.81 X3R20.1 ; v2(31.09,79.51) 31.09,79.76 v1(31.58,80.25)
  IN1 w0.127: v1(25.2,105.81) 25.2,104.05 25.72,103.53 25.72,101.85 25.98,101.59 25.98,98.16 26.58,97.56 26.58,93.36 27.72,92.21 27.72,91.51 28.12,91.11 28.12,90.8 28.49,90.43 28.49,89.13 28.39,89.03 28.39,81.61 29.65,80.36 31.48,80.36 v1(31.58,80.25)
  BOTTOM w0.127: SR7856.2 31.71,80.13 v1(31.58,80.25)
SUS_CLK_SSD_R: length 7.8
  TOP w0.127: J219.68 20.44,107.63 19.68,106.87 19.68,106.38 X3R21.2 19.16,105.85 19.16,105.23 19.77,104.61 20.85,104.61 20.9,104.66 21.49,104.66 v2(21.89,104.26) 22.22,104.59 X3R20.2
SUS_CLK_WLAN: length 19
  TOP w0.127: APR115.2 58.15,44.52 APR116.2 57.54,44.91 57.45,45 56.54,45 56.36,45.18 S1C81.1 54.75,45.57 52.97,47.35 52.42,47.35 v2(52.09,47.01) 51.79,47.01 50.77,45.99 50.18,45.99 49.69,46.48 48.72,46.48 47.89,47.31 47.89,48.25 47.3,48.84 47.3,49.66 46.89,50.08 46.89,51.35 46.95,51.41 J218.50
SUS_PWR_ACK: length 40
  TOP w0.089: U1.BE35 39.96,87.1 39.5,87.1 39.38,87.15 39.32,87.21 37.65,87.21 37.6,87.16 37.24,87.16 37.09,87.01
  TOP w0.127: SR120.2 34.38,85.32 34.8,85.74 35.72,85.74 v1(36.17,86.19) 36.27,86.19 37.09,87.01 ; PQ102.3 31.08,109.78 30.83,109.54 30.83,108.45 30.05,107.66 30.05,106.47 SR701.2 29.53,105.95 29.53,105.51 SR703.1 29.06,105.04 v1(29.06,104.64) 29.06,104.08 v2(28.5,103.52)
  IN1 w0.127: v1(29.06,104.64) 29.06,104.25 29.65,103.65 29.65,102.46 30.14,101.97 31.52,101.97 32.56,100.93 32.56,100.25 32.89,99.92 32.89,98.91 33.6,98.2 33.6,96.29 34.21,95.68 34.21,95.12 35.27,94.07 35.27,92.57 38.89,88.95 38.89,88.08 37,86.19 v1(36.17,86.19)
SUS_WARNB: length 194
  TOP w0.127: v1(69.06,144.95) 70.25,144.95 70.69,144.52 SR7999.1 ; U1.BC37 40.65,86.73 v1(40.65,86.88) ; ECR96.1 7.45,95.47 6.94,94.97 6.73,94.97 v1(6.72,94.96) 6.72,94.97 6.68,94.97 6.06,94.34 6.06,90.85 5.57,90.36 5.51,90.36 5.15,90.01 5.15,76.9 v1(6.25,75.81) ; v1(21.77,76.05) 22.83,77.12 22.83,77.44 23.28,77.88 23.28,83.89 25.25,85.86 25.25,86.45 25.76,86.97 27.18,86.97 27.51,86.64 27.51,86 28.23,85.28 SR7844.2 29.6,85.28 30.09,84.8 30.55,84.8 30.71,84.65 30.71,84.2 30.95,83.96 31.49,83.96 31.82,84.29 31.82,85.32 32.13,85.63 SR122.1 32.92,85.63 SR120.1 33.67,85.77 34.48,85.77 34.71,85.99 35.14,85.99 35.24,86.1 35.24,86.11 35.3,86.17 v1(35.54,86.17)
  IN2 w0.127: v1(6.72,94.96) 8.28,94.96 9.13,94.11 9.57,94.11 10.09,94.63 10.09,98.84 7.96,100.97 7.96,107.84 9.25,109.13 9.25,110.56 7.61,112.2 7.61,112.51 7.43,112.69 7.43,113.4 7.61,113.58 7.61,114.94 10.98,118.32 10.98,122.48 12.35,123.84 13.86,123.84 14.48,123.23 16.14,123.23 18.45,125.54 18.45,125.85 18.48,125.88 18.48,126.16 19.75,127.43 19.75,130.33 21.26,131.84 21.84,131.84 23.62,133.62 23.62,134.15 24.08,134.61 26.84,134.61 27.65,135.42 29.64,135.42 30.63,136.41 31.39,136.41 32.67,137.69 35.75,137.69 v1(35.76,137.68)
  BOTTOM w0.127: v1(35.54,86.17) 35.99,86.62 36.35,86.62 36.63,86.35 36.63,86.26 37.4,85.49 37.41,85.49 37.45,85.45 38.7,85.45 39.09,85.84 40.27,85.84 40.65,86.22 v1(40.65,86.88) ; v1(6.25,75.81) 6.97,75.81 v2(7.36,75.41) 20.35,75.41 20.99,76.05 v1(21.77,76.05) ; v1(69.06,144.95) 69.06,144.72 66.52,142.18 66.24,142.18 65.81,142.61 65.35,142.61 65.12,142.38 60.22,142.38 59.23,143.37 59.23,146.04 58.72,146.55 58.01,146.55 57.61,146.95 57.61,147.74 56.69,148.66 55.14,148.66 54.89,148.4 54.89,147.69 55.65,146.93 55.85,146.93 56.5,146.28 56.5,145.48 56.18,145.16 55.26,145.16 54.53,144.44 54.53,143.45 53.97,142.89 52.53,142.89 51.28,141.65 47.22,141.65 46.02,140.45 44.94,140.45 43.39,138.9 40.79,138.9 38.28,136.39 37.06,136.39 v1(35.76,137.68)
SUS_WARNB_R: length 3.3
  TOP w0.127: v1(9.41,95.33) 9.41,95.33 9.27,95.47 ECR96.2 8.71,95.09 v2(8.1,94.48)
  BOTTOM w0.127: U104.68 9.18,95.56 v1(9.41,95.33)
SUS_WLAN_CK: length 80.8
  TOP w0.127: v1(30.8,77.75) 29.45,76.41 29.45,75.21 29.29,75.05 29.29,74.13 28.27,73.11 28.27,73.07 26.8,71.61 26.07,71.61 24.84,70.38 24.84,67.68 24.53,67.38 24.53,63.5 24.05,63.02 24.05,58.87 23.79,58.6 23.79,57.25 23.63,57.1 23.63,54.4 23.37,54.13 23.37,52.98 23.8,52.55 23.8,50.2 23.93,50.07 23.93,44.7 23.52,44.29 23.52,43.57 23.41,43.46 23.41,41.88 v2(24.07,41.22) 24.51,40.78 v1(24.51,40.12) ; v1(54.53,41.8) 54.53,42.42 56.3,44.19 56.37,44.19 APR116.1
  IN1 w0.127: v1(24.51,40.12) 25.78,40.12 25.94,39.96 27.01,38.89 33.55,38.89 33.93,39.27 34.1,39.27 34.1,39.27 37.1,39.27 38.4,37.98 44.07,37.98 45.21,39.11 47.57,39.11 49.15,40.68 53.41,40.68 v1(54.53,41.8)
  BOTTOM w0.127: v1(30.8,77.75) 31.11,78.07 31.11,78.58 31.34,78.81 31.79,78.81 SR7855.2
SUSCLK: length 14.8
  TOP w0.127: v1(40.27,82.99) 40.06,82.79 U1.BE45
  BOTTOM w0.127: SR7856.1 33.92,80.13 34.37,80.58 35.2,80.58 35.48,80.85 35.48,81.57 35.98,82.07 SR7792.1 36.9,82.46 37.11,82.68 37.79,82.68 SR272.1 39.13,83.15 40.12,83.15 v1(40.27,82.99) ; SR7856.1 SR7855.1 32.57,78.76 32.14,78.76 SR7791.1 ; SR7856.1 32.57,79.67 31.72,79.67 v2(31.37,79.31)
SYS_FAN2_CTRL_SIO: length 7.8
  TOP w0.102: v2(18.67,93.86) 18.67,94.6 v1(17.58,95.7) 17.22,96.05 OR149.1
  BOTTOM w0.102: v1(17.58,95.7) 16.69,95.7 15.91,94.92 U104.49
SYS_FAN2_TACH_SIO: length 9.6
  TOP w0.102: OR147.1 18.87,99.84 v1(19.07,100.04) v2(19.84,100.04)
  BOTTOM w0.102: v1(19.07,100.04) 19.8,99.31 19.8,98.68 19.33,98.21 19.33,94.86 19.8,94.39 19.8,93.5 19.91,93.39 U104.39
SYS_FAN_CTRL_SIO: length 5.3
  TOP w0.102: v1(17.29,95.13) 16.98,95.13 16.91,95.06 OR148.1 16.03,94.62 v2(16.03,94.12)
  BOTTOM w0.102: v1(17.29,95.13) 16.6,95.13 16.18,94.71 16.18,93.89 16.31,93.76 U104.48
SYS_FAN_TACH_SIO: length 12.4
  TOP w0.102: v2(20.83,101.03) 19.45,101.03 v1(19.15,101.34) 19,101.34 OR146.1
  BOTTOM w0.102: v1(19.15,101.34) 19.66,100.83 19.66,100.47 19.49,100.31 19.49,99.91 20,99.4 20,98.6 19.53,98.13 19.53,94.94 20,94.47 20,93.7 20.31,93.39 U104.38
SYS_PWROK_PCH: length 10.8
  TOP w0.127: SR274.2 39.15,109.92 SR292.1 SC84.1 40.59,108.92 40.59,107.84 v2(40.49,107.74) 40.72,107.5 41,107.5 41.69,106.81 41.85,106.81 43.17,105.49 43.17,104.99 43.14,104.96 43.14,104.1 U1.AU3
SYS_RESET#: length 288.4
  TOP w0.127: v1(51.52,43.96) 50.91,44.57 v1(50.91,45.58) ; v1(68.07,129.91) 65.96,127.8 65.96,123.64 66.55,123.05 66.55,120.69 66.81,120.42 SR267.2 66.81,119.85 66.41,119.45 66.39,119.45 66.39,117.39 69.91,113.88 69.91,110.01 71.88,108.03 HR380.2 ; U1.AU2 43.87,103.77 43.36,104.28 43.36,104.87 43.39,104.91 43.39,105.59 41.93,107.05 41.83,107.05 40.97,107.91 40.97,109.11 40.71,109.36 40.71,109.57 40.41,109.87 40.12,109.87 SR264.2 39.43,110.56 39.19,110.56 38.91,110.84 38.91,111.95 38.32,112.55 35.47,112.55 35.23,112.79 35.23,113.42 35.1,113.55 v1(34.74,113.55) ; SW_RST1.2 4.03,20.32 3.73,20.61 3.73,22.67 4.03,22.97 SW_RST1.1 4.03,24 3.53,24.5 3.53,28.31 3.05,28.79 3.05,30.93 4.19,32.07 4.19,35.34 5.69,36.84 v1(5.69,45.91) 5.94,46.17 5.94,51.98 8.71,54.75 8.71,55.89 8.05,56.55 8.05,57.96 7.68,58.33 v1(7.68,59.83)
  IN1 w0.127: v1(51.52,43.96) 51.22,43.65 47.97,43.65 47.82,43.81 46.45,43.81 46.4,43.86 44.01,43.86 43.14,42.99 38.65,42.99 38.1,43.54 37.14,43.54 34.81,45.87 34.81,46.87 34.21,47.46 34.21,47.79 33.83,48.17 33.67,48.17 33.04,48.8 28.26,48.8 v1(27.85,49.21)
  IN2 w0.127: v1(68.07,129.91) 67.91,129.91 67.02,129.02 65.84,129.02 64.68,130.18 64.68,130.51 63.8,131.39 62.76,131.39 62.02,130.65 62.02,127.98 60.68,126.63 60.09,126.63 58.71,125.25 58.71,124.42 57.57,123.29 56.33,123.29 55.7,123.92 50.91,123.92 48.23,121.24 36.44,121.24 35.19,119.98 35.19,113.99 v1(34.74,113.55) 34.6,113.69 32.03,113.69 31.56,113.22 31.56,112.92 30.99,112.35 30.47,112.35 28.27,110.15 26.29,110.15 23.02,106.88 23.02,106.66 22.33,105.97 22.33,104.96 22.07,104.71 22.07,104.3 22.07,104.13 22.07,103.96 22.07,103.07 20.66,101.66 20.66,99.83 20.04,99.21 20.04,98.52 18.24,96.71 18.24,92.92 17.63,92.31 17.63,86.98 19.39,85.22 19.39,79.24 17.87,77.72 17.87,66.11 18.87,65.1 18.87,63.51 18.77,63.4 18.77,56.11 19.37,55.52 19.37,54.03 19.7,53.7 19.7,51.62 21.03,50.28 24.56,50.28 26.11,48.73 27.38,48.73 v1(27.85,49.21)
  BOTTOM w0.127: v1(27.85,49.21) v2(27.1,48.46) 25.7,47.06 25.7,43.66 24.91,42.87 24.43,42.87 24.15,42.59 19.75,42.59 19.09,43.25 6.78,43.25 5.46,44.56 5.46,45.68 v1(5.69,45.91) ; SR759.1 7.92,59.59 v1(7.68,59.83) ; v1(50.91,45.58) 50.91,45.85 51.48,46.42 52.02,46.42 52.32,46.73 52.32,48.3 54.2,50.18 54.2,51.1 55.44,52.34 56.62,52.34 57.2,52.92 APR9.1
SYS_RESET#_APS: length 12.6
  BOTTOM w0.127: P466.13 51.5,54.18 52.02,54.7 52.45,54.7 52.81,54.34 52.81,54.04 53.47,53.38 54.53,53.38 55.9,54.75 56.92,54.75 57.2,54.47 APR9.2 57.21,54.05 57.55,53.71 57.91,53.71 58.37,54.17 58.37,54.68 58.6,54.9 v2(59.92,54.9)
TCK0: length 58.9
  TOP w0.102: v1(113.16,125.23) 113.16,125.26 XU1.F11 ; v1(82.04,118.85) 81.34,118.85 80.45,119.74 HR371.1 80.45,121.3 81.13,121.97 82,121.97 82.57,122.54 82.57,123.37 83.32,124.13 HR81.1 83.32,124.77 v2(83.97,125.42) 85.01,126.45 85.69,126.45 86.05,126.09 86.11,126.04 89.06,126.04 89.45,125.64 90.12,125.64 90.31,125.83 93.33,125.83 95.8,123.37 96.44,123.37 v1(96.84,123.77)
  IN1 w0.102: v1(82.04,118.85) 82.04,116.86 81.51,116.32 81.51,114.16 80.36,113.02 80.36,107.33 80.35,107.32 v1(80.35,106.94) ; v1(113.16,125.23) 112.55,125.23 111.81,125.97 111.81,126.29 111.47,126.63 109.7,126.63 108.67,125.59 105.69,125.59 105.31,125.97 104.48,125.97 104.23,125.72 103.33,125.72 102.69,125.08 102.18,125.08 101.55,124.45 98.6,124.45 97.91,123.77 v1(96.84,123.77)
  BOTTOM w0.102: XDP1.57 79.29,107.46 79.82,106.94 v1(80.35,106.94)
TDI: length 66.4
  TOP w0.102: v1(96.2,124.44) 95.64,124.44 93.84,126.24 90.42,126.24 89.97,126.69 89.56,126.69 89.54,126.66 v1(88.44,126.66) 86.96,126.66 86.8,126.5 86.22,126.5 85.86,126.86 84.58,126.86 83.95,126.23 83.8,126.23 81.94,124.38 v1(81.94,122.79) ; v1(114.95,125.23) 114.95,125.22 114.83,125.11 XU1.G12
  IN1 w0.102: v1(74.27,108.09) 75.1,108.93 75.6,108.93 77.44,110.78 77.44,112.82 78.09,113.46 78.09,115.96 80.49,118.37 80.49,120.21 80.86,120.58 80.86,121.7 81.13,121.97 81.3,121.97 81.94,122.62 v1(81.94,122.79) ; v1(114.95,125.23) 114.49,125.69 114.49,125.69 113.15,127.04 104.79,127.04 104.02,126.27 103.3,126.27 102.73,125.69 102.02,125.69 101.29,124.96 98.53,124.96 98.42,124.85 98.1,124.53 96.29,124.53 v1(96.2,124.44)
  BOTTOM w0.102: v1(74.27,108.09) 74.14,107.96 XDP1.56 ; v2(83.53,125.4) 84.2,124.73 84.74,124.73 HR372.1 85.73,124.82 85.73,125.39 85.91,125.57 85.91,125.76 86.4,126.25 88.03,126.25 v1(88.44,126.66)
TDO: length 109.8
  TOP w0.102: SR764.1 46.75,111.97 v1(46.81,112.02) ; XU1.H13 114.95,123.4 v1(114.95,123.4)
  IN1 w0.102: 80.25,121.69 80.24,121.7 80.24,122.1 80.49,122.35 81.35,123.21 82.24,123.21 83.41,122.04 v1(83.6,122.04) ; 80.25,121.69 v1(80.24,121.69) ; 80.25,121.69 80.08,121.53 80.08,119.89 79.28,119.09 79.28,117.73 77.68,116.13 77.68,113.65 76.96,112.93 76.96,111.72 75.69,110.45 75.16,110.45 v1(74.14,109.44) ; v1(85.98,120.49) 87.27,119.19 91.46,119.19 v1(91.9,118.76)
  IN2 w0.102: v1(91.9,118.76) 91.9,119.15 91.67,119.38 91.67,121.37 92.46,122.16 93.88,122.16 94.36,122.65 98.89,122.65 100.4,124.16 104.53,124.16 105.26,123.43 110.74,123.43 111.12,123.82 114.53,123.82 v1(114.95,123.4) ; v1(72.45,126.27) 71.16,126.27 70.04,125.15 68.01,125.15 65.96,123.1 61.38,123.1 59.59,121.31 55.44,121.31 55.23,121.11 51.77,121.11 47.36,116.7 47.36,112.76 46.81,112.22 v1(46.81,112.02)
  BOTTOM w0.102: v1(83.6,122.04) 83.26,122.38 HR91.2 83.26,123.16 83.14,123.28 83.14,123.68 83.38,123.93 83.92,123.93 85.29,122.55 85.29,121.63 85.98,120.94 v1(85.98,120.49) ; XDP1.52 73.67,108.96 v1(74.14,109.44) ; v2(71.17,126.74) 71.98,126.74 v1(72.45,126.27) 76.66,122.06 79.87,122.06 v1(80.24,121.69)
TMIN_SHIFT: length 46.9
  TOP w0.089: U1.BD33 40.29,88.6 39.62,88.6 39.59,88.62 39.35,88.62 38.96,89.01 37.71,89.01 37.7,88.99 37.45,88.99
  TOP w0.102: PQ93028.2 26.72,77.04 27.14,76.62 27.14,75.95 26.68,75.49 26.68,73.55 26.2,73.07 24.61,73.07 22.97,71.43 22.38,71.43 21.52,72.28 ECR135.1 20.95,73.01 v1(20.66,73.31) 20.85,73.5 21.2,73.5 SR7982.2 20.89,74.87 SR7983.1 20.89,76.12 22.83,78.07 22.83,84.07 24.81,86.05 24.81,86.64 25.58,87.41 29.14,87.41 29.39,87.17 29.8,87.17 29.89,87.25 30.99,87.25 31.07,87.33 32.64,87.33 32.82,87.5 32.82,87.7 33.18,88.06 36.05,88.06 36.98,88.99 37.45,88.99
  BOTTOM w0.102: v2(21.31,72.94) 21.03,72.94 v1(20.66,73.31)
TMIN_SHIFT_SIO: length 40.8
  TOP w0.102: PQ93028.3 27.68,77.99 27.54,77.85 27.54,75.78 27.08,75.32 27.08,73.38 26.36,72.66 25.07,72.66 v1(23.26,70.86) ; v1(22.34,72.3) 22.36,72.32 ECR135.2
  BOTTOM w0.102: v1(23.26,70.86) 23,70.59 O2R10.2 O2R25.1 22.16,72.12 v1(22.34,72.3) 23,72.96 23,73.91 23.53,74.44 23.53,74.98 25.13,76.57 25.17,76.57 25.95,77.36 25.95,78.31 27.14,79.49 27.14,79.92 28.08,80.87 28.08,84.81 27.52,85.37 27.52,86.79 27,87.31 25.13,87.31 23.49,88.95 v2(23.49,89.52) 23.49,89.91 23.8,90.21 23.8,90.92 23.15,91.57 22.82,91.57 22.31,92.08 U104.33
TMS: length 67
  TOP w0.102: XU1.F13 114.98,126.14 v1(114.95,126.14) ; v1(97.81,121.27) 97.81,123.66 v1(96.11,125.36) ; v2(83.08,122.95) 83.08,122.57 82.75,122.24 v1(82.75,122.04) 82.75,121.66 81.77,120.68 HR384.1
  IN1 w0.102: v1(74.9,108.09) 75.32,107.67 75.71,107.67 78.08,110.04 78.08,112.64 78.61,113.17 78.61,113.73 80.49,115.61 80.49,116.58 81,117.08 81,119.83 81.76,120.59 81.76,121.05 v1(82.75,122.04) 83.25,121.54 86.38,121.54 87.01,120.91 87.01,120.74 87.75,120.01 93.06,120.01 94.33,121.28 95.75,121.28 96.09,120.94 97.48,120.94 v1(97.81,121.27)
  IN2 w0.102: v1(96.11,125.36) 96.55,125.8 97.33,125.8 97.8,126.27 97.8,126.27 99.24,127.7 103.64,127.7 104.13,127.21 105.83,127.21 106.38,126.66 114.43,126.66 v1(114.95,126.14)
  BOTTOM w0.102: v1(74.9,108.09) 74.27,107.46 XDP1.58
TP_CHA_XMM3_S2: length 3.1
  TOP w0.102: DIMM2.162 115.62,62.62 v1(116.12,63.12)
  BOTTOM w0.102: D4T2.1 116.14,63.11 v1(116.12,63.12)
TP_CHA_XMM3_S3: length 2.8
  TOP w0.102: DIMM2.165 114.87,71.22 D4T1.1
TP_CHB_XMM1_S2: length 3.1
  TOP w0.102: DIMM1.162 115.63,50.02 115.7,50.08 115.7,50.97 v1(115.57,51.1)
  BOTTOM w0.102: v1(115.57,51.1) 114.95,51.1 D4T4.1
TP_CHB_XMM1_S3: length 4.4
  TOP w0.102: DIMM1.165 114.88,54.09 v1(115.16,53.81)
  BOTTOM w0.102: D4T3.1 114.68,53.33 v1(115.16,53.81)
TP_CLKOUT_48: length 5
  TOP w0.102: v1(37.06,88.18) 37.34,88.18 37.53,87.98 39.6,87.98 U1.BE33
  BOTTOM w0.102: ST3.1 37.31,88.92 37.31,88.43 v1(37.06,88.18)
TP_CPU_BPM_N2: length 39.8
  TOP w0.102: XU1.G14 115.89,124.34 v1(115.87,124.34)
  IN1 w0.102: v1(115.87,124.34) 115.74,124.21 115.38,123.85 113.02,123.85 111.22,125.66 109.26,125.66 108.81,125.21 105.45,125.21 105,125.66 104.63,125.66 104.2,125.23 v1(104.06,125.23)
  BOTTOM w0.102: v1(104.06,125.23) 104.06,127.45 103.4,128.11 102.83,128.11 102.2,128.74 102.2,129.32 100.51,131.01 100.33,131.01 96.99,134.35 96.55,134.35 94.26,136.64 92.48,136.64 89.93,139.2 89.93,139.67 89.35,140.25 88.47,140.25 87.76,140.96 HT4.1
TP_CPU_BPM_N3: length 27
  TOP w0.102: v1(115.87,123.4) 116.21,123.74 XU1.H14
  BOTTOM w0.102: HT5.1 97.36,136.99 100.24,134.11 101.74,134.11 102.33,133.52 102.33,131.69 104.64,129.38 104.64,128.82 106.09,127.38 106.71,127.38 108.41,125.68 111.23,125.68 113.09,123.82 115.45,123.82 v1(115.87,123.4)
TP_CPU_RSVD_AB35: length 22.6
  TOP w0.127: XU1.AB35 138.16,110.57 v1(138.16,110.57)
  IN1 w0.102: v1(156.44,104.41) 155.6,104.41 149.78,110.23 138.51,110.23 v1(138.16,110.57)
  BOTTOM w0.102: HT38.1 157.07,104.41 v1(156.44,104.41)
TP_CPU_RSVD_AB37: length 23.7
  TOP w0.102: XU1.AB37 139.95,110.53 140.57,110.53 142.2,112.16 143.79,112.16 144.12,112.49 149.1,112.49 153.79,107.79 v1(154.85,107.79)
  BOTTOM w0.102: v1(154.85,107.79) 157.88,104.76 HT3.1
TP_CPU_RSVD_AB38: length 21.1
  TOP w0.102: v1(156.13,107.58) 155.83,107.28 154.02,107.28 149.02,112.29 144.2,112.29 143.87,111.95 142.28,111.95 XU1.AB38
  BOTTOM w0.102: v1(156.13,107.58) 156.13,107.41 157.57,105.97 HT22.1
TP_CPU_RSVD_AC37: length 38
  TOP w0.102: v1(148.19,85.21) 149.39,85.21 152.26,88.08 152.26,103.55 147.04,108.78 140.03,108.78 XU1.AC37
  BOTTOM w0.102: HT18.1 148.75,85.21 v1(148.19,85.21)
TP_CPU_RSVD_AJ22: length 1.6
  TOP w0.102: XU1.AJ22 125.85,104.1 v1(126.19,104.43)
  BOTTOM w0.102: HT37.1 126.21,104.46 v1(126.19,104.43)
TP_CPU_RSVD_AU9: length 46.3
  TOP w0.102: v1(112.29,96.89) 111.83,97.35 XU1.AU9
  IN2 w0.102: v1(95.15,104.82) 95.32,104.82 98.44,107.93 104.82,107.93 107.23,105.53 107.23,104.88 107.47,104.64 108.71,104.64 109.02,104.33 109.02,102.86 109.93,101.95 109.93,99.38 110.16,99.15 111.71,99.15 111.81,99.05 111.81,97.37 v1(112.29,96.89)
  BOTTOM w0.102: HT34.1 111.25,108.04 110.74,107.53 110.74,106.78 110.49,106.53 109.34,106.53 108.06,105.25 108.06,104.88 107.82,104.64 95.33,104.64 v1(95.15,104.82)
TP_CPU_RSVD_AU10: length 45.3
  TOP w0.102: v1(113.08,97.81) 113.08,97.75 XU1.AU10
  IN2 w0.102: v1(113.08,97.81) 112.72,98.17 112.72,99.42 112.65,99.48 112.65,99.91 112.48,100.09 111.17,100.09 110.87,100.4 110.87,104.38 110.61,104.64 110.13,104.64 109.9,104.87 109.9,105.29 109.56,105.63 107.43,105.63 104.93,108.13 97.98,108.13 v1(95.32,105.48)
  BOTTOM w0.102: HT39.1 109.65,108.8 109.01,108.16 109.01,106.87 107.72,105.59 104.72,105.59 104.47,105.83 104.47,106.12 104.15,106.44 96.28,106.44 v1(95.32,105.48)
TP_CPU_RSVD_AV1: length 27.3
  TOP w0.102: XU1.AV1 103.66,95.64 103.66,87.98 v1(91.11,75.43)
  BOTTOM w0.102: HT9.1 91.46,75.78 v1(91.11,75.43)
TP_CPU_RSVD_AW2: length 27.5
  TOP w0.102: v1(91.11,74.79) 103.99,87.67 103.99,94.14 XU1.AW2
  BOTTOM w0.102: HT11.1 91.26,74.64 v1(91.11,74.79)
TP_CPU_RSVD_B39: length 18.5
  TOP w0.102: v1(142.1,129.9) 141.4,129.2 XU1.B39
  IN2 w0.102: v1(142.1,129.9) 145.69,133.49 v1(145.69,136.9)
  BOTTOM w0.102: HT20.1 146.77,143.84 146.77,138.36 146.12,137.71 146.12,137.33 v1(145.69,136.9)
