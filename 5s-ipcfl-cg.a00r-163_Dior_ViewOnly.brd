# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RSM_RST#_R: length 4.3
  BOTTOM w0.127: v2(11.43,44.06) 11.43,44.06 11.43,45.29 SR162.1 11.87,46.36 12.15,46.63 XDP3.39
RTCRST#: length 208.3
  TOP w0.127: v1(35.2,139.16) 35.08,139.16 34.92,139.31 34.67,139.31 34.42,139.56 34.42,140.01 35.14,140.73 35.28,140.73 36.14,141.59 36.14,141.73 36.14,145.73 37.64,147.23 40.63,147.23 42.71,145.15 44.16,145.15 44.42,144.88 45.12,144.88 45.26,145.02 45.26,145.74 46.96,147.44 46.96,148.78 47.57,149.39 47.57,150.87 48.55,151.84 JMP1.1 ; v1(40.55,81.43) 40.39,81.59 U1.BE47 ; v1(24.66,141.49) 25.2,142.03 25.2,144.45 23.84,145.81 22.1,145.81 21.77,146.14 17.66,146.14 15.54,148.26 15.54,150.26 v1(15.57,150.28) 16.23,149.62 17.65,149.62 17.88,149.39 17.88,149.03 18.08,148.83 C97.1 19.07,148.83 19.2,148.71 R71.2
  IN1 w0.127: v1(55.28,58.58) 55.21,58.5 54.17,58.5 53.58,57.91 52.78,57.91 52.17,57.3 52,57.3 50.25,55.55 50.25,55.21 49.64,54.6 v1(45.06,54.6) ; v1(40.55,81.43) 40.55,80.92 39.08,79.44 39.07,79.44 38.14,78.51 38.14,78.5 38.05,78.41 36.09,78.41 35.77,78.09 34.25,78.09 33.93,78.41 33.34,78.41 32.89,77.97 31.62,77.97 30.84,77.18 29.52,77.18 28.01,78.7 24.73,78.7 23.61,79.82 23.61,85.61 23.93,85.93 23.93,87.13 23.09,87.98 23.09,89.68 22.28,90.49 22.25,90.49 20.99,91.74 20.99,94.87 20.37,95.5 20.37,101.77 19.49,102.65 19.49,107.81 18.77,108.53 18.77,110.16 18.09,110.83 18.09,112.67 19.63,114.21 19.63,115.77 19.76,115.91 19.76,116.37 19.59,116.54 19.59,118.47 20.33,119.21 20.33,120.3 19.96,120.67 19.44,120.67 16.76,123.35 16.76,124.6 16.13,125.24 15.64,125.24 v1(15.49,125.39)
  IN2 w0.127: v1(35.2,139.16) 35.01,139.35 34.78,139.35 34.36,139.77 30.72,139.77 30.44,140.05 29.06,140.05 27.79,141.32 24.84,141.32 v1(24.66,141.49) ; v1(55.28,58.58) 54.46,59.4 54.46,59.75 53.54,60.67 53.54,64.45 49.69,68.3 48.92,68.3 46.21,71.01 46.21,71.36 44.81,72.76 44.81,73.5 42.26,76.05 42.26,78.19 42.59,78.53 42.59,79.39 40.55,81.43 v1(40.55,81.43)
  BOTTOM w0.127: v1(15.49,125.39) 14.86,126.02 14.86,128.51 12.79,130.58 12.79,132.97 12.19,133.57 12.19,140.71 11.77,141.13 11.77,141.82 10.11,143.47 10.11,146.69 10.85,147.44 10.85,148.82 12.44,150.41 15.44,150.41 v1(15.57,150.28) ; APR8.1 45.57,55.36 45.5,55.36 45.06,54.92 v1(45.06,54.6)
RTCRST#_APS: length 3
  BOTTOM w0.127: P466.9 46.42,54.18 46.91,54.67 46.91,55.29 46.77,55.43 APR8.2
RTCX_32.768K_IN: length 6.8
  TOP w0.127: F3R29.1 40.19,76.39 SC29.1 SR320.2 41.38,77.38 v2(41.47,77.48) 41.6,77.61 41.6,78.76 41.5,78.86 41.5,79.93 41.76,80.19 41.76,80.44 U1.BA49
RTCX_32.768K_IN_R: length 2.2
  TOP w0.127: Y5.1 37.42,75.64 37.9,76.11 38.42,76.11 F3R29.2
RTCX_32.768K_OUT: length 10
  TOP w0.089: 42.04,80 42.04,80.05 ; U1.BA48 41.96,80.92 42.06,80.92 42.22,80.77 42.22,80.5 42.04,80.32 42.04,80.1
  TOP w0.127: 42.04,80.05 42.04,80.1 ; Y5.4 39.01,75.03 SC30.1 40.42,75.44 40.57,75.29 SR320.1 42.01,75.92 42.01,78.75 41.73,79.03 41.73,79.67 42.04,79.97 42.04,80
S_FLASH_OVERRIDE#: length 120.4
  TOP w0.102: v1(33.3,103.16) 33.3,102.5 33.07,102.28 32.38,102.28 32.27,102.16 SR7812.2 ; JMP1.6 51.92,147.1 51.92,144.8 51.31,144.19 50.82,144.19 50.09,144.92 47.95,144.92 46.12,143.09 45.19,143.09 44.24,144.05 37.48,144.05 v1(37.31,143.88)
  IN1 w0.102: v1(33.3,103.16) 33.09,103.38 33.09,103.44 31.14,105.38 31.14,107.53 30.3,108.37 30.3,109.77 28.46,111.61 28.46,117.69 27.6,118.56 27.6,122.05 26.88,122.76 26.41,122.76 25.39,123.78 25.39,125.42 24.68,126.13 24.68,129.02 25.09,129.43 26.35,129.43 28.97,132.05 28.97,132.45 32.32,135.8 32.32,139.63 36.4,143.71 37.14,143.71 v1(37.31,143.88)
  IN2 w0.102: v1(33.3,103.16) 32.86,103.6 31.56,103.6 31.13,103.17 30.29,103.17 27.75,100.64 27.75,99.95 26.82,99.02 26.82,95.62 26.6,95.4 26.6,94.74 26.85,94.5 26.85,93.77 26.12,93.04 26.12,88.47 25.34,87.69 25.34,85.04 25.04,84.74 25.04,83.66 25.67,83.04 25.67,80.77 25.69,80.75 25.69,80.19 25.5,80 25.5,78.6 25.94,78.16 25.94,75.68 26.8,74.83 26.8,73.36 26.15,72.71 26.15,67.3 v1(26.72,66.73)
  BOTTOM w0.102: Q1.3 25.86,66.03 26.56,66.73 v1(26.72,66.73)
SA_VDQ_RC: length 2.1
  TOP w0.305: v2(150.65,76.65) 150.65,77 150.64,77 HR8.1 HC2.2
SATA_DETECT_GPIO: length 140.4
  TOP w0.102: v1(15.84,123.9) 15.97,123.9 17.05,124.99 17.05,126.49 17.55,126.99 19.2,126.99 19.53,126.66 31.37,126.66 43.13,126.66 43.52,126.27 53.43,126.27 P110.P12 ; v1(44.52,79.42) 44.91,79.8 44.91,80.2 44.45,80.66 44.45,80.77 44.3,80.92 44.3,81.9 U1.AU46
  IN1 w0.102: v1(49.92,75.47) 50.39,75 50.39,74.56 49.71,73.88 49.71,73.25 49.46,73 47.58,73 46.67,73.91 45.23,73.91 43.37,75.77 40.81,75.77 40.5,75.45 38.1,75.45 37.01,74.36 36.07,74.36 35.26,75.17 32.21,75.17 31.68,74.65 30.73,74.65 29.99,75.39 28.66,75.39 27.5,76.55 24.73,76.55 21.55,79.74 21.55,86.08 20.83,86.8 20.83,88.03 19.8,89.06 19.8,90.43 19.04,91.19 19.04,93.31 18.2,94.14 18.2,97.89 17.46,98.63 17.46,99.54 17.93,100.01 17.93,101.29 18.13,101.49 18.13,107.07 15.87,109.33 15.87,111.4 16.49,112.02 16.49,113.04 17.32,113.87 17.32,115.35 18.06,116.09 18.06,116.39 18.47,116.8 18.47,118.99 18.78,119.31 18.78,120.34 15.84,123.29 v1(15.84,123.9)
  IN2 w0.102: v1(49.92,75.47) 49.92,75.48 49.9,75.48 48.91,76.47 48.4,76.47 48.18,76.69 48.18,77.61 46.07,79.72 44.82,79.72 v1(44.52,79.42)
  BOTTOM w0.102: SR39.2 50.96,73.28 51.09,73.41 51.09,74.44 50.26,75.27 50.12,75.27 v1(49.92,75.47)
SATA_RXN0_C: length 6.2
  BOTTOM w0.127: P110.S5 31.79,126.97 31.79,126.78 30.53,125.52 30.53,123.56 30.26,123.29 30.26,122.69 TC12.2
SATA_RXN0_HDD: length 62
  TOP w0.127: v1(59.93,82.4) 59.94,82.4 60.02,82.48 U1.C45
  IN1 w0.127: v1(59.93,82.4) 59.93,82.4 59.66,82.67 59.66,83.86 60.11,84.3 60.11,84.92 59.72,85.31 59.21,85.31 58.16,86.36 58.01,86.36 56.66,87.71 55.18,87.71 54.81,87.34 53.84,87.34 53.55,87.62 53.55,88.9 53.43,89.03 52.94,89.03 52.83,88.91 52.43,88.91 52.31,89.03 51.66,89.03 51.11,89.58 51.11,90.01 51.38,90.29 51.66,90.29 51.79,90.42 51.79,90.69 51.64,90.85 51.39,90.85 51.11,91.13 51.11,91.65 50.34,92.42 50.34,95.32 50.05,95.61 49.06,95.61 48.11,96.56 48.11,100.3 47.38,101.03 47.17,101.03 46.26,101.94 46.26,103 45.78,103.49 45.78,105.62 44.05,107.35 41.36,107.35 38.77,109.95 38.33,109.95 37.98,110.3 34.95,110.3 33.25,112.01 33.25,115.44 31.93,116.76 31.93,119.55 v1(31.47,120)
  BOTTOM w0.127: v1(31.47,120) 31.67,120.21 31.67,120.39 31.47,120.59 30.59,120.59 30.3,120.88 30.3,121.05 TC12.1
SATA_RXP0_C: length 6.2
  BOTTOM w0.127: TC11.2 30.52,122.69 30.52,123.19 30.78,123.46 30.78,125.42 32.05,126.68 32.05,126.97 P110.S6
SATA_RXP0_HDD: length 62
  TOP w0.127: v1(60.15,83.02) 60.42,83.02 60.82,82.62 60.82,82.36 60.76,82.3 U1.C46
  IN1 w0.127: v1(60.15,83.02) 59.93,83.24 59.93,83.75 60.37,84.19 60.37,85.03 59.83,85.57 59.32,85.57 58.27,86.62 58.12,86.62 56.77,87.98 55.07,87.98 54.7,87.61 53.95,87.61 53.82,87.73 53.82,89.01 53.54,89.3 52.83,89.3 52.72,89.18 52.54,89.18 52.42,89.3 51.77,89.3 51.37,89.69 51.37,89.9 51.5,90.02 51.77,90.02 52.06,90.31 52.06,90.81 51.75,91.11 51.5,91.11 51.37,91.24 51.37,91.76 50.61,92.53 50.61,95.43 50.16,95.87 49.17,95.87 48.37,96.68 48.37,100.41 47.49,101.3 47.28,101.3 46.53,102.05 46.53,103.11 46.05,103.6 46.05,105.73 44.16,107.61 41.48,107.61 38.88,110.21 38.44,110.21 38.09,110.57 35.07,110.57 33.51,112.12 33.51,115.55 32.19,116.87 32.19,119.92 v1(32.11,120)
  BOTTOM w0.127: TC11.1 30.55,121.13 30.55,120.98 30.7,120.84 31.57,120.84 31.93,120.49 31.93,120.18 v1(32.11,120)
SATA_TXN0_C: length 6
  BOTTOM w0.127: P110.S3 28.24,126.97 28.24,126.39 28.93,125.69 28.93,124.15 28.49,123.7 28.49,122.69 TC9.2
SATA_TXN0_HDD: length 76.3
  TOP w0.127: U1.B38 61.09,86.01 62.58,84.52 64.92,84.52 v1(65.23,84.83)
  IN1 w0.127: v1(65.23,84.83) 65.43,85.03 65.6,85.03 65.73,84.9 65.73,84.7 65.63,84.6 65.63,84.44 65.74,84.33 66.03,84.33 66.33,84.63 66.33,88.57 65.87,89.03 61.36,89.03 60.63,89.75 58.27,89.75 57.92,90.1 56.86,90.1 56.55,90.41 53.73,90.41 52.4,91.73 52.31,91.73 51.31,92.74 51.31,95.98 50.42,96.87 49.65,96.87 49.3,97.21 49.3,100.22 48.27,101.25 48.27,102.27 46.65,103.89 46.65,105.82 46.82,105.99 46.82,106.55 45.23,108.14 41.74,108.14 39.16,110.72 38.68,110.72 38.15,111.24 35.11,111.24 34.02,112.33 34.02,115.9 32.82,117.11 32.82,120.8 32.03,121.59 30.98,121.59 30.19,120.8 30.19,120.4 30.28,120.31 30.66,120.31 30.78,120.18 30.78,120.08 v1(30.58,119.88)
  BOTTOM w0.127: TC9.1 28.47,121.08 28.47,120.76 28.67,120.56 29.9,120.56 30.24,120.22 30.24,120.22 v1(30.58,119.88)
SATA_TXP0_C: length 6
  BOTTOM w0.127: P110.S2 27.98,126.97 27.98,126.28 28.68,125.59 28.68,124.25 28.23,123.81 28.23,122.69 TC10.2
SATA_TXP0_HDD: length 76.4
  TOP w0.127: v1(65.24,84.06) 65.04,84.27 62.48,84.27 60.91,85.83 60.91,85.83 U1.C38
  IN1 w0.127: v1(65.24,84.06) 66.14,84.06 66.6,84.52 66.6,88.68 65.98,89.3 61.47,89.3 60.74,90.02 58.38,90.02 58.03,90.36 56.97,90.36 56.66,90.67 53.84,90.67 52.51,92 52.42,92 51.57,92.85 51.57,96.09 50.53,97.13 49.76,97.13 49.57,97.32 49.57,100.33 48.54,101.36 48.54,102.38 46.91,104 46.91,105.7 47.09,105.88 47.09,106.66 45.34,108.41 41.85,108.41 39.27,110.99 38.79,110.99 38.26,111.51 35.22,111.51 34.29,112.44 34.29,116.01 33.09,117.22 33.09,120.91 32.14,121.85 30.87,121.85 29.92,120.91 v1(29.92,119.88)
  BOTTOM w0.127: TC10.1 28.22,121.1 28.22,120.66 28.57,120.31 29.49,120.31 v1(29.92,119.88)
SD3_GPPJ__RCOMP: length 8
  TOP w0.203: v1(38.4,104.79) 39.37,104.79 39.82,104.34 U1.BE1
  TOP w0.254: U1.BE4 39.5,102.55 v1(39.5,102.38) 39.53,102.42 U1.BE5 ; U1.BE1 39.82,104.09 U1.BE2 40.32,104.06 U1.BD1
  BOTTOM w0.254: v2(38.45,102) 38.78,102 39.02,102.24 39.36,102.24 v1(39.5,102.38)
  BOTTOM w0.305: v1(38.4,104.79) 38.92,104.27 SR7914.1 38.92,102.95 v1(39.5,102.38)
SD_CARD_DET: length 7.3
  TOP w0.102: U1.Y46 51.84,82.14 v1(51.26,82.72)
  BOTTOM w0.102: SR108.2 50.28,77.82 SR115.1 50.37,78.59 50.37,79.77 v2(50.26,79.87) 50.52,80.13 50.52,81.73 50.79,81.99 50.79,82.25 v1(51.26,82.72)
SER_IRQ_LT: length 38
  TOP w0.102: U1.AW35 42.52,87.86 v1(42.52,89.53)
  IN1 w0.102: v1(27.66,113.4) 27.66,113.15 28.05,112.75 28.05,111.33 29.13,110.26 29.13,109.28 29.53,108.88 29.53,108.05 29.77,107.8 29.77,105.73 31.09,104.41 31.09,103.72 34.41,100.4 34.41,96.54 34.96,95.99 34.96,95.43 36.02,94.38 36.02,92.88 37,91.9 38.12,91.9 40.09,89.93 42.12,89.93 v1(42.52,89.53)
  BOTTOM w0.102: ECR67.1 v2(26.44,113.93) 26.97,113.4 v1(27.66,113.4) ; SR34.2 42.26,88.98 42.26,89.09 42.52,89.35 v1(42.52,89.53)
SER_SENSE: length 13.4
  TOP w0.102: U1.L48 56.72,80.96 56.72,80.46 57.76,79.42 57.76,79.1 58.06,78.79 59.06,78.79 59.67,79.4 62.88,79.4 63.13,79.65 63.13,80.78 63.87,81.51 64.53,81.51 v2(64.85,81.19) 65.42,80.63 65.42,80.39 65.52,80.29 SR105.2
SERIAL_DETECT: length 109.8
  TOP w0.102: SR7989.2 28.92,96.38 v1(28.7,96.6) ; J68.24 76.85,152.15 v1(76.2,152.8)
  IN1 w0.102: v1(36.93,145.02) 36.65,145.02 31.71,140.09 31.71,136.05 28.36,132.7 28.36,132.3 27.62,131.56 25.87,131.56 23.46,129.15 23.46,124.03 24.2,123.28 24.2,119.62 25.63,118.2 25.63,115.94 25.06,115.37 25.06,112.49 25.67,111.88 25.67,108.93 26.56,108.04 27.33,108.04 27.53,107.84 27.53,107.27 27.81,106.99 27.81,106.34 27.81,105.78 27.35,105.32 27.02,105.32 26.63,104.93 26.63,104.65 27.15,104.13 27.15,104.05 28.14,103.06 28.14,102.24 27.87,101.97 27.87,98.91 28.64,98.14 28.64,96.66 v1(28.7,96.6)
  IN2 w0.102: v1(36.93,145.02) 38.8,145.02 40.14,146.37 40.95,146.37 43.06,148.48 46.23,148.48 46.99,147.72 46.99,147.14 47.58,146.54 51.66,146.54 51.82,146.7 53.49,146.7 53.99,147.2 56.78,147.2 58.58,149 63.23,149 63.94,148.29 64.49,148.29 65.36,149.16 65.36,149.67 66.42,150.73 66.42,151.9 67.33,152.81 71.69,152.81 72.49,152.01 73.66,152.01 74.45,152.8 v1(76.2,152.8)
  BOTTOM w0.102: v1(76.2,152.8) v2(76.2,153.51)
SERIAL_DETECT_R: length 13.8
  TOP w0.089: U1.BD21 40.26,94.06 39.39,94.06 arc(39.35,94.07) 39.31,94.1 39.27,94.13 arc(39.21,94.23) 39.18,94.35 arc(39.18,94.38) 39.16,94.41 38.71,94.86 37.97,94.86 37.95,94.84
  TOP w0.102: 37.95,94.84 37.85,94.74 37.14,94.74 36.37,95.51 36.04,95.51 35.25,96.29 34.66,96.29 34.39,96.56 34.39,97.12 33.96,97.55 33.46,97.55 SR7943.2 32.55,97.65 32.43,97.65 32.07,97.29 32.07,96.45 v2(31.77,96.15) 31.55,96.38 SR7989.1
SERIRQ_SIO: length 7.3
  BOTTOM w0.102: U104.127 21.91,109.28 22.07,109.44 22.55,109.44 22.88,109.11 23.67,109.11 v2(23.87,109.31) 24.28,109.72 24.28,112.44 ECR67.2
SIO_GP053: length 4.6
  BOTTOM w0.102: U104.105 13.11,109.11 12.11,110.11 v2(12.11,110.3) 11.75,110.66 OR132.1
SIO_GP055: length 5.2
  BOTTOM w0.102: OR133.1 12.32,112.06 v2(12.32,111.6) 12.51,111.41 12.51,110.63 12.61,110.53 12.61,109.9 13.18,109.33 13.79,109.33 13.91,109.21 U104.107
SIO_GP060: length 3.3
  BOTTOM w0.102: v2(13.51,110.28) 13.82,110.58 14.18,110.58 OR135.1 14.63,110.13 14.63,109.59 15.11,109.11 U104.110
SIO_GP062: length 2.7
  BOTTOM w0.102: OR137.1 v2(15.33,110.07) 15.57,109.83 15.57,109.44 15.91,109.1 U104.112
SIO_GP104: length 5
  BOTTOM w0.102: v2(4.8,104.33) 5.05,104.08 6.01,104.08 OR120.1 ECR131.1 7.34,102.76 U104.86
SIO_GP106: length 6
  BOTTOM w0.102: v2(4.8,106.21) 5.13,105.88 5.97,105.88 OR122.1 ECR132.1 7.11,104.81 7.11,103.9 7.45,103.56 U104.88
SIO_GP107: length 37.6
  TOP w0.102: ECR141.1 17.58,118.44 v1(17.21,118.44)
  IN1 w0.102: v1(14.47,99.56) 14.47,99.68 13.92,100.23 13.92,103.24 13.5,103.66 13.5,104.23 13.85,104.58 13.85,105.74 13.44,106.16 13.44,110 13.75,110.31 13.75,113.37 14.32,113.94 14.32,115.74 15.65,117.06 15.65,118.13 15.97,118.44 v1(17.21,118.44)
  BOTTOM w0.102: v1(14.47,99.56) 14.45,99.56 14.07,99.94 12.35,99.94 11.08,101.21 10.31,101.21 9.19,102.33 9.19,103.73 8.97,103.96 U104.89 7.44,103.96 7.34,104.06 7.34,106.23 6.86,106.71 6.86,107.08 6.65,107.29 OR123.1 5.97,107.45 v2(5.97,108.18)
SIO_GP116: length 7.2
  TOP w0.102: v1(10.4,105.54) 10.34,105.48 OR112.1
  BOTTOM w0.102: v1(10.4,105.54) 9.77,105.54 8.95,106.36 U104.95 7.5,106.36 7.06,106.8 7.06,108.83 v2(6.58,109.31)
SIO_GREEN: length 45.1
  TOP w0.102: v2(22.98,97.68) 22.37,97.07 v1(22.21,97.07) ; v1(25.27,80.59) 25.27,80.58 24.65,79.96 24.65,78.61 24.73,78.52 24.73,75.97 25.08,75.62 Q17.1
  IN1 w0.102: v1(25.27,80.59) 25.28,80.59 25.38,80.69 25.38,83.13 25.04,83.46 25.04,84.85 25.4,85.21 25.4,88.05 24.68,88.77 24.68,90.96 23.58,92.07 22.66,92.07 22.41,92.31 22.41,94.14 22.79,94.52 22.79,95.57 22.66,95.71 22.66,96.59 22.21,97.04 v1(22.21,97.07) 21.78,97.5 21.78,102.93 v1(21.11,103.6)
  BOTTOM w0.102: v1(22.21,97.07) 22.37,97.23 22.61,97.23 22.94,97.56 U104.24 24.65,97.56 25.43,98.34 27.35,98.34 27.7,98.69 28.31,98.69 R60.2 ; U104.2 23.08,106.36 23.05,106.39 22.54,106.39 21.73,105.58 21.73,104.21 v1(21.11,103.6)
SIO_O2Q3_PIN2: length 3.9
  BOTTOM w0.102: v2(13.21,118.4) 13.28,118.34 O2R15.2 14.03,116.72 14.29,116.46 O2Q3.2
SIO_O2Q3_PIN5: length 7.4
  BOTTOM w0.102: v2(14.63,120.59) 14.37,120.33 O2R14.1 13.62,119.92 13.79,119.75 O2R13.1 12.93,119.33 12.6,118.99 12.6,118.2 13.16,117.64 13.49,117.64 13.77,117.36 13.77,116.58 13.64,116.46 O2Q3.5
SIO_PECI_R: length 6.8
  BOTTOM w0.127: O2R1.2 29.31,93.93 28.83,93.45 28.29,93.45 28.24,93.41 v2(27.9,93.41) 26.83,94.48 26.19,94.48 25.71,94.96 SC52.2 25.17,94.96 24.97,95.16 U104.30
SIO_PECI_REQ_N: length 47.5
  TOP w0.102: v1(27.46,81.83) 27.58,81.83 28.57,82.82 28.57,84.1 29.17,84.69 29.86,84.69 30.28,84.27 30.3,84.27 ; 30.3,84.27 30.3,84.27 30.86,83.71 31.72,83.71 31.96,83.95 SR121.1 32.36,83.74 32.59,83.51 33.86,83.51 34.47,84.12 34.47,85.07 34.93,85.52 35.81,85.52 36.03,85.74 36.31,85.74 36.88,86.31 36.88,86.46 37.37,86.94 37.95,86.94 38.02,87.01 39.23,87.01 39.27,86.98 39.48,86.89 39.49,86.88 U1.BF36 ; 30.3,84.27 SR110.2 ; v1(22.82,99.09) 22.74,99.09 22.2,98.55 22.2,98.25 21.56,97.61 21.56,96.73 19.8,94.97 19.8,92.97 v2(20.04,92.73) 20.04,90.36 19.8,90.12 19.8,89.29 18.95,88.44 v1(18.95,88.22)
  BOTTOM w0.102: v1(22.82,99.09) 22.89,99.16 U104.20 ; v1(18.95,88.22) 19.11,88.05 20.73,88.05 21.09,87.69 22.58,87.69 23.44,86.83 23.44,81.3 24.6,80.14 26.03,80.14 26.06,80.11 26.17,80.11 26.21,80.07 26.84,80.07 26.91,80.14 26.94,80.14 27.46,80.66 v1(27.46,81.83)
SIO_PIN82: length 6
  TOP w0.102: v2(10.39,100.54) 11.09,100.54 v1(11.12,100.57)
  BOTTOM w0.102: ECR129.1 6.69,101.8 7.33,101.16 U104.82 9.55,101.16 9.56,101.15 9.63,101.15 9.84,100.93 10.77,100.93 v1(11.12,100.57)
SIO_PIN83: length 3.5
  TOP w0.102: v1(7.09,102.17) v2(6.41,102.85)
  BOTTOM w0.102: U104.83 7.37,101.56 7.09,101.84 v1(7.09,102.17) 6.54,102.71 ECR130.1
SIO_PROCHOT_R_N: length 9.9
  IN2 w0.127: v1(22.26,89.04) 22.26,87.41 v1(22.43,87.25)
  BOTTOM w0.102: v2(20.99,85.36) 20.45,85.91 ECR104.1 21.75,86.57 v1(22.43,87.25)
  BOTTOM w0.127: v1(22.26,89.04) 21.92,89.39 21.62,89.39 21.08,89.92 21.08,91.58 21.11,91.61 U104.36
SIO_PWRGOD_PS: length 53.2
  IN1 w0.102: v1(20.77,118.07) 21.08,117.76 21.08,113.91 20.27,113.1 v1(20.27,110)
  IN2 w0.102: v1(40.17,136.73) 40.03,136.59 39.17,136.59 37.83,135.24 37.41,135.24 36.98,134.81 36.98,133.95 36.19,133.16 32.14,133.16 30.94,131.95 30.94,130.85 29.21,129.12 25.62,129.12 24.63,128.13 24.63,125.73 24.55,125.65 24.55,123.11 23.7,122.26 23.7,121.78 22.16,120.24 22.16,120.07 22.16,119.81 21.56,119.21 21.56,118.52 21.12,118.07 v1(20.77,118.07)
  BOTTOM w0.102: v1(20.27,110) 20.51,110.24 SR7794.1 ; v2(24.18,114.9) 23.14,114.9 23.02,115.01 21.95,115.01 21.44,114.5 21.44,112.72 21.37,112.65 21.37,111.32 21.41,111.28 21.41,110.72 SR7794.1 ; ECR159.2 ECR160.2 40.47,136.43 v1(40.17,136.73) ; SR7794.1 20.93,109.9 20.31,109.28 U104.123
SIO_SMBCLK1: length 4.4
  TOP w0.102: v2(7.52,96.43) 7.69,96.61 v1(9.45,96.61) 9.87,96.19 OR141.2
  BOTTOM w0.102: U104.70 9.19,96.36 v1(9.45,96.61)
SIO_SMBDAT1: length 2.9
  BOTTOM w0.102: U104.72 7.16,97.16 7.14,97.18 v2(6.6,97.18) 6.41,97.18 6.12,96.89 OR142.2
SIO_SPKR: length 98.8
  TOP w0.102: v1(4.7,37.15) 4.7,46.34 5.19,46.84 5.19,54.13 3.86,55.46 3.86,72.84 4.48,73.46 4.48,73.89 4,74.37 4,102.14 4.37,102.5 4.96,102.5 5.41,102.95 5.41,103.28 5.83,103.7 7.03,103.7 7.72,104.38 v2(7.97,104.38) 8.38,104.79 8.38,105.76 8.58,105.96 10.58,105.96 10.87,105.67 10.87,105.28 O2R9.1 12.57,104.3 12.98,104.71 v1(12.98,105.04) ; v1(5.46,28.65) 5.28,28.65 AC206.1
  IN1 w0.102: v1(4.7,37.15) 4.7,29.41 v1(5.46,28.65)
  BOTTOM w0.102: U104.125 21.11,107.74 20.97,107.6 20.97,107.6 20.87,107.5 20.8,107.43 18.34,107.43 17.79,106.88 16.9,106.88 14.88,104.87 13.15,104.87 v1(12.98,105.04)
SIO_SPKR_C: length 2.6
  TOP w0.102: SR7884.2 4.56,26.79 4.73,26.97 AC206.2 4.73,27.32 5.4,27.98 v1(5.4,28.02)
  BOTTOM w0.102: v1(5.4,28.02) v2(4.69,28.02)
SIO_SUS3_ON: length 218.4
  IN2 w0.102: v1(97.92,36.97) 98.53,37.59 98.53,42.42 96.7,44.25 93.85,44.25 89.13,48.97 89.13,50.65 87.48,52.3 87.48,54.48 84.56,57.4 81.43,57.4 79.18,55.15 74.46,55.15 73.09,56.52 72.01,56.52 69.75,54.26 68.69,54.26 67.34,52.91 67.34,49.91 65.11,47.68 64.43,47.68 57.67,40.92 44.37,40.92 41.27,44.03 41.27,44.58 40.77,45.08 33.95,45.08 33.45,45.58 33.45,45.81 33.2,46.07 32.19,46.07 32.19,46.07 32.02,46.07 31.61,46.48 31.61,47.09 30.81,47.89 30.02,47.89 29.82,47.69 29.82,47.01 29.53,46.71 28.58,46.71 27.86,47.43 23.01,47.43 22.4,48.04 19.05,48.04 16.58,50.5 16.58,53.05 14.75,54.89 11.76,54.89 9.49,57.15 9.49,59.68 10.15,60.33 10.15,63.3 8.63,64.81 8.63,65.95 8.54,66.04 8.54,66.39 8.84,66.68 8.84,69.89 8.74,69.99 8.74,76.38 5.84,79.28 5.84,85.26 6.7,86.13 6.7,93.24 6.02,93.93 6.02,95.75 6.32,96.05 7.09,96.05 7.54,96.51 7.54,98.57 6.87,99.24 6.87,101.28 6.37,101.78 6.37,104.03 6.91,104.56 6.91,109.29 7.67,110.05 7.67,110.78 6.53,111.93 6.53,112.51 6.79,112.78 6.79,119.74 7.01,119.95 7.01,120.41 10.01,123.41 10.55,123.41 10.83,123.69 10.83,124.3 10.88,124.35 10.88,124.72 11.38,125.21 v1(11.38,125.44)
  BOTTOM w0.102: PR70.1 PC67.1 PR66.2 101.88,24.22 100.89,25.21 100.89,27.02 99.31,28.59 v2(99.31,33.31) 99.31,35.59 97.93,36.97 v1(97.92,36.97) ; PQ9823.3 11.63,126.89 11.38,126.63 v1(11.38,125.44)
SIO_TRST#: length 5.2
  BOTTOM w0.102: U104.124 20.71,109.25 21.61,110.15 21.61,111.28 21.87,111.54 v2(21.87,112.18) 21.94,112.26 OR34.2
SIO_YELLOW: length 86.2
  TOP w0.102: Q16.1 3.58,30.64 3.71,30.76 R56.2 4.8,35.61 6.18,36.99 6.18,51.88 9.31,55.01 9.31,57.54 8.32,58.54 8.32,65.76 8.18,65.89 8.18,66.65 8.58,67.05 8.58,68.44 10.29,70.14 10.29,71.47 v2(10.73,71.91) 9.35,73.3 9.35,75.78 7.9,77.23 7.9,84.32 10.86,87.28 15.91,87.28 16,87.19 16.04,87.16 18.49,87.16 19.37,88.04 19.37,88.57 20,89.21 20,89.73 20.24,89.97 20.24,92.06 20.53,92.36 20.53,93.12 20,93.65 20,94.88 21.77,96.65 21.77,97.22 v1(22.25,97.7)
  BOTTOM w0.102: v1(22.25,97.7) 22.58,97.7 22.83,97.96 U104.23
SKL_PCUSTB_DN0: length 57.9
  TOP w0.102: HR83.1 73.95,120.21 74.43,120.21 75.44,119.19 v1(75.94,119.19) v2(76.66,119.19) ; v1(115.87,127.05) 116.08,126.84 116.11,126.84 XU1.E14 ; v1(89.66,128.2) 92.72,128.2 94.61,126.3 96.57,126.3 96.66,126.4 v1(97.34,126.4)
  IN1 w0.102: v1(75.94,119.19) 75.94,120.51 76.97,121.53 76.97,123.05 80.47,126.56 87.69,126.56 88.91,127.78 89.24,127.78 v1(89.66,128.2) ; v1(115.87,127.05) 115.45,127.47 115.45,128.09 114.74,128.8 113.03,128.8 111.87,129.96 110.01,129.96 109,128.94 109,128.74 108.75,128.49 104.04,128.49 103.53,127.98 101.69,127.98 100.35,126.64 97.58,126.64 v1(97.34,126.4)
  BOTTOM w0.102: v1(75.94,119.19) 74.67,120.46 XDP1.6
SKL_PCUSTB_DN1: length 65.2
  TOP w0.102: HR84.1 74.18,114.12 v2(74.43,113.87) 75.56,114.99 v1(76.05,114.99) ; v1(119.55,124.34) 119.55,124.34 XU1.G18
  IN1 w0.102: v1(91.01,122.8) 90.71,122.8 90.23,123.28 89.74,123.28 88.68,124.34 80.94,124.34 78.83,122.23 78.83,121.03 77.86,120.07 77.86,118.13 76.37,116.63 76.37,115.31 v1(76.05,114.99)
  IN2 w0.102: v1(91.01,122.8) 94.08,125.87 95.71,125.87 98.17,128.33 100.04,128.33 101.04,129.33 103.83,129.33 104.61,128.55 106.16,128.55 106.94,129.33 110.66,129.33 111.35,128.64 114.27,128.64 114.47,128.84 116.56,128.84 117.24,128.16 117.24,127.18 118.11,126.32 118.11,126.07 118.49,125.69 118.76,125.69 119.06,125.39 119.06,124.83 v1(119.55,124.34)
  BOTTOM w0.102: XDP1.24 74.27,115.96 75.24,114.99 v1(76.05,114.99)
SKL_PCUSTB_DP0: length 78
  TOP w0.102: v1(116.8,126.14) 116.78,126.14 XU1.F14 ; v1(94.02,124.4) 92.79,125.63 90.4,125.63 90.21,125.44 89.36,125.44 88.97,125.83 86.02,125.83 85.97,125.89 85.61,126.25 85.22,126.25 84.91,125.93 84.91,124.86 84.57,124.51 84.57,123.88 83.67,122.98 83.67,122.69 83.17,122.2 83.17,121.44 82.09,120.36 82.09,119.7 82.66,119.13 82.66,118.59 82.3,118.23 78.84,118.23 v2(78.45,118.62) 75.61,121.45 73.47,121.45 72.95,121.97 69.25,121.97 68.97,122.25 68.28,122.25 67.85,121.83 67.85,121.04 v1(67.73,120.92) 67.87,120.78 67.87,119.7 67.99,119.57 67.99,118.53 67.77,118.3 67.77,116.88 69.82,114.82 HR85.1
  IN1 w0.102: v1(94.02,124.4) 94.78,125.16 95.27,125.16 96.95,126.84 99.92,126.84 102.64,129.55 105.11,129.55 105.26,129.4 109.13,129.4 109.88,130.16 111.99,130.16 112.98,129.17 115.31,129.17 116.36,128.12 116.36,126.76 116.8,126.32 v1(116.8,126.14)
  BOTTOM w0.102: XDP1.4 70.78,120.96 70.68,120.86 67.79,120.86 v1(67.73,120.92)
SKL_PCUSTB_DP1: length 64.4
  TOP w0.102: v1(75.74,115.57) 75.29,115.57 v2(75.03,115.31) 74.79,115.07 HR82.1 ; XU1.F18 119.56,126.13 v1(119.51,126.13)
  IN1 w0.102: v1(119.51,126.13) 119.51,126.5 119.11,126.89 119.11,128.12 116.48,130.76 116.48,130.89 115.65,131.73 107.28,131.73 106.74,131.19 101.32,131.19 98.52,128.39 95.3,128.39 91.4,124.49 91.4,124.05 91.16,123.8 89.83,123.8 88.45,125.17 88.1,125.17 87.47,124.54 80.83,124.54 78.59,122.3 78.59,121.08 77.63,120.13 77.63,118.19 76.16,116.72 76.16,115.99 v1(75.74,115.57)
  BOTTOM w0.102: XDP1.22 74.38,116.46 75.27,115.57 v1(75.74,115.57)
SLEEVE: length 27.7
  TOP w0.229: U6.18 14.37,22.04 14.23,22.17
  IN2 w1.016: 12.68,21.38 12.68,18.17 12.98,17.88 12.98,16.02 13.81,15.19 15.37,15.19 16.08,15.89 17.78,15.89 19.26,14.42 23.78,14.42 24.86,15.5 27.87,15.5 29.18,14.19 31.7,14.19 31.95,14.44
  vias: v1(13.04,22.2) v1(13.67,22.2) v1(33.81,15.53) v1(33.93,14.87) v2(33.98,17.03)
SLEEVE_B: length 12.5
  TOP w1.016: 29.7,12.06 29.7,11.38 27.67,9.35 27.67,3.2 27.1,2.63 J301.4
  BOTTOM w0.254: v2(30.29,13.66) 30.29,13.07 v1(30.01,12.79)
SLP_A#_APS: length 12.5
  BOTTOM w0.127: P466.6 41.34,47.12 40.66,46.45 37.16,46.45 36.34,45.62 35.21,45.62 33.75,44.16 32.69,44.16 v2(32.29,43.77) 31.86,43.77 31.85,43.78 APR7.1
SLP_LAN#: length 184.2
  TOP w0.102: U1.BF40 39.5,85.16 38.59,85.16 37.66,84.23 37.06,84.23 36.78,83.95 36.78,83.8 36.07,83.09 35.9,83.09
  TOP w0.127: v1(24.76,58) 24.76,59 v2(24.61,59.15) 24.31,59.45 24.31,62.85 25.84,64.38 26.01,64.38 27.19,65.56 27.19,67.03 25.35,68.87 25.35,70.2 26.23,71.08 26.96,71.08 28.75,72.87 28.75,72.91 29.77,73.93 29.77,74.85 30.01,75.09 30.01,76.27 30.83,77.09 31.07,77.09 31.46,77.48 31.46,79.05 31.6,79.18 31.6,79.66 32.32,80.38 32.32,80.4 33.05,81.13 33.05,81.63 33.66,82.24 34.67,82.24 34.74,82.3 35.01,82.3 35.8,83.09 35.9,83.09 ; v1(99.8,9.36) 100.05,9.62 ECR157.1
  IN1 w0.127: v1(99.8,9.36) 99.29,9.87 99.29,12.7 93.19,18.79 93.19,24.86 92.46,25.59 v1(91.87,25.59) ; v1(68.83,62.93) 66.29,62.93 64.49,61.13 62.86,61.13 61.36,59.63 59.16,59.63 58.74,59.21 58.42,59.21 57.88,58.68 56.46,58.68 55.53,57.74 54.45,57.74 53.89,57.18 53.08,57.18 52.48,56.57 52.3,56.57 50.98,55.25 50.98,54.9 50.56,54.48 50.56,53.88 50.11,53.43 46.55,53.43 46.13,53.85 43.49,53.85 42.54,54.8 37.49,54.8 36.14,56.15 36.14,57.12 35.26,58 33.46,58 33.07,57.61 32.46,57.61 32.18,57.33 30.27,57.33 29.43,58.17 24.93,58.17 v1(24.76,58) ; v1(79.98,58.26) 79.53,58.26 77.11,55.84 75.29,55.84 74.83,56.3 74.45,56.3 74.19,56.04 74.19,54.73 74.52,54.4 74.52,45.2 69.75,40.42 69.75,29.76 71.25,28.26 71.25,28.13 v1(72.79,26.58)
  IN2 w0.127: v1(91.87,25.59) 91.77,25.69 75.66,25.69 75.08,26.28 74.24,26.28 74.12,26.15 73.23,26.15 v1(72.79,26.58)
  BOTTOM w0.127: v1(79.98,58.26) 77.23,58.26 75.81,59.68 72.08,59.68 v1(68.83,62.93) ; v1(24.76,58) 24.76,58.61 SR216.1
SLP_S0_N: length 140.5
  TOP w0.127: v1(10.63,52.26) 11.15,52.78 11.15,54.5 12.87,56.22 13.27,56.22 13.6,56.55 13.6,56.99 13.33,57.25 13.33,61.08 14.35,62.09 14.35,62.69 18.59,66.93 v1(18.59,66.98) ; v1(48.6,55.06) 48.17,54.63 47.24,54.63 46.51,53.89 44.72,53.89 44.07,54.54 41.53,54.54 40.87,53.88 40.87,51.42 39.8,50.35 39.8,48.87 39.6,48.67 39.6,47.51 39.41,47.33 39.41,46.83 39.74,46.51 39.74,45.17 39.37,44.8 39.37,43.35 v2(40.13,42.59) 42.51,42.59 43.65,43.73 45.92,43.73 v1(47.19,42.46) ; v1(42.04,90.59) 41.63,91 41.07,91 U1.BC28
  IN1 w0.127: v1(47.19,42.46) 47.19,41.87 46.46,41.14 42.82,41.14 42.52,41.44 38.04,41.44 37.3,40.7 37.06,40.46 33.44,40.46 33.05,40.08 27.51,40.08 27.14,40.46 25.97,41.62 21.48,41.62 18.16,44.95 15.35,44.95 10.79,49.5 10.79,52.09 v1(10.63,52.26)
  IN2 w0.127: v1(42.04,90.59) 41.17,89.73 40.54,89.73 39.61,88.8 39.61,87.36 38.97,86.71 38.97,80.88 39.52,80.33 39.52,79.14 38.73,78.35 38.73,77.26 39.11,76.88 39.11,75.53 41.38,73.26 41.38,71.86 41.9,71.34 42.9,71.34 43.38,70.86 43.38,69.83 44.56,68.65 44.56,67.95 45.95,66.56 47.02,66.56 47.27,66.31 47.27,64.18 49.41,62.04 49.41,59.74 50.44,58.71 50.44,57.51 49.91,56.97 48.58,56.97 48.03,56.43 48.03,55.63 v1(48.6,55.06)
  BOTTOM w0.127: F3R70.2 18.57,66.98 v1(18.59,66.98)
SLP_S3#_APS: length 6.5
  TOP w0.127: v1(35.53,46.32) 35.5,46.32 APR5.1
  BOTTOM w0.127: P466.2 36.26,47.04 v1(35.53,46.32) 34.66,46.32 34.55,46.21 33.75,46.21 33.53,45.99 32.7,45.99 v2(32.22,45.51)
SLP_S3_LED_B: length 5
  TOP w0.102: v1(159.54,24.22) 160.23,23.53 R8828.1 162.4,23.53 162.41,23.54 Q9344.1
  BOTTOM w0.102: v1(159.54,24.22) 158.85,23.54 v2(158.85,23.28)
SLP_S3_LED_C: length 6.1
  TOP w0.102: Q9344.3 163.98,25.24 163.28,24.53 R4814.2 160.48,24.53 v1(160.17,24.22)
  BOTTOM w0.102: v1(160.17,24.22) 160.17,24.39 v2(159.6,24.97)
SLP_S3_LED_E: length 4.5
  TOP w0.102: Q9344.2 164.93,25.18 v1(165.4,25.65) 165.78,25.65 CR22.1
  BOTTOM w0.102: v2(165.68,26.46) 165.4,26.18 v1(165.4,25.65)
SLP_S3_N: length 436.8
  TOP w0.102: 36.47,81.92 36.88,82.34 36.88,82.43 37.2,82.74 37.62,82.74 38.72,83.84 39.06,83.84 39.22,83.99 U1.BF42
  TOP w0.127: R8828.2 157.71,22.69 155.31,25.1 152.03,25.1 145.08,32.04 136.14,32.04 132.94,28.85 132.94,25.01 v1(132.31,24.37) ; v1(52.25,20.83) 52.25,34.05 47.57,38.72 47.57,39.26 46.77,40.06 46.77,41.65 46.12,42.3 46.12,43.04 45.75,43.42 43.72,43.42 41.92,41.62 36.96,41.62 36.57,42.01 36.57,44.63 34.47,46.73 APR5.2 34.03,47.35 v1(33.76,47.62) 33.75,47.63 SR8001.1 ; 36.47,81.92 v1(36.36,81.82) ; PR93156.1 v1(34.7,23.26)
  IN1 w0.127: v1(36.36,81.82) 36.35,81.83 36.35,82.73 36.92,83.3 37.34,83.3 37.77,83.73 37.77,84.14 39.39,85.77 39.39,88.95 39.39,90.29 38.02,91.66 36.9,91.66 35.77,92.78 35.77,94.28 34.72,95.33 34.72,95.89 34.11,96.5 34.11,100.36 31.78,102.69 v1(30.4,102.69) 30.4,103.68 30.05,104.02 30.05,105.11 29.53,105.63 29.53,107.7 29.25,107.98 29.25,108.72 27.57,110.4 27.57,110.92 27.81,111.17 27.81,112.62 27.23,113.21 27.23,113.7 27.61,114.09 27.61,114.79 v1(27.28,115.13) ; v1(24.7,56.5) 25.87,56.5 26.37,56 26.97,56 27.56,56.59 28.16,56.59 28.39,56.37 29.62,56.37 29.8,56.19 32.66,56.19 32.76,56.29 33.62,56.29 33.76,56.15 34.24,56.15 36.93,53.46 38.45,53.46 39.31,52.59 41.79,52.59 42.08,52.3 45.49,52.3 45.91,51.88 52.47,51.88 53.38,52.8 53.49,52.9 54.62,52.9 55.25,53.53 58.69,53.53 59.53,54.37 60.96,54.37 61.27,54.06 63.59,54.06 65.22,55.69 66.86,55.69 67.61,56.44 v1(67.61,59.25)
  IN2 w0.127: v1(67.61,59.25) 68.1,59.73 70.69,59.73 71.5,60.54 76.83,60.54 79.65,63.36 80.09,63.36 80.39,63.67 80.39,67.91 80.96,68.48 80.96,70.22 80.48,70.69 80.48,79.91 81.1,80.53 81.1,83.45 74.01,90.54 74.01,92.32 73.63,92.7 73.2,92.7 v1(72.95,92.95) ; v1(130.85,39.53) 131.4,40.08 138.52,40.08 v1(138.92,39.67) ; v1(33.76,47.62) 33.61,47.62 32.86,48.37 32.28,48.37 31.86,48.8 28.92,48.8 28.06,49.65 26.62,49.65 25.17,51.09 25.17,52.77 25.45,53.05 25.45,55.75 v1(24.7,56.5) ; v1(34.7,23.26) 36.23,23.26 40.8,18.69 47.1,18.69 48.02,19.61 48.83,19.61 50.04,20.82 51.73,20.82 51.74,20.83 v1(52.25,20.83) 52.41,21 54.91,21 55.61,20.3 57.76,20.3 59.42,18.63 64.53,18.63 64.78,18.89 70.46,18.89 70.86,19.29 71.42,19.29 71.62,19.29 74.1,21.77 83.84,21.77 85.15,20.46 85.35,20.46 90.45,20.46 91.67,19.24 95.27,19.24 95.81,19.78 106.28,19.78 106.68,20.19 120.39,20.19 123.92,23.71 129.34,23.71 130.09,24.46 132.22,24.46 v1(132.31,24.37)
  BOTTOM w0.127: v1(30.4,102.69) 30.8,102.69 31.31,102.18 PU76.3 ; PR129.1 137.09,35.6 137.09,36.13 138.47,37.51 138.55,37.59 138.9,37.59 139.41,38.1 139.41,39.26 139,39.67 v1(138.92,39.67) ; v1(72.95,92.95) 72.62,92.62 72.62,92.01 72.27,91.67 69.01,91.67 68.68,92 PR115.1 ; v1(24.7,56.5) 25.67,57.46 25.67,59.71 26.27,60.31 26.44,60.31 26.9,60.77 26.9,62.1 30.38,65.58 30.38,67.9 30.86,68.38 30.86,72.99 31.65,73.78 31.65,75.15 33.07,76.57 33.07,77.85 SR212.1 32.98,78.68 33.25,78.68 33.44,78.87 33.44,79.25 34.53,80.35 35.3,80.35 36.02,81.06 36.02,81.47 v1(36.36,81.82) ; v1(27.28,115.13) 26.34,116.07 25.98,116.07 24.92,117.13 24.26,117.13 22.68,115.56 20.64,115.56 19.34,114.26 19.34,113.06 20.04,112.36 20.04,112.12 20.19,111.96 20.19,111.25 C81.1 19.58,110.64 19.58,109.72 19.51,109.65 U104.121 ; v1(130.85,39.53) 131.35,39.03 131.35,36.65 131.06,36.36 v2(131.06,24.63) 131.75,24.63 131.82,24.56 132.12,24.56 v1(132.31,24.37) ; D522.2 33.79,47.8 33.68,47.69 33.68,47.65 33.71,47.62 v1(33.76,47.62)
SLP_S3_N_PU7: length 8.4
  TOP w0.102: v2(34.01,25.64) PR93156.2 PC7899.1 35.75,24.79 35.83,24.72 35.83,23.66 34.74,22.57 v1(34.69,22.57)
  BOTTOM w0.102: v1(34.69,22.57) 34.69,22.16 34.47,21.94 PR93170.2 33.96,22.39 34.03,22.47 34.03,23 33.58,23.46 PU7.3
SLP_S4#_APS: length 12.6
  BOTTOM w0.127: APR6.2 41.34,54.24 P466.5 41.34,51.84 40.61,51.12 38.6,51.12 37.88,50.4 33.72,50.4 v2(33.32,50)
SLP_S4_N: length 572
  TOP w0.102: U1.BE42 39.64,83.63 38.8,83.63 37.72,82.56 37.72,82.01 37.54,81.83
  TOP w0.127: UU66.4 76.51,24.8 76.3,25.01 76.01,25.01 SR213.1 75.5,25.86 v1(75.8,26.16) ; v1(20.57,114.54) 19.99,113.96 14.91,113.96 14.69,113.74 12.28,113.74 11.99,113.45 9.49,113.45 8.29,112.26 7.02,112.26 v1(6.95,112.18) ; v1(79.35,62.3) 79.98,61.66 79.98,60.34 80.64,59.68 80.64,55.43 v1(82.22,53.85) ; v1(66.9,138.29) 66.33,138.86 v1(66.33,142.76) ; v1(144.47,35.09) 148.79,30.77 158.6,30.77 159.33,31.51 162.69,31.51 163.3,32.12 R8829.2 ; 37.54,81.83 37.46,81.75 37.46,81.34 v1(37.18,81.07) ; v1(9.45,95.96) 9.84,95.57 9.84,94.27 5.67,90.11 5.61,90.11 5.41,89.9 5.41,77.96 6.75,76.61 6.75,75.61 6.32,75.17 6.32,74.6 4.35,72.63 4.35,59.62 5.54,58.43 5.54,54.78 v1(5.46,54.7)
  IN1 w0.127: v1(77.44,98.52) 77.89,98.96 77.89,100.88 77.58,101.19 77.58,102.07 75.84,103.8 75.84,104.59 73.13,107.3 73.13,117.3 74.37,118.54 74.37,129.35 69.7,134.02 69.7,135.5 v1(66.9,138.29) ; v1(5.46,54.7) 5.82,54.35 5.82,52.03 14.45,43.4 17.52,43.4 22.36,38.56 25.52,38.56 26.01,38.08 33.82,38.08 34.25,38.51 34.42,38.51 34.42,38.51 36.78,38.51 38.08,37.21 44.39,37.21 45.52,38.34 54.66,38.34 57.83,41.52 62.84,41.52 v1(63.73,40.63) 64.22,40.14 v1(64.22,36.67) ; v1(68.27,59.17) 67.87,58.77 67.87,56.34 65.33,53.81 61.17,53.81 60.86,54.12 59.63,54.12 58.8,53.28 55.36,53.28 54.72,52.64 53.59,52.64 52.58,51.63 45.8,51.63 45.38,52.05 41.97,52.05 41.69,52.34 39.21,52.34 38.34,53.2 35.66,53.2 v1(34.96,53.9) 34.96,55.04 34.11,55.9 33.66,55.9 33.52,56.03 32.86,56.03 32.76,55.93 29.69,55.93 29.51,56.11 28.28,56.11 28.05,56.34 27.67,56.34 27.07,55.74 26.27,55.74 26,56.01 24.51,56.01 v1(24.07,56.45) ; v1(75.8,26.16) 76.27,25.69 77.08,25.69 77.92,24.86 88.06,24.86 v1(88.21,24.7) ; v1(135.72,42.57) 134.43,41.28 134.35,41.2 v1(130.87,41.2) ; v1(102.34,23.18) 106.7,27.55 109.17,27.55 111.4,29.78 111.4,31.44 110.31,32.53 v1(110.31,35.8)
  IN2 w0.127: v1(82.22,53.85) 81.19,52.82 75.82,52.82 70.89,47.89 69.76,47.89 69.24,47.37 69.24,46.01 63.85,40.63 v1(63.73,40.63) ; v1(9.45,95.96) 7.78,97.63 7.78,98.67 7.11,99.34 7.11,101.38 6.62,101.88 6.62,103.69 7.15,104.22 7.15,109.19 7.91,109.95 7.91,111.22 v1(6.95,112.18) ; v1(102.34,23.18) 99.64,23.18 98.78,24.04 88.87,24.04 v1(88.21,24.7) ; v1(135.72,42.57) 138.62,42.57 144.89,36.3 144.89,35.51 v1(144.47,35.09) ; v1(68.27,59.17) 68.62,58.82 70.35,58.82 71.59,60.06 76.7,60.06 78.94,62.3 v1(79.35,62.3) 79.35,62.7 79.75,63.11 80.19,63.11 80.64,63.56 80.64,67.81 81.21,68.38 81.21,70.32 80.74,70.8 80.74,79.74 81.37,80.37 81.37,83.62 74.4,90.59 74.4,92.43 v1(73.38,93.44)
  BOTTOM w0.127: v1(130.87,41.2) 130.87,41.63 SR7889.1 129.94,41.12 129.1,41.12 v2(127.68,42.53) 127.56,42.66 118.46,42.66 117.27,43.86 105.22,43.86 PR118.1 104.28,40.74 105.13,39.89 105.13,36.54 106.04,35.63 110.13,35.63 v1(110.31,35.8) ; v1(135.72,42.57) 135.62,42.47 APR130.2 ; UU19.4 66.52,144.59 66.76,144.83 SR116.2 67.32,143.75 v1(66.33,142.76) ; UU64.4 73.7,148.72 73.33,148.35 73.33,146.95 73.02,146.65 73.02,141.19 70.09,138.25 67.93,138.25 67.89,138.29 v1(66.9,138.29) ; v1(34.96,53.9) 34.96,53.9 35.15,54.09 35.15,54.83 35.53,55.2 36.98,55.2 37.33,54.85 37.62,54.85 41.11,54.85 APR6.1 ; v1(24.07,56.45) 24.45,56.07 24.88,56.07 25.92,57.11 25.92,59.6 26.38,60.06 26.55,60.06 27.15,60.67 27.15,62 30.63,65.47 30.63,67.79 31.11,68.28 31.11,72.88 31.9,73.67 31.9,75.05 33.32,76.47 33.32,78.17 33.76,78.6 33.76,79.24 34.63,80.12 35.39,80.12 35.78,80.51 36.47,80.51 37.03,81.07 v1(37.18,81.07) ; v1(9.45,95.96) 9.44,95.96 U104.69 ; PR114.1 68.27,92.74 68.27,92.05 68.91,91.42 72.45,91.42 72.95,91.91 72.95,92.34 73.38,92.77 v1(73.38,93.44) 74.2,94.27 74.2,95.16 75.4,96.36 75.95,96.36 77.44,97.85 v1(77.44,98.52) ; v1(75.8,26.16) 75.8,29.82 71.35,34.28 68.1,34.28 65.7,36.67 v1(64.22,36.67) ; v1(20.57,114.54) 20.57,114.43 ECR148.1 C82.1 ; v1(102.34,23.18) UU65.4
SLP_S4_N_LED_B: length 5.2
  TOP w0.102: R8829.1 165.66,31.57 v1(165.87,31.57)
  BOTTOM w0.102: Q9345.1 163.76,33.21 v2(164.16,32.81) 165.39,31.57 v1(165.87,31.57)
SLP_S4_N_LED_C: length 13
  BOTTOM w0.102: R4815.2 166.78,36.67 166.36,36.25 Q9345.3 165.55,35.53 165.39,35.69 165.39,36.17 164.56,37 163.16,37 161.95,35.79 161.95,31.45 v2(161.74,31.25)
SLP_S4_N_LED_E: length 9.7
  TOP w0.102: CR5.1 165.71,29.97 v1(165.71,30.04)
  BOTTOM w0.102: v1(165.71,30.04) 166.72,31.05 v2(166.72,31.49) 166.72,33.82 165.58,34.97 164.62,34.97 163.76,35.82 Q9345.2
SLP_S4_SIO: length 8.5
  BOTTOM w0.102: U104.122 19.91,109.39 19.82,109.48 19.82,110.16 20.43,110.77 20.43,112.06 20.29,112.2 20.29,112.84 ECR148.2 19.68,113.08 19.58,113.18 19.58,114.16 20.47,115.05 v2(21.16,115.05)
SLP_S5_N: length 78.4
  TOP w0.127: v1(41.14,84.98) 41.14,84.98 41.14,84.48 U1.BC42
  IN1 w0.127: v1(32.03,60.38) 32.75,61.1 37.11,61.1 37.68,60.53 40.03,60.53 41.1,59.47 41.1,58.99 41.37,58.71 42.21,58.71 44.03,60.53 44.46,60.53 45.14,61.21 49.97,61.21 50.55,61.79 51.4,61.79 51.89,62.28 54.65,62.28 55.48,63.12 56.78,63.12 v1(57.48,63.82)
  IN2 w0.127: v1(53.26,65.55) 49.88,68.93 49.01,68.93 46.72,71.22 46.72,71.57 45.32,72.97 45.32,74 42.77,76.55 42.77,78.17 42.95,78.35 42.95,79.44 42.49,79.9 42.49,81.37 41.94,81.93 41.94,82.52 41.98,82.56 41.98,82.92 41.14,83.76 v1(41.14,84.98)
  BOTTOM w0.127: APR127.2 27.38,46.66 27.38,47.07 SR214.1 28.12,47.81 28.12,48.86 28.28,49.03 28.28,49.03 29,49.75 29.8,49.75 30.58,50.53 30.58,52.26 29.96,52.88 29.96,56.42 30.73,57.18 30.73,57.76 31.2,58.24 31.2,59.06 v2(31.61,59.46) 31.61,59.96 v1(32.03,60.38) ; v1(53.26,65.55) 53.49,65.55 53.95,65.09 55.89,65.09 56.92,65.09 57.48,64.53 v1(57.48,63.82)
SLP_SUS#: length 332.5
  TOP w0.089: U1.BD39 40.53,85.93 40.11,85.93 39.94,85.9 39.71,85.76 39.57,85.76 39.42,85.73
  TOP w0.102: 36.49,84.64 37.49,84.64 38.42,85.56 38.43,85.56 38.6,85.73 39.42,85.73
  TOP w0.127: v1(97.24,36.96) 100.05,39.77 110.2,39.77 113.88,36.08 135.55,36.08 136.17,36.7 142.37,36.7 143.5,35.58 145.08,35.58 145.79,34.86 161.72,34.86 v1(165.2,38.34) ; v1(50.3,45.34) 49.91,44.96 49.91,40.83 51.66,39.08 v1(51.66,39.06) ; v1(5.1,55.26) 5.1,55.49 4.1,56.49 4.1,57.88 SR217.1 4.1,58.77 4.1,72.73 5.26,73.89 5.26,75.35 4.9,75.71 4.9,90.11 5.4,90.61 5.46,90.61 5.79,90.94 5.79,94.69 6.72,95.62 v1(6.73,95.62) ; v1(36.09,84.24) 36.49,84.64
  IN1 w0.127: v1(5.1,55.26) 5.54,55.26 6.07,54.73 6.07,52.14 14.55,43.65 17.62,43.65 22.46,38.81 25.63,38.81 26.06,38.38 33.39,38.38 33.76,38.38 34.14,38.76 34.31,38.76 34.31,38.76 36.89,38.76 38.19,37.47 44.29,37.47 45.42,38.6 51.2,38.6 v1(51.66,39.06) 52.68,40.07 54.79,40.07 56.49,41.77 64.36,41.77 v1(65.25,42.66)
  IN2 w0.127: v1(65.25,42.66) 65.51,42.66 68.93,46.09 68.93,47.43 70.18,48.67 70.18,50.32 v1(71.54,51.68) 74.32,51.68 75.72,53.08 80.62,53.08 81.86,54.32 83.36,54.32 87.32,50.36 87.32,46.75 94.09,39.98 95.18,39.98 97.24,37.91 v1(97.24,36.96) ; v1(36.09,84.24) 37.34,84.24 38.12,83.46 38.12,82.6 38.13,82.59 38.13,80.74 37.86,80.47 37.86,78.67 37.4,78.21 37.4,77.7 37.82,77.28 37.82,73.57 38.95,72.44 38.95,69.68 39.38,69.25 39.38,67.86 39.89,67.35 43.27,67.35 45.13,65.48 45.13,64.87 48.11,61.9 48.11,59.68 47.28,58.85 47.28,57.43 45.71,55.86 45.71,54.88 47.14,53.44 47.98,53.44 49.25,54.71 49.92,54.71 50.02,54.62 50.27,54.37 50.27,54 49.58,53.3 49.58,51.79 50.39,50.98 50.39,45.44 v1(50.3,45.34)
  BOTTOM w0.127: SCB75.1 6.43,95.32 6.72,95.62 v1(6.73,95.62) 6.98,95.87 6.98,96 7.24,96.26 7.24,96.66 7.33,96.76 U104.71 ; PU10.3 66.76,45.18 66.75,45.16 66.28,45.16 C941635.1 65.63,43.04 v1(65.25,42.66) ; v1(71.54,51.68) 70.08,51.68 69.49,52.26 PR7607.1 ; v1(165.2,38.34) 164.95,38.09 Q9308.1 ; v1(97.24,36.96) v2(98.49,35.71) 98.82,35.39 98.82,33.54 98.8,33.53 98.8,33.1 98.82,33.09 98.82,28.73 100.61,26.94 100.61,25.12 102.01,23.71 104.51,23.71 PR64.1
SLP_SUS_LED: length 21.8
  TOP w0.102: CR1.2 167.25,23.85 v1(167.08,23.85)
  IN1 w0.102: v1(167.08,23.85) 167,23.93 167,36.87 167.18,37.05 167.18,37.82 v1(166.75,38.25)
  BOTTOM w0.102: v2(163.04,25.57) 164.76,23.85 v1(167.08,23.85) ; R4820.1 v1(166.75,38.25)
SLP_SUS_LED_D: length 8.4
  BOTTOM w0.102: Q9308.3 167.83,39.04 168,39.22 R4820.2 165.84,39.98 165.2,39.33 162.86,39.33 v2(162.51,39.69)
SLP_WLAN_N: length 90.1
  TOP w0.102: U1.BD42 40.18,84.32 39.37,84.32 39.27,84.42 38.73,84.42 37.45,83.15 37.03,83.15 36.32,82.44 36.09,82.44 35.66,82.01
  TOP w0.127: v1(66.56,54.33) 66.56,54 67.1,53.46 68.43,53.46 68.7,53.73 D524.1 ; v1(34.92,79.46) 34.92,80.26 35.66,81 35.66,82.01
  IN1 w0.127: v1(29.01,51.32) 30.06,51.32 30.44,50.94 33.66,50.94 34.22,50.38 37.04,50.38 39.29,48.13 42.53,48.13 42.59,48.2 50.91,48.2 51.37,48.66 52.5,48.66 54.99,51.14 54.99,51.98 55.8,52.8 60.2,52.8 60.95,53.55 65.78,53.55 v1(66.56,54.33)
  BOTTOM w0.127: v1(29.01,51.32) 28.02,52.31 27.41,52.31 26.9,52.82 26.9,53.62 SR218.1 28.39,55.11 28.39,57.66 29.05,58.33 29.36,58.33 29.83,58.81 29.83,60.58 32.1,62.86 v2(32.1,63.76) 32.1,67.3 33.45,68.65 35.11,68.65 36.22,69.76 36.22,72.43 34.82,73.82 34.82,77.32 SR7857.2 35.28,78.27 34.92,78.63 v1(34.92,79.46)
SMB_CLK: length 118.2
  TOP w0.127: v1(4.65,100.6) 5.18,100.07 5.41,100.07 5.86,100.52 9.53,100.52 10.03,100.02 11.61,100.02 12.42,100.83 13.71,100.83 14.86,101.97 15.34,101.97 v1(16.66,103.29) 17.73,103.29 18.36,102.66 21.74,102.66 21.99,102.91 23.64,102.91 26.59,105.86 v1(26.59,106.26) ; APR132.1 50.01,50.77 v1(49.93,50.77) ; v2(27.93,93.36) 28.28,93.02 v1(28.57,93.02) 28.81,92.78 SR160.2 30.39,92.78 SC17.1 31.14,92.02 32.2,92.02 32.38,91.85 32.65,91.85 33.19,91.3 34.77,91.3 35,91.54 37.27,91.54 37.29,91.51 37.85,91.51 37.88,91.53 39.45,91.53 39.45,91.54 39.71,91.54 39.93,91.76 U1.BE26 ; v1(15.01,102.61) 14.91,102.7 14.68,102.7 APR142.1
  IN1 w0.127: v1(28.57,93.02) 28.57,93.2 29.56,94.18 29.56,94.71 27.95,96.31 27.95,98.13 27.35,98.72 27.35,102.23 26.66,102.93 26.66,103.92 26.14,104.44 26.14,105.14 26.59,105.59 v1(26.59,106.26)
  IN2 w0.127: v1(49.93,50.77) 49.88,50.77 48.26,52.39 44.79,52.39 44.78,52.4 42.51,52.4 40.2,54.71 40.17,54.71 40.16,54.71 38.14,54.71 36.71,56.14 36.71,56.15 35.13,57.74 35.13,58.61 34.44,59.3 33.22,59.3 32.57,59.95 31.85,59.95 29.56,62.24 29.56,65.57 28.18,66.95 28.18,69.95 27.65,70.48 27.65,79.7 28.56,80.61 28.56,83.31 28.22,83.65 28.22,86.58 27.25,87.55 27.25,91.69 v1(28.57,93.02)
  BOTTOM w0.127: ECR137.2 5.19,100.89 4.9,100.6 v1(4.65,100.6) ; v1(16.66,103.29) 16.05,102.68 15.09,102.68 v1(15.01,102.61)
SMB_CLK_R_SSD: length 6.6
  TOP w0.102: J219.40 13.44,107.29 12.95,106.8 12.95,105.66 13.46,105.15 13.46,104.62 13.05,104.21 v2(13.05,103.53) 13.05,103.23 13.56,102.72 APR142.2
SMB_CLK_R_WLAN: length 7
  TOP w0.127: J218.60 49.45,51.07 49.49,51.03 49.49,50.45 APR132.2 50.49,49.45 51.46,49.45 51.61,49.6 52.73,49.6 52.81,49.52 v2(53.19,49.52) 53.57,49.52 53.71,49.38 SR7885.2
SMB_CLK_S0: length 278.3
  TOP w0.127: v1(89.13,68.06) 89.58,67.6 92.58,67.6 92.87,67.9 DIMM2.253 ; DIMM1.253 92.88,54.48 92.76,54.35 86.08,54.35 86.08,54.36 v1(86.08,54.36) ; J69.26 55.18,138.12 55.76,138.71 57.1,138.71 57.44,138.38 57.44,135.91 58.67,134.68 58.67,132.98 58.93,132.73 60.55,132.73 61.44,133.62 65.66,133.62 66.05,134.01 71.76,134.01 v1(71.77,134.02) ; v1(7.28,56.13) 6.65,56.76 6.65,60.26 7.49,61.1 7.49,63.24 6.5,64.23 6.5,65.66 4.86,67.3 4.86,72.42 5.61,73.17 6.95,73.17 6.96,73.17 8.2,73.17 8.48,73.45 8.48,75.62 6.32,77.78 6.32,85.89 6.62,86.19 6.62,87.47 R70280.2 ECR138.2
  IN1 w0.127: v1(89.13,68.06) 88.66,68.06 88.05,68.68 88.05,76.45 89.46,77.86 89.46,94.69 86.81,97.34 82.47,97.34 78.31,101.5 78.31,102.41 76.73,103.99 76.73,104.74 76.63,104.84 76.63,105.76 v1(77.04,106.16) 76.07,107.13 74.62,107.13 73.71,108.04 73.71,111.85 73.63,111.93 73.63,114.02 74.4,114.78 74.4,117.49 74.99,118.09 74.99,129.44 71.37,133.06 71.37,133.63 v1(71.77,134.02)
  IN2 w0.127: v1(7.28,56.13) 7.46,56.3 8.02,56.3 9.55,54.77 9.55,51.86 v1(10.09,51.33) 9.93,51.17 9.93,50.48 13.06,47.35 22.11,47.35 22.72,46.73 25.62,46.73 26.16,46.19 31.2,46.19 32.8,44.59 38.72,44.59 41.19,42.12 42.48,42.12 44.17,40.43 56.57,40.43 57.81,39.18 58.85,39.18 59.76,40.1 59.76,41.95 64.99,47.18 67.05,47.18 68.58,48.71 68.58,49.16 68.38,49.37 68.38,51.01 71.56,54.19 73.38,54.19 73.91,53.66 74.68,53.66 75.24,54.22 80.14,54.22 81.38,55.46 84.97,55.46 v1(86.08,54.36)
  BOTTOM w0.127: v1(89.13,68.06) 87.88,66.82 87.88,56.16 v2(87.66,55.94) v1(86.08,54.36) ; XDP3.53 8.65,50.64 9.33,51.32 10.08,51.32 v1(10.09,51.33) ; v1(77.04,106.16) 76.58,106.62 76.58,108.34 76.71,108.46 XDP1.53
SMB_CLK_S0_SIO: length 16.6
  TOP w0.127: ECR138.1 6.75,89.97 6.75,90.39 9.04,92.68 v2(9.86,92.68) 11.2,94.02 11.2,94.58 v1(11.76,95.14)
  BOTTOM w0.127: v1(11.76,95.14) 12.2,95.58 12.2,96.04 10.72,97.53 10.72,99.86 10.23,100.35 9.73,100.35 9.31,100.76 U104.81
SMB_CLK_SIO: length 4.1
  BOTTOM w0.127: U104.80 7.32,100.36 6.79,100.89 ECR137.1 6.35,101.16 6.17,101.34 v2(4.68,101.34)
SMB_DATA: length 121
  TOP w0.127: v1(29.2,93.21) 29.4,93.21 SR161.2 30.35,93.6 SC18.1 31.07,92.89 31.7,92.89 32.48,92.1 32.75,92.1 33.3,91.56 34.66,91.56 34.89,91.79 37.37,91.79 37.39,91.76 39.27,91.76 39.43,91.92 U1.BF26 ; v1(15.31,103.17) 14.95,103.17 APR143.1 ; v1(48.79,50.77) 48.73,50.7 48.73,49.36 49.76,48.33 50.46,48.33 APR133.1 ; v1(27.25,106.31) 27.25,106.16 23.74,102.66 22.1,102.66 21.85,102.4 18.06,102.4 17.8,102.66 v1(17.3,102.66) 16.41,102.66 15.47,101.72 15.01,101.72 13.87,100.57 12.52,100.57 11.71,99.76 9.93,99.76 9.67,100.01 v2(8.58,100.01) 8.33,100.27 6.2,100.27 5.97,100.03 5.97,99.91 5.62,99.56 5.03,99.56 v1(4.62,99.96)
  IN1 w0.127: v1(27.25,106.31) 27.25,105.89 26.39,105.03 26.39,104.55 26.91,104.03 26.91,103.04 27.61,102.34 27.61,98.83 28.21,98.23 28.21,96.42 29.81,94.81 29.81,93.82 v1(29.2,93.21)
  IN2 w0.127: v1(48.79,50.77) 47.43,52.13 44.69,52.13 44.68,52.14 42.41,52.14 40.1,54.45 40.06,54.45 40.06,54.46 38.03,54.46 36.46,56.03 36.46,56.05 33.47,59.04 33.11,59.04 32.46,59.7 31.73,59.7 29.3,62.12 29.3,65.4 27.13,67.58 27.13,68.06 27.39,68.33 27.39,79.81 28.3,80.72 28.3,83.05 27.96,83.39 27.96,86.48 26.99,87.45 26.99,92.05 28.39,93.45 28.95,93.45 v1(29.2,93.21)
  BOTTOM w0.127: v1(15.31,103.17) 15.87,103.72 16.84,103.72 17.3,103.26 v1(17.3,102.66) ; ECR136.2 4.63,99.97 v1(4.62,99.96)
SMB_DATA_R_SSD: length 5.3
  TOP w0.102: APR143.2 13.5,103.78 13.5,104.37 13.66,104.54 13.66,105.23 13.41,105.49 v4(13.41,105.86) 13.41,106.94 13.87,107.39 13.87,107.45 13.94,107.53 J219.42
SMB_DATA_R_WLAN: length 8.5
  TOP w0.127: J218.58 48.95,51.22 49.24,50.93 v2(49.24,49.58) 49.66,49.15 49.67,49.15 APR133.2 50.49,49.19 51.2,49.19 51.75,48.64 53.54,48.64 53.73,48.45 SR7886.2
SMB_DATA_S0: length 281.4
  TOP w0.127: DIMM1.254 92.63,50.03 92.35,50.31 92.35,52.16 90.47,54.04 88.49,54.04 88.24,53.79 v1(86.36,53.79) ; ECR139.2 R70279.2 6.36,87.5 6.36,86.29 6.07,86 6.07,77.68 7.29,76.45 7.29,73.86 6.86,73.42 5.51,73.42 4.61,72.52 4.61,67.19 6.25,65.56 6.25,64.13 7.24,63.14 7.24,61.2 6.4,60.36 6.4,56.4 7.11,55.69 7.74,55.69 v1(7.79,55.74) ; DIMM2.254 92.62,63.88 v1(89.1,67.4) ; J69.20 55.89,141.12 57.69,139.32 57.69,136.02 58.99,134.72 58.99,133.13 59.14,132.98 60.45,132.98 61.36,133.9 65.58,133.9 65.95,134.27 71.28,134.27 71.67,134.66 v1(71.8,134.66)
  IN1 w0.127: v1(89.1,67.4) 88.67,67.4 87.79,68.28 87.79,76.55 89.2,77.96 89.2,94.28 86.4,97.08 82.58,97.08 82.37,97.08 78.06,101.39 78.06,102.29 76.43,103.93 76.43,104.68 76.38,104.74 76.38,106.04 v1(76.25,106.16) 75.54,106.87 74.52,106.87 73.46,107.93 73.46,111.75 73.38,111.82 73.38,114.12 74.14,114.89 74.14,117.6 74.74,118.19 74.74,129.34 71.12,132.96 71.12,134.41 71.37,134.66 v1(71.8,134.66)
  IN2 w0.127: v1(86.36,53.79) 85.62,53.79 84.2,55.2 81.49,55.2 80.25,53.96 75.35,53.96 74.79,53.41 73.81,53.41 73.27,53.94 71.66,53.94 69.29,51.57 69.29,49.06 67.15,46.93 65.1,46.93 60.02,41.85 60.02,39.99 58.95,38.93 57.71,38.93 56.46,40.17 44.06,40.17 42.37,41.86 41.09,41.86 38.62,44.33 32.7,44.33 31.09,45.94 26.06,45.94 25.51,46.48 22.62,46.48 22.01,47.09 12.96,47.09 9.5,50.55 v1(9.5,50.81) 9.5,51.34 9.29,51.55 9.29,53.67 7.79,55.17 v1(7.79,55.74)
  BOTTOM w0.127: v1(9.5,50.81) 9.42,50.81 9.15,50.53 XDP3.51 ; XDP1.51 76.61,108.96 76.33,108.68 76.33,106.67 76.25,106.59 v1(76.25,106.16) ; v1(89.1,67.4) 88.25,66.55 88.25,63.13 88.62,62.76 v2(88.62,59.55) 88.62,56.05 v1(86.36,53.79)
SMB_DATA_S0_SIO: length 15.6
  TOP w0.127: ECR139.1 6.37,89.64 6.5,89.77 6.5,90.52 v2(10.65,94.67) v1(11.76,95.77)
  BOTTOM w0.127: v1(11.76,95.77) 10.26,97.27 10.26,99.83 10.13,99.96 U104.79
SMB_DATA_SIO: length 4.3
  BOTTOM w0.127: U104.78 7.49,99.56 7.08,99.97 ECR136.1 6.35,99.63 6.22,99.51 5.07,99.51 v2(4.68,99.13)
SMBALERT_N: length 118.4
  TOP w0.102: v1(13.92,104.05) 14.25,104.39 APR144.1 ; SR171.2 33.91,93 33.98,92.93 35.11,92.93 SR185.1 36.23,93.14 36.61,93.52 37.68,93.52 38.1,93.1 38.74,93.1 39.11,92.73 39.53,92.73 39.54,92.72 39.71,92.72 U1.BE25 ; SR171.2 33.06,92.59 32.34,92.59 32.15,92.77 32.15,94.07 v1(31.74,94.49) ; SR171.2 33.48,92.29 v2(33.65,92.12)
  IN1 w0.102: v1(36.19,73.14) 35.89,73.45 35.01,73.45 34.97,73.48 30.93,73.48 29.64,74.78 26.85,74.78 25.69,75.94 24.49,75.94 20.94,79.48 20.94,85.54 17.68,88.8 17.68,91.49 15.41,93.75 15.41,99.21 14.5,100.12 14.32,100.12 14.12,100.32 14.12,103.32 13.92,103.53 v1(13.92,104.05) ; v1(36.52,81.18) 36.36,81.18 35.8,81.74 35.8,82.81 34.82,83.79 33.96,83.79 32.31,85.44 32.31,86.82 31.71,87.43 31.71,88.34 31.57,88.48 31.57,89.41 32.01,89.85 32.01,90.93 32.35,91.26 32.35,92.16 32.18,92.33 32.18,94.05 v1(31.74,94.49)
  IN2 w0.102: v1(49.84,54.19) 49.12,54.19 48.13,53.2 47.01,53.2 45.46,54.75 45.46,56.07 47.04,57.65 47.04,58.95 47.86,59.78 47.86,61.8 44.85,64.81 44.85,65.42 43.17,67.11 39.66,67.11 39.14,67.63 39.14,69.15 38.71,69.58 38.71,72.2 38.1,72.81 36.52,72.81 v1(36.19,73.14) 37.46,74.41 37.46,75.32 36.24,76.54 36.24,77.94 37.23,78.93 37.23,79.58 36.52,80.29 v1(36.52,81.18)
  BOTTOM w0.102: R3139.1 49.84,54.77 v1(49.84,54.19)
SMBALERT_N_R_SSD: length 2.6
  TOP w0.102: J219.44 14.44,107.49 14.49,107.44 14.49,105.93 APR144.2
SMBALERT_N_R_WLAN: length 6.8
  TOP w0.102: J218.62 49.95,53.57 50.3,53.93 50.3,54.9 v1(49.81,55.39)
  BOTTOM w0.102: v2(52.16,56.25) R3139.2 51.29,55.73 51.2,55.82 50.07,55.82 49.81,55.55 49.81,55.39 v1(49.81,55.39)
SML0_CLK: length 7.9
  TOP w0.102: 38.23,92.32 38.3,92.24 38.76,92.24 38.82,92.18 39.1,92.18 39.36,92.45 U1.BF25
  TOP w0.127: v2(36.25,92.44) v1(36.92,93.11) 37.11,93.11 37.44,92.78 37.44,92.57 37.69,92.32 38.23,92.32
  BOTTOM w0.127: v1(36.92,93.11) 36.45,93.11 SC19.1 35.46,93.23 34.05,93.23 SR163.2
SML0_DATA: length 10.1
  TOP w0.102: U1.BE24 40.22,92.74 40.27,92.69 40.27,92.34 40.11,92.18 39.84,92.18 39.84,92.18 39.52,92.18 39.52,92.18 39.39,92.18 39.18,91.98 37.79,91.98 37.73,92.04
  TOP w0.127: v1(37.01,92.48) 37.01,92.48 37.01,92.47 37.06,92.47 37.49,92.04 37.73,92.04
  BOTTOM w0.127: v2(32.03,92.74) 32.5,92.27 33.27,92.27 SR164.2 33.98,92.98 35.34,92.98 SC20.1 36.94,92.55 37.01,92.48 v1(37.01,92.48)
