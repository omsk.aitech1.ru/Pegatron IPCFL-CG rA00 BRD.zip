# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VSB&+3P3VA_PG: length 2.9
  BOTTOM w0.203: 107.76,30.94 108.04,30.65 PU4.7
  BOTTOM w0.254: PR58.2 107.17,32.39 v2(107.17,31.8) 107.17,31.52 107.76,30.94
+5VSB_BST: length 2.4
  BOTTOM w0.508: v2(110.61,23.07) 108.87,24.8
+5VSB_BST_RC: length 2
  BOTTOM w0.254: v2(109.07,20.82) 108.87,21.01 108.87,22.72
+5VSB_CS: length 2.9
  BOTTOM w0.203: PU4.1 106.93,28.15 106.41,27.63
  BOTTOM w0.457: PR60.2 105.56,26.83 v2(105.71,26.98) 105.76,26.98 106.41,27.63
+5VSB_EN: length 5.2
  BOTTOM w0.127: PR70.2 PR64.2 105.51,25.05 105.55,25.02 v2(105.95,25.02) 106.47,25.54 106.47,26 107.64,27.17 PU4.20
+5VSB_FB: length 8.3
  BOTTOM w0.203: 106.54,28.44 106.64,28.55 PU4.2
  BOTTOM w0.254: v2(100.82,30.71) 100.99,30.71 102.4,29.3 102.4,28.25 PR62.1 PR61.2 PC61.2 105.98,27.89 106.54,28.44
+5VSB_FB_RC: length 19.9
  TOP w0.254: PJP6.2 106.67,17.66 107.13,18.12 v1(107.52,18.12)
  IN1 w0.254: v1(103.25,26.33) 103.25,26.16 102.72,25.63 102.72,24.6 101.17,23.05 101.17,20.84 101.7,20.31 105.33,20.31 v1(107.52,18.12)
  BOTTOM w0.254: v1(107.52,18.12) v2(108.81,18.12)
  BOTTOM w0.432: PC61.1 PR61.1 102.84,27.05 PC62.1
  BOTTOM w0.457: v1(103.25,26.33) 102.77,26.82 PC62.1
+5VSB_HG: length 27.6
  BOTTOM w0.635: v3(132.46,21.1) 131.88,21.67 125.54,21.67 121.83,17.97 115.54,17.97 112.04,21.47 112.04,23.56 110.73,24.87
  vias: v2(110.87,24.99)
+5VSB_HG_R: length 3.2
  TOP w0.127: 133.86,16.27 134.8,17.21 v2(134.8,19.07)
+5VSB_LG: length 37.6
  TOP w0.635: PR55.1 v1(132.56,11.67)
  BOTTOM w0.635: 113.22,24.91 v2(115.53,22.6) 116.95,21.18 116.95,19.93 117.77,19.11 121.36,19.11 125.06,22.82 132.67,22.82 133.68,21.81 133.68,20.61 132.76,19.7 132.76,15.92 131.99,15.14 131.99,12.25 v1(132.56,11.67)
+5VSB_LG_R_D: length 1.1
  BOTTOM w0.635: v2(131.77,9.29) v1(131.77,8.17)
+5VSB_PHASE: length 22.1
  BOTTOM w0.635: 122.1,14.54 117.35,14.54 112.44,19.45 107.52,19.45 v2(106.73,20.23) 105.95,21.02 105.95,23.84 106.26,24.15
  vias: v3(126.44,14.26) v3(126.41,13.25) v3(126.41,12.28) v3(126.44,11.24)
+5VSB_SN_C:
  vias: v2(126.06,10.23)
+5VSB_VO1:
  vias: v2(111.01,27.91)
+19V_VIN: length 8.5
  TOP w0.635: 160.39,161.63 J1.5 ; 164.31,161.63 J1.6
  BOTTOM w0.635: J1.6 164.31,161.49 ; J1.6 164.31,163.8 ; J1.6 165.19,162.67 ; J1.5 160.39,163.8 ; J1.5 160.39,161.49 ; J1.5 159.51,162.67
  vias: v3(161.21,160.85) v3(161.85,160.21) v3(162.48,160.85) v3(163.12,160.21) v3(163.75,160.85) v3(164.39,160.21)
+19V_VIN_R_O2Q4: length 4.5
  BOTTOM w0.406: O2Q4.2 38.63,110.81 38.33,111.11 38.33,111.83 38.68,112.18 R93117.2 R93116.1 37.09,112.5 v2(36.85,112.74)
+19VA:
  vias: v2(166.83,149.47) v3(166.44,151.7) v3(166.44,148.66) v3(167.33,151.7) v3(167.33,148.66)
+19VA_IN:
  vias: v1(165.96,156.48) v1(166.6,156.48) v1(167.23,156.48) v2(165.96,155.67) v3(163.6,156.45) v3(163.6,155.56) v3(164.49,156.45) v3(164.49,155.56)
+19VA_IN_ID: length 9.4
  TOP w0.457: J1.9 162.35,163.52 161.7,164.17 159.89,164.17 159.2,163.47 159.2,162.15 158.66,161.61 PR8.1 158.39,161.13 158.06,161.46 PC941620.1
+19VA_IN_R_C:
  vias: v2(165.2,152.26)
+19VA_R_SEN: length 50.4
  TOP w0.254: PR11.1 164.07,144.63 163.9,144.47 163.9,144.1 165.12,142.89 165.12,140.86 165.3,140.68 165.95,140.68 PC5.1 PC941497.1 168.4,140.92 v1(168.4,140.92) ; PU30.4 v1(156.6,167.35)
  IN1 w0.254: v1(168.4,140.92) 167.98,140.92 167.84,141.07 167.84,141.95 168.71,142.81 168.71,156.79 166.55,158.94 161.64,158.94 159.43,161.15 158.22,161.15 157.36,162.01 157.36,166.05 156.6,166.8 v1(156.6,167.35)
  BOTTOM w0.254: v1(156.6,167.35) 157.14,167.88 158.8,167.88 159.25,168.33 v2(161.37,168.33)
+19VA_SB_SEN: length 47.7
  TOP w0.254: v1(168.38,140.03) 168.32,140.08 PC941666.1 PC5.2 165.95,140.32 165.15,140.32 164.77,140.71 164.77,142.74 163.55,143.96 163.55,144.44 163.36,144.63 PR12.1 ; v1(155.95,167.35) PU30.5
  IN1 w0.254: v1(168.38,140.03) 167.49,140.92 167.49,142.1 168.35,142.96 168.35,156.64 166.41,158.59 161.5,158.59 159.29,160.8 158.04,160.8 157,161.83 157,165.87 155.95,166.92 v1(155.95,167.35)
  BOTTOM w0.254: v2(156.46,168.11) 155.95,167.6 v1(155.95,167.35)
+V3P3A_V1P8A_PCH_SPI: length 25.6
  TOP w0.203: v1(45.85,83.66) 45.85,83.36 U1.AN44
  IN1 w0.254: v1(45.85,83.66) 45.88,83.62 45.88,82.48 44.04,80.63 44.04,80.34 43.2,79.49 v1(43.2,77.79) ; v1(52.98,70.4) 52.83,70.56 51.41,70.56 50.84,69.98 49.31,69.98 v1(48.97,69.64)
  IN2 w0.254: v1(43.2,77.79) 43.2,76.57 45.64,74.13 45.64,73.1 47.04,71.7 47.04,71.57 v1(48.97,69.64)
  BOTTOM w0.254: v1(48.97,69.64) 49.54,69.07 v2(49.54,68.96)
  BOTTOM w0.305: v1(52.98,70.4) 52.75,70.17 51.99,70.17 51.71,69.89 HR61.2
+V3P3A_V1P8A_VCCPAZIO: length 5.2
  BOTTOM w0.254: HR67.2 36.35,101.21 36.9,100.65 v2(36.9,100.52) 37.16,100.27 39.11,100.27 ; HR425.1 38.42,99.57 39.11,100.27 ; 39.11,100.27 C200.1
+V3P3A_V1P8A_VCCPGPPA: length 2.5
  TOP w0.254: v1(45.37,89.78) 45.88,89.27 U1.AN32
  BOTTOM w0.254: v2(45.54,90.72) 45.37,90.55 v1(45.37,89.78)
  BOTTOM w0.508: v1(45.37,89.78) 45.47,89.68 HR74.2
+V3P3A_V1P8A_VCCPGPPD: length 1.1
  TOP w0.254: U1.AN24 45.62,93.39 v1(45.62,93.94)
+VCCA_XTAL_1P05: length 10.1
  TOP w0.203: U1.P3 55.36,103.4 U1.P2 55.5,103.85 55.5,104.61 55.39,104.72 55.39,105.44
  TOP w0.508: v1(56.16,108.08) 55.88,107.8 55.88,105.93 55.39,105.44
  BOTTOM w0.508: v1(56.16,108.08) 56.01,107.93 v2(56.01,107.36) 56.45,106.91 HC12.2 HC11.2 HR423.1
+VCCAMPHYPLL_1P05: length 10
  TOP w0.508: 60.53,80.23 60.93,79.82 v1(62.71,79.82) ; v1(62.7,81.28) 63.75,82.33 64,82.33 v2(64.73,83.06) 65.32,82.47 HR422.1
  BOTTOM w0.508: v1(62.7,81.28) 63.02,81.6 HC19.2 HC20.2 63.38,79.32 63.14,79.09
+VCCDPHY_1P24V: length 19.9
  TOP w0.229: v1(38.35,102.71) 38.57,102.49 38.88,102.49 U1.BG5
  IN1 w0.508: v1(38.35,102.71) 38.95,102.71 39.24,103 39.3,103 40.49,104.18 41.04,104.18 41.98,103.24 ; v1(47.57,92.83) 47.57,93.36 46.2,94.73 46.2,96.77 44.75,98.21 44.75,99.23 43.94,100.04 43.94,100.42 43.53,100.83
  BOTTOM w0.254: v2(48.26,91.99) 48.26,92.14 v1(47.57,92.83)
  BOTTOM w0.457: C86.1 36.41,102.49 36.71,102.79 38.27,102.79 v1(38.35,102.71)
  BOTTOM w0.508: C86.1 HR73.1
+VCCDSW_1P05V: length 9
  TOP w0.203: U1.BG45 U1.BG46 38.94,81.99 38.59,81.64 38.59,81.48 38.39,81.27 38.39,80.48 38.17,80.27 38.17,80 36.27,78.09 34.95,78.09 34.33,77.48 34.33,76.94 33.98,76.6 HC15.2
+VCCGT: length 25
  TOP w0.635: PCE97035.1 152.35,140.16 ; PCE97035.1 151.42,141.09 ; PCE97035.1 150.49,140.16 ; PCE97035.1 151.42,139.24 ; 162.66,141.09 PCE97034.1 ; PCE97034.1 161.73,140.16 ; PCE97034.1 163.59,140.16 ; PCE97034.1 162.66,139.24 ; PCE97038.1 157.08,141.29 ; PCE97038.1 157.08,139.54 ; PCE97038.1 156.21,140.42 ; PCE97038.1 157.96,140.42 ; 166.67,118.43 PCE97033.1 ; PCE97033.1 165.44,119.67 ; PCE97033.1 167.9,119.67
  IN1 w0.635: 151.42,139.31 PCE97035.1 150.57,140.16
  BOTTOM w0.127: 141.37,106.82 141.37,107.18 ; 141.4,107.74 141.4,108.09
  BOTTOM w0.254: PJP89003.2 143.38,123.51 v1(143.23,123.66)
  BOTTOM w0.635: 152.44,140.16 PCE97035.1 ; PCE97035.1 151.42,139.15 ; PCE97035.1 150.4,140.16 ; 165.7,119.67 PCE97033.1 166.67,118.49 ; 156.12,140.42 PCE97038.1 157.08,139.45
  vias: v1(128.8,112.21) v1(128.82,109.4) v1(129.54,114.47) v1(130.21,114.47) v1(130.21,109.4) v1(130.92,117.09) v1(130.92,114.47) v1(131.16,109.41) v1(131.61,114.47) v1(132,109.41) v1(132.32,114.47) v1(132.95,114.47) v1(133.58,112.89) v1(133.55,112.21) v1(133.84,117.14) v1(133.92,117.78) v1(134.11,114.57) v1(135.08,114.04) v1(135.49,110.62) v1(136.36,110.62) v1(137.26,117.92) v1(137.3,115.2) v1(137.28,113.37) v1(137.28,111.51) v1(137.28,110.62) v1(139.1,124.31) v1(139.14,120.63) v1(139.1,117.02) v1(139.13,115.2) v1(139.13,113.37) v1(139.1,111.55) v1(140.03,123.38) v1(140.02,120.63) v1(140.93,118.83) v1(140.93,117.02) v1(140.93,115.2) v1(140.96,120.63) v1(140.98,113.37) v1(141.85,120.63) v1(141.87,122.48) v1(142.79,122.48) v1(142.79,120.63) v1(142.81,118.87) v1(142.81,117.02) v1(142.79,113.37) v1(142.86,115.2) v1(143.42,122.48) v1(143.42,120.63) v1(143.42,113.37) v1(143.55,118.87) v1(143.55,117.02) v1(143.55,115.2) v1(144.06,122.48) v1(144.06,113.37) v1(144.18,120.63) v1(144.18,118.87) v1(144.18,117.02) v1(144.18,115.2) v1(144.69,122.48) v1(144.69,113.37) v1(144.82,120.63) v1(144.82,118.87) v1(144.82,117.02) v1(144.82,115.2) v1(145.33,122.48) v1(145.33,113.37) v1(145.45,120.63) v1(145.45,118.87) v1(145.45,117.02) v1(145.45,115.2) v1(145.96,122.48) v1(145.96,113.37) v1(146.09,120.63) v1(146.09,118.87) v1(146.09,117.02) v1(146.09,115.2) v3(147.95,122.32) v3(147.95,121.43) v3(147.95,120.54) v3(147.95,119.65) v3(150.85,138.24) v3(150.85,137.35) v3(150.85,136.44) v3(150.85,135.55) v3(150.85,134.66) v3(150.85,133.77) v3(151.38,115.71) v3(151.38,114.82) v3(151.38,113.93) v3(151.38,113.05) v3(151.74,138.24) v3(151.74,137.35) v3(155.18,136.24) v3(155.18,135.35) v3(155.18,134.46) v3(155.18,133.57) v3(156.34,113.81) v3(156.36,112.84)
+VCCIO_EN: length 116.3
  TOP w0.102: v1(52.21,141.76) 52.19,141.75 52.02,141.75 51.8,141.53 PR29.2 51.8,140.69 52.2,140.3 52.2,139.87 51.94,139.61 51.94,138.98 52.4,138.52 R99518.2 51.93,138.51 51.9,138.48 PC24.1 51.02,138.05 PU3.14 ; R3.1 80.91,76.51 v1(81.17,76.77)
  IN1 w0.102: v1(65.63,142.1) 70.5,137.23 81.62,137.23 85.65,133.21 86.47,133.21 86.9,132.77 86.9,132.39 87.98,131.31 88.53,131.31 v1(88.83,131)
  IN2 w0.102: v1(52.21,141.76) 52.22,141.76 52.22,141.75 52.38,141.59 54.69,141.59 54.97,141.3 57.88,141.3 58.45,141.87 65.31,141.87 65.54,142.1 v1(65.63,142.1)
  BOTTOM w0.102: v1(81.17,76.77) 81.68,77.28 v2(82.24,77.28) 83.81,77.28 84.13,76.96 85.47,76.96 88.59,80.08 88.59,89.74 87.72,90.62 87.72,94.21 85.57,96.35 85.57,104.06 92.2,110.69 92.2,117.88 93.71,119.39 93.71,121.61 92.42,122.9 92.42,127.23 89.55,130.09 89.43,130.09 88.83,130.69 v1(88.83,131)
+VCCIO_EN_DISCH_A: length 2.1
  TOP w0.254: Q7.3 78.95,77.12 79.15,76.92 R3.2 v2(78.28,76.51)
+VCCIO_FB: length 4.4
  TOP w0.254: v1(47.69,131.28) 47.43,131.28 47.18,131.54 PR35.2 47.6,132.44 47.68,132.44 PR37.2 48.39,132.43 48.47,132.43 PC35.1 PR39.1
+VCCIO_FB_R: length 102.7
  TOP w0.254: PJP6801.1 77.02,100.63 v1(77.45,100.2) ; v1(89.15,102.22) 89.15,107.79 91.83,110.46 91.83,117.69 93.55,119.41 93.55,120.03 94.12,120.61 94.97,120.61 v1(95.32,120.25) ; v1(45.77,131.59) 45.91,131.59 PR35.1
  IN1 w0.254: v1(75.16,138.55) 75.16,138.5 76.14,137.51 81.74,137.51 85.77,133.49 86.58,133.49 87.07,133 87.59,133 87.88,132.71 87.88,132.16 88.41,131.63 89.31,131.63 89.7,131.25 v1(89.7,130.74)
  IN2 w0.254: v1(77.45,100.2) 80.63,100.2 82.12,101.69 83.18,101.69 84.15,102.66 88.72,102.66 v1(89.15,102.22) ; v1(45.77,131.59) 47.2,130.16 49.83,130.16 50.82,131.15 51.56,131.15 51.73,130.99 56.42,130.99 57.29,131.86 60.41,131.86 62.31,133.76 62.98,133.76 63.87,134.65 69.37,134.65 72.74,138.02 74.9,138.02 75.16,138.27 v1(75.16,138.55)
  BOTTOM w0.254: v1(95.32,120.25) 95.32,120.74 93.56,122.51 93.56,123.56 92.98,124.14 92.98,127.39 89.7,130.66 v1(89.7,130.74)
  BOTTOM w0.508: v2(74.27,139.54) 74.33,139.54 75.16,138.71 v1(75.16,138.55)
+VCCIO_LDRV_A: length 62.1
  TOP w0.254: v1(67.64,110.28) 67.23,110.68 67.23,115.33 65.51,117.06 65.51,120.64 61.68,124.47 61.68,125.88 58.69,128.88 56.99,128.88 v1(56.44,129.43) ; v1(54.39,131.84) 53.95,131.41 51.34,131.41 PR42.1 49.96,132.79 PR39.2 PC35.2 49.41,133.26 49.73,133.26 50.52,134.06 PU3.6 ; PC28.2 v1(83.41,103.8)
  IN1 w0.254: v1(76.48,101.72) 74.83,103.37 74.83,104.18 73.46,105.55 72.06,105.55 v1(70.74,106.87)
  BOTTOM w0.254: v1(67.64,110.28) 69.71,110.28 70.78,109.21 70.78,106.91 v1(70.74,106.87) ; v1(76.48,101.72) 76.48,102.34 77.29,103.15 80.58,103.15 81.58,102.15 82.37,102.15 83.06,102.83 83.06,103.44 v1(83.41,103.8) ; v1(54.39,131.84) 54.39,131.58 v2(55.23,130.74) 56.44,129.53 v1(56.44,129.43)
+VCCIO_LDRV_C: length 102.6
  TOP w0.254: v1(50.87,132.81) 50.61,133.07 50.61,133.59 51.02,134 PU3.7
  TOP w0.457: 80.45,103.8 PC28.1 81.01,104.38
  IN1 w0.508: v1(98.88,120.27) 96.18,120.27 95.58,120.87 94.5,120.87 94.45,120.83 93.22,119.6 87.58,119.6 86.6,120.58 86.6,120.75 86.24,121.11 82.89,121.11 81.42,119.64 81.42,116.87 81,116.45 81,114.29 79.98,113.27 79.35,113.27 78.97,112.89 v1(78.97,106.16)
  IN2 w0.508: v1(79.65,140.91) 77.57,140.91 77.35,140.69 75.95,140.69 74.74,139.49 72.7,139.49 71.35,138.14 70.13,138.14 67.47,135.49 64.84,135.49 64.84,135.49 63.51,135.49 62.63,134.61 61.97,134.61 60.06,132.7 54.39,132.7 54.12,132.44 53.58,132.44 53.2,132.06 51.61,132.06 50.87,132.79 v1(50.87,132.81)
  BOTTOM w0.508: v1(79.65,140.91) 80.74,139.82 83.16,139.82 83.95,139.03 85.81,139.03 v2(87.17,137.67) 89.03,137.67 93.23,133.48 93.23,132.71 94.41,131.53 94.41,129.99 96.68,127.72 96.68,126.17 97.46,125.4 97.46,124.97 97.82,124.61 97.82,123.12 98.88,122.06 v1(98.88,120.27)
+VCCIO_LDVR: length 5.5
  TOP w0.457: PC30.1 81.99,105.69
  BOTTOM w0.254: v2(83.69,102.94) 83.93,103.17 83.93,105.46 83.24,106.15 82.69,106.15 82.24,105.7 v1(82.07,105.7)
+VCCPDSW_3P3V: length 8.4
  TOP w0.254: 35.61,77.28 36.22,77.28 36.5,77.56 36.73,77.56 38.5,79.34 38.94,79.34 39.82,80.22 U1.BE49 39.82,80.81 U1.BE48
  TOP w0.508: R99515.2 29.78,69.12 SCB127.1
  vias: v2(30.48,72.61)
+VCCPHVLDO_1P8V: length 1.1
  TOP w0.254: U1.AF20 49.49,94.77 v1(49.11,95.15) U1.AF19
  vias: v2(48.18,93.28)
+VCCPLL_OC_W20MIL: length 4.8
  TOP w0.305: XU1.AJ9 v1(112.22,105.12)
  BOTTOM w0.254: v1(112.22,105.12) 111.86,104.76 v2(111.86,104.38)
  BOTTOM w0.457: HR64.2 111.69,106.5 111.9,106.3 111.9,105.45 v1(112.22,105.12) 112.57,105.47 HR63.2
+VCCPRIM_1P05: length 12.1
  TOP w0.254: U1.V27 53.45,91.68 v1(53.83,91.3) 53.83,91.28 53.45,90.9 U1.V28 ; U1.AB30 51.05,90.13 v1(50.67,90.51) 50.28,90.13 U1.AD30 ; v1(49.89,95.16) U1.AD20 U1.AB20 ; U1.V31 53,89.73 v1(52.98,89.73) 52.98,89.73 52.94,89.69 U1.W31 ; U1.W20 v1(52.2,95.17) ; U1.AB27 51.01,91.63 50.8,91.42 v1(50.66,91.29) ; v1(49.88,93.61) 50.27,93.22 U1.AD23 ; v1(50.66,91.29) 50.7,91.25 U1.AB28 ; v1(50.66,91.29) U1.AD28 ; v1(52.2,93.6) U1.AA23 51.71,93.34 51.17,93.34 U1.AB23 ; U1.U26 54.21,92.22 v1(54.21,92.31) 54.07,92.45 U1.V25 ; U1.AD31 49.9,89.72 v1(49.9,89.72) ; U1.AE17 50.18,96.49 v1(50.24,96.43) ; v1(49.88,92.06) 50.27,91.68 U1.AD27
  vias: v1(49.88,90.52) v1(52.22,94.4) v1(52.98,95.16) v1(52.98,94.38) v1(53.85,89.88) v1(60.96,104.76) v1(61.59,104.76) v1(63.57,91.52) v1(64.1,92.42) v1(66.5,91.58) v1(67.64,91.68) v1(67.82,90.36) v1(67.82,88.22) v1(67.82,87.58) v1(67.82,86.95) v1(67.82,86.31) v2(65.61,96.38) v3(62.25,92.31) v3(62.81,91.61) v3(63.32,92.34) v3(63.5,95.21) v3(64.03,93.77) v3(64.32,91.68) v3(64.41,95.19) v3(64.95,93.77) v3(65.21,91.77) v3(65.76,93.31) v3(66.34,92.62)
+VCCPRIM_1P8_3P3: length 7.9
  TOP w0.254: U1.AP26 45.57,92.23 v1(45.57,92.27) U1.AN26
  BOTTOM w0.457: v1(45.57,92.27) 45.65,92.19 SCB124.2 45.65,91.57 46.81,90.41 46.81,89.91
  BOTTOM w0.508: 46.81,89.91 46.81,89.59 47.3,89.11 47.31,89.11 48.08,88.34 ; HR59.2 44.25,93.26 45.23,92.27 v1(45.57,92.27)
  vias: v1(48.99,87.24) v1(50.37,87.24) v2(48.69,88.05)
+VCCPRIM_1P8V: length 108.9
  TOP w0.254: U1.AG20 48.72,94.77 48.37,95.13 48.37,95.14 v1(48.33,95.18) 48.35,95.19 48.37,95.19 U1.AG19 ; v1(39.84,47.01) 40.05,46.8 40.05,46.15 SR7997.1 40.23,45.32 40.23,45.05 v1(39.81,44.63) ; v1(41.96,99.56) 41.72,99.32 U1.BB11 ; v1(38.06,97.58) 37.68,97.96 35.35,97.96 35.04,98.26 33.58,98.26 33.25,98.59 31.72,98.59 31.65,98.66 30.42,98.66 30.19,98.43 29.49,98.43 28.81,97.75 28.58,97.75 27.59,96.76 v1(27.59,94.55) ; v1(46.48,97.37) U1.AN15 U1.AR15 ; v1(37.86,47.41) 38.07,47.2 38.07,46.38 SR7996.1
  IN1 w0.254: v1(49.48,45.91) 48.84,45.28 46.75,45.28 46.38,45.65 43.88,45.65 42.87,44.63 v1(39.81,44.63)
  IN2 w0.254: v1(39.84,47.01) 38.53,47.01 38.13,47.41 v1(37.86,47.41) ; v1(27.59,94.55) 27.59,94.02 26.67,93.11 26.67,87.25 27.65,86.28 27.65,83.26 27.96,82.95 27.96,80.99 27.07,80.11 27.07,77.36 26.22,76.51 26.22,75.8 27.08,74.95 27.08,68.46 26.99,68.38 26.81,68.19 26.81,67.45 28.99,65.27 28.99,61.99 31.62,59.36 32.29,59.36 33.64,58.01 34.05,58.01 35.9,56.16 35.9,56.14 37.9,54.14 39.93,54.14 42.24,51.82 44.55,51.82 49.48,46.89 v1(49.48,45.91) ; v1(38.06,97.58) 38.06,98.25 39.52,99.71 40.11,99.71 40.45,99.37 41.77,99.37 v1(41.96,99.56)
  BOTTOM w0.254: C941643.1 43.92,98.77 SR7924.2
  BOTTOM w0.508: v1(48.33,95.18) 48.33,95.21 48.18,95.37 48.18,96.41 48.21,96.43 48.21,96.88 48.21,96.88 48.21,97.37 SR7921.2 47.11,97.39 ; SR7919.2 42.67,99.2
  vias: v2(46.58,98.16)
+VCCSA: length 95.4
  IN2 w0.254: v1(117.07,43.42) 116.64,43.86 109.63,43.86 107.16,46.32 99.25,46.32 98.22,47.35 98.22,48.28 97.36,49.14 97.36,52.55 95.73,54.18 95.73,56.12 87.98,63.87 87.98,76.79 90.46,79.26 90.46,95.76 89.98,96.24 89.98,102.85 92.73,105.6
  BOTTOM w0.254: R651.1 118.91,36.25 120.19,37.53 120.22,37.59 120.22,40.48 v2(119.15,41.54) 118.95,41.54 v1(117.07,43.42)
  vias: v1(65.85,114.57) v1(65.85,113.93) v1(65.85,113.29) v1(65.85,112.66) v1(65.85,112.02) v1(65.85,111.34) v1(108.58,114.26) v1(109.5,117.9) v1(109.46,115.2) v1(109.49,114.26) v1(109.46,113.34) v1(109.48,111.52) v1(109.49,110.6) v1(110.41,114.26) v1(110.37,113.32) v1(110.4,110.6) v3(64.54,114.75) v3(64.54,112.87) v3(64.62,115.71) v3(64.59,113.78) v3(64.57,111.95) v3(64.57,110.94) v3(64.59,110.05) v3(99.6,115.43) v3(100.52,115.43) v3(101.44,115.44)
+VCCSA_BOOT: length 3.8
  TOP w0.279: PU3.13 51.52,137.35 51.94,137.77 v3(52.16,137.77)
  BOTTOM w0.635: PR28.1 53.9,137.53 53.26,138.17 v2(53.08,138.17) 52.55,138.17 v3(52.16,137.77)
+VCCSA_BOOT_25: length 8
  BOTTOM w0.508: PR28.2 55.62,135.88 55.59,135.85 55.59,134.97 55.61,134.95 55.95,134.61 55.97,134.59 56.38,134.19 PC23.2 57.06,134.19 57.57,134.7 57.57,135.76 57.92,136.12 PD4.3 v2(58.59,134.69)
+VCCSA_FB_A: length 5.9
  TOP w0.254: PU3.3 48.97,135.68 48.79,135.5 48.79,135.27 48.49,134.97 PC37.2 PR44.1 47.18,133.8 PR47.1 47.19,132.96 47.56,133.33 47.89,133.33 v2(48.21,133.64)
+VCCSA_HG_D: length 30.6
  TOP w0.279: v3(52.83,137.13) 52.83,136.96 52.55,136.68 PU3.12
  TOP w0.635: 33.37,121.23 34.01,121.87 34.01,123.03 v3(34.54,123.56)
  IN2 w0.635: v3(52.83,137.13) 52.44,136.74 51.46,136.74 50.76,137.44 49.66,137.44 49.03,136.81 48.44,136.81 46.07,134.43 44.63,134.43 44.24,134.04 43.01,134.04 38.05,129.07 38.05,127.22 34.54,123.72 v3(34.54,123.56)
  BOTTOM w0.127: v3(52.83,137.13) 52.29,136.59 v2(51.94,136.59)
+VCCSA_ILIM_A: length 4.8
  TOP w0.254: v1(54.93,135.21) 54.72,135.21 54.39,134.88 PR34.1 52.84,135.32 52.77,135.32 52.41,135.68 PU3.10
  BOTTOM w0.254: v2(55.64,133.94) 55.64,134.14 54.93,134.85 54.93,135.21 v1(54.93,135.21)
+VCCSA_ILIM_R_A: length 46.5
  TOP w0.254: PJP3.2 34.34,114.44 34.59,114.18 v1(34.74,114.18) ; PR34.2 53.9,134.04 53.92,134.06 v1(53.92,134.06)
  BOTTOM w0.254: v1(53.92,134.06) 54.31,133.68 v2(54.31,132.81) 55.05,132.06 55.05,131.65 55.32,131.38 55.73,131.38 56.93,130.18 56.93,129.52 57.22,129.23 58.62,129.23 59.66,128.19 59.66,126.65 58.34,125.33 58.34,123.96 57.6,123.22 56.56,123.22 55.99,123.79 45.34,123.79 43.5,121.95 40.56,121.95 39.3,120.69 36.76,120.69 35.63,119.56 35.63,118.21 34.74,117.32 v1(34.74,114.18)
+VCCSA_IN_PQ: length 35.9
  TOP w0.254: JP1.1 27.74,120.23 28,120.49 29.65,120.49 32.1,122.94 v1(32.1,123.51) ; v1(44.14,135.52) 43.22,136.45 43.22,138.23 44.5,139.52 48.03,139.52 48.13,139.41 PR26.1
  IN2 w0.254: v1(32.1,123.51) 32.46,123.87 33.34,123.87 37.1,127.62 37.1,129.56 37.71,130.17 37.71,131.55 40.28,134.13 41.66,134.13 43.06,135.52 v1(44.14,135.52)
  BOTTOM w0.254: v1(32.1,123.51) v2(32.1,124.22)
+VCCSA_LG_D: length 37.3
  TOP w0.279: PU3.8 51.52,134.2 51.8,133.92 v3(52.07,133.92)
  IN2 w0.635: v3(52.07,133.92) 51.94,133.92 51.57,134.29 50.58,134.29 49.55,135.33 48.65,135.33 46.61,133.29 45.1,133.29 44.12,132.31 43.06,132.31 39.19,128.44 39.19,125.31 36.68,122.8 35.49,122.8 v3(35.37,122.67)
  BOTTOM w0.635: v3(30.61,113.32) 30.63,113.3 31.61,113.3 32.74,114.42 v2(32.74,118.35) 33.65,119.27 33.65,120.51 35.37,122.23 v3(35.37,122.67)
+VCCSA_LG_R_D:
  vias: v2(33.83,113.68)
+VCCSA_PHASE_D: length 44.5
  TOP w0.279: PU3.11 52.79,136.18 v3(53.05,135.92)
  BOTTOM w0.635: v3(39.22,115) 39.22,119.83 40.79,121.4 43.72,121.4 45.57,123.24 55.77,123.24 56.33,122.68 57.83,122.68 58.88,123.73 58.88,125.1 60.23,126.45 60.23,128.38 58.84,129.77 58.35,129.77 57.66,130.46 v2(57.66,131.66) 57.66,132.19 PC23.1 55.57,132.85 54.85,133.56 54.85,134.12 v3(53.05,135.92)
  vias: v1(30.38,116.96)
+VCCSA_SN:
  vias: v2(27.68,120.18)
+VCCSA_TON: length 2.4
  TOP w0.279: PU3.16 50.02,137.96 v2(49.49,138.5) PR26.2
+VCCSA_VDD: length 5.5
  TOP w0.279: PU3.2 48.96,136.18
  TOP w0.508: 48.96,136.18 48.42,136.72 PC17.1 48.06,136.12 48.16,136.03 v2(48.16,135.65) 46.18,135.65 45.86,135.33 PR25.2
+VCCSA_VIN:
  vias: v1(26.8,118.46)
+VCCSA_VOUT_A: length 2.4
  TOP w0.254: PU3.1 49.12,136.98 49.12,137.68 48.75,138.05 v1(48.75,138.08) 48.61,137.94 PR41.1
+VCCSA_VOUT_R_A: length 41.6
  TOP w0.254: PJP4.2 56.98,117.06 56.56,117.06 54.99,118.63 54.99,119.29 54.94,119.34 v1(54.94,119.36) ; PR43.2 43.92,132.46 43.92,131.53 v1(43.51,131.13)
  IN2 w0.254: v1(43.51,131.13) 43.97,130.67 43.97,130.67 44.01,130.63 45.15,130.63 46.57,129.21 55,129.21 55.21,129.42 55.71,129.92 56.86,129.92 57.6,130.66 v1(58.43,130.66)
  BOTTOM w0.254: v1(58.43,130.66) 58.43,131.32 58.65,131.54 v2(60.4,131.54) 61.48,130.46 61.48,126.04 60.96,125.52 60.96,123.89 57.49,120.42 56,120.42 v1(54.94,119.36)
+VCCST: length 613
  TOP w0.254: R6502.1 31.11,30.7 30.96,30.85 v1(30.96,31.23) 30.95,31.24 30.95,32.08 R70295.1 ; PR89002.2 PR89013.1 PR89001.1 PC89001.1 81.65,170.89 79.47,168.71 v1(79.47,165.89) ; v1(121,32.96) v1(121,26.74) ; v1(23.08,122.14) 23.08,122.93 23.85,123.7 25.32,123.7 25.82,124.2 25.82,125 26.64,125.82 37.06,125.82 38.99,123.89 v1(38.99,122.7) 40.64,122.7 43.18,125.24 55.35,125.24 55.84,125.74 57.6,125.74 58.85,124.49 58.85,123.92 60.29,122.48 61.5,122.48 63.77,120.21 v1(63.77,119.02) 63.77,117.32 v1(64.06,117.03) ; SR765.1 SR766.1 47.26,109.42 v1(46.91,109.77) ; v1(25.54,95.9) 25.62,95.82 25.62,94.32 v1(25.61,94.31)
  TOP w0.381: XU1.V6 108.57,115.17 v1(108.57,115.2) 108.11,114.73 XU1.V5 ; v1(107.61,115.17) 107.61,115.14 XU1.V4
  TOP w0.457: v1(86.61,122.37) 86.61,122.53 86.88,122.79 HC5.1 86.47,123.45 HC4.1 ; v1(88.27,135.55) 88.27,137.23 87.81,137.68 86.56,137.68 86.1,137.23 HR30.1 ; HR58.2 84.78,122.15 84.78,122.47 v1(84.71,122.54)
  TOP w0.508: v1(84.71,122.54) 84.81,122.64 HC4.1
  IN1 w0.229: v1(27.81,142.59) 30.5,139.89 30.5,136.44 28.75,134.69 27.72,134.69 22.55,129.52 22.55,122.66 v1(23.08,122.14)
  IN1 w0.254: v1(65.85,109.88) 67.66,108.07 v1(69.21,108.07) ; v1(50.94,28.78) 46.79,32.93 36.58,32.93 35.81,32.16 32.29,32.16 31.67,31.54 31.27,31.54 v1(30.96,31.23) ; v1(46.91,109.77) 46.91,111.09 46.32,111.69 46.32,112.23 46.61,112.52 46.76,112.52 47.05,112.81 47.05,120.58 45.57,122.06 39.62,122.06 v1(38.99,122.7) ; v1(25.54,95.9) 25.47,95.96 25.47,96.33 25.04,96.76 25.04,97.57 24.78,97.84 24.78,101.27 24.56,101.49 24.56,104.02 24.7,104.17 24.7,106.1 24.97,106.37 v1(25.48,106.37) ; v3(102.11,121.1) 102.74,121.73 107.54,121.73 109.08,120.19 109.86,120.19 109.93,120.26 110.87,120.26 111.62,119.5 113.35,119.5 114.53,118.33 114.53,117.82 115.47,116.88 115.47,106.75 116.23,105.99 121.11,105.99 121.85,106.72 122.3,106.72 122.93,106.09 127.79,106.09 128.24,106.54 128.24,110.23 127.85,110.62 127.85,111.08 128.24,111.47 128.24,117.01 129.18,117.95 132.08,117.95 v1(133.4,119.27) 135.08,119.27 v1(136.4,117.95)
  IN1 w0.508: v1(86.61,122.37) 86.61,122.07 87.46,121.22 88,121.22 88.69,120.54 92.81,120.54 94.33,122.06 95.83,122.06
  IN1 w0.762: v3(102.11,121.1) 101.07,122.14 96.98,122.14
  IN2 w0.254: v1(17.3,105.65) 16.1,105.65 15.48,105.03 14.7,105.03 13.56,106.16 13.56,108.69 14.74,109.87 14.74,113.06 15.64,113.96 16.12,113.96 16.66,114.5 16.66,115.02 21.68,120.04 21.68,120.44 23.08,121.84 v1(23.08,122.14) ; v1(50.94,28.78) 53.24,26.48 62.94,26.48 63.36,26.06 68.35,26.06 70.32,28.03 75.26,28.03 76.02,27.27 77.44,27.27 77.82,27.65 78.62,27.65 79.2,27.08 94.6,27.08 97.32,24.36 98.91,24.36 99.56,23.72 105.32,23.72 105.9,24.3 118.79,24.3 121,26.51 v1(121,26.74) ; v3(115.68,36.79) 106.87,45.61 97.51,45.61 96.28,46.84 96.28,47.14 94.64,48.78 94.64,51.97 90.83,55.78 90.83,58.38 87.27,61.94 87.27,77.08 89.62,79.44 89.62,95.59 89.18,96.04 89.18,97.81 v3(88.09,98.9) ; v1(84.58,146.56) 83.72,147.42 83.72,152.14 83.95,152.36 84.33,152.36 84.56,152.59 84.56,154.22 83.72,155.05 83.72,159.42 81.84,161.31 81.15,161.31 79.47,162.99 v1(79.47,165.89)
  IN2 w0.762: v3(88.09,98.9) 88.87,99.68 88.87,100.85 88.11,101.62 84.5,101.62 83.26,100.37 82.27,100.37 81.33,99.43 74.42,99.43 72.79,101.06
  BOTTOM w0.191: O2CB10.1 26.25,95.63 26.05,95.43 25.13,95.43 25,95.56 U104.29
  BOTTOM w0.254: 84.1,122.75 84.5,122.75 v1(84.71,122.54) ; 84.1,122.75 84.1,121.83 83.72,121.45 82.19,121.45 81.59,120.86 81.43,120.86 HR347.1 ; 84.1,122.75 HR91.1 ; v1(69.21,108.07) 68.35,107.2 68.35,104.89 69.09,104.15 69.12,104.15 69.34,103.93 69.34,103.54 70.22,102.66 70.79,102.66 ; PR93063.1 26.33,145.85 26.72,145.46 26.72,143.23 27.36,142.59 v1(27.81,142.59) ; v1(25.54,95.9) 25.75,96.11 26.07,96.11 O2CB10.1 ; v1(25.61,94.31) 25.87,94.05 25.97,94.05 OR3.1 ; HR15.1 136.2,116.54 136.21,116.53 136.57,116.53 136.86,116.82 136.86,117.49 v1(136.4,117.95) 136.16,118.19 HR14.1 ; v1(64.06,117.03) 64.24,117.03 65.33,115.94 65.33,110.4 v1(65.85,109.88) ; SR763.1 47.27,110.12 v1(46.91,109.77) 47.03,109.65 SR769.1 ; v1(84.58,146.56) 83.78,146.56 83.62,146.73 81.95,146.73 81.75,146.52 80.82,146.52 79.73,145.43 79.73,144.7 78.6,143.57 78.6,142.31 78.45,142.16 78.45,141.12 80.48,139.09 82.39,139.09 84.75,136.73 85.72,136.73 86.9,135.55 v1(88.27,135.55) ; SR259.1 51.03,111.19 50.86,111.36 50.86,112.4 51.54,113.07 56.72,113.07 57.66,114.01 59.05,114.01 60.65,115.62 60.65,115.9 v1(63.77,119.02) ; HR29.1 132.99,120.34 132.99,119.67 v1(133.4,119.27) ; v1(17.3,105.65) 17.85,105.65 18.49,106.29 21.59,106.29 22.39,107.1 25.05,107.1 25.48,106.67 v1(25.48,106.37) ; R93122.1 120.27,32.22 v1(121,32.96)
  BOTTOM w0.508: v1(88.27,135.55) 88.27,135.04 91.54,131.77 91.54,130.3 94.02,127.82 94.02,125.57 94.87,124.72 94.87,123 95.93,121.94
  BOTTOM w0.533: 117.85,32.22 R93122.1
  BOTTOM w0.762: v3(115.68,36.79) v2(115.68,34.74) 115.68,34.4 117.85,32.22 ; 96.65,119.83 96.65,118.94 94.61,116.91 94.61,109.54 88.09,103.01 v3(88.09,98.9)
  vias: v1(72.29,101.82) v1(72.92,101.84) v1(96.24,121.4) v1(96.9,121.43)
AVDD1: length 1.4
  TOP w0.203: 15.39,17.9 16.09,18.61 U6.26
  vias: v1(8.74,15.53) v1(8.76,16.17) v1(14.2,16.16) v1(14.83,16.14) v2(9.83,16.12)
AVDD2: length 5.2
  TOP w0.203: 22.55,20.56 22.4,20.72 21.36,20.72 21.24,20.84 U6.40
  TOP w0.254: AC90.1 24.16,20.69 23.64,20.69 23.32,20.38 23.32,20.14 v2(23.09,19.9) 22.83,20.16 22.83,20.28 22.55,20.56
DVDD: length 12.9
  TOP w0.203: U6.9 16.89,25.3 v1(16.79,25.4)
  TOP w0.508: L120.2 21.7,28.3
  BOTTOM w0.457: AC52.1 24.29,27.77 R181.2
  BOTTOM w0.508: AC52.1 24.29,27.11 AC5.1 23.66,27.24 23.66,27.52 23.15,28.03 21.95,28.03 v1(21.8,27.89) ; v1(20.68,26.54) v2(20.02,27.2) 19.93,27.3 18.01,27.3 16.79,26.07 v1(16.79,25.4)
GND: length 2233.8
  TOP w0.102: U1.V4 53.01,102.61 52.88,102.91 52.91,103.09 52.91,103.24 52.53,103.62 v1(52.53,104.37)
  TOP w0.152: v1(48.82,105.58) 48.65,105.41 48.65,104.42 48.6,104.37 U1.AG1 ; v1(38.4,96.88) 38.96,96.32 U1.BG17 ; v1(37.71,86.12) 37.9,86.31 38.27,86.31 38.35,86.38 U1.BG37 ; v1(45.6,58.06) 45.67,58.13 45.67,58.33 45.82,58.48 45.82,58.84 45.7,58.96 J218.45 ; U1.AM1 46.47,104.33 46.47,106.04 v1(46.35,106.15) ; v1(38.5,92.68) 38.73,92.68 U1.BG25 ; v1(38.51,94.41) 38.79,94.13 U1.BG22 ; U1.AD2 50.36,103.84 50.9,104.38 v1(50.9,104.92) 50.77,104.92 50.28,104.42 U1.AD1 ; v1(54.23,79.87) 54.15,79.95 U1.T49 ; v1(38.42,90.65) 38.55,90.77 U1.BG28 ; U1.AD49 50.02,80.64 49.54,80.15 v1(49.54,79.86) ; U1.BG33 38.49,88.58 38.46,88.6 v1(38.45,88.6) ; v1(46.4,80.13) U1.AM49 ; U1.Y9 53.03,100.92 53.03,101.53 53.2,101.7 53.2,102.36 U1.V4 ; U1.C30 59.97,90.08 U1.D30 ; v1(52.61,79.63) 52.6,79.64 52.6,79.99 U1.AA49 ; U1.AG49 v1(48.6,80) ; U1.A37 61.77,86.38 v1(62.08,86.07)
  TOP w0.178: U1.BC35 41.01,87.77 41.01,88.27 41.25,88.51 41.25,89.28 v1(41.24,89.28) ; M1U4.3 120.76,158.91 ; U1.C30 60.45,90.08 60.6,90.24 61.49,90.24
  TOP w0.203: U1.AT45 44.47,82.59 44.8,82.26 v1(44.81,82.26) 44.94,82.39 U1.AP46 ; v1(53.58,83.01) 53.38,83.01 53.05,82.69 U1.V46 ; U1.D16 60.09,96.71 U1.D17 59.85,96.47 59.65,96.27 U1.E17 ; v1(41.24,89.28) 41.24,89.35 40.92,89.67 U1.BC31 ; XU1.C12 v1(114.94,128.01) ; v1(54.11,104.82) 54.14,104.79 54.77,104.79 55.12,104.44 55.12,103.98 54.88,103.75 54.88,103.4 54.89,103.39 54.89,103.12 U1.R3 54.84,102.64 U1.R4 ; v1(56.69,79.8) 56.64,79.8 56.44,80 56.44,80.57 U1.M49 ; U1.AE46 50.05,82.75 v1(50.13,82.75) 50.15,82.77 50.47,82.77 U1.AC46 ; U1.BC13 40.92,97.84 v1(41.24,97.53) ; 57.55,102.51 U1.J4 57.14,102.21 56.74,102.21 56.64,102.31 U1.M5 ; U1.BE44 40.1,83.54 U1.BD43 40.79,83.54 40.92,83.4 ; U1.D33 60.09,88.85 59.92,89.01 v1(59.92,89.07) ; v1(62.43,88.38) 62.19,88.58 U1.A33 ; U1.BA5 42.44,101.95 v1(42.52,101.95) 42.67,101.95 43.11,102.38 U1.AW4 ; v1(43.79,104.59) 43.79,104.57 44.09,104.26 U1.AT1 ; U1.R4 54.75,102.25 v1(54.92,102.07) 55.25,102.4 U1.P4 ; U1.R4 54.53,102.76 U1.T4 54.29,102.52 U1.T5 54.12,102.26 U1.T7 ; U1.BC10 40.72,100.04 v1(40.63,100.12) 40.63,100.36 U1.BC8 ; U1.P46 54.98,82.66 v1(54.98,82.9) ; U1.BC19 41.02,94.92 41.02,94.7 v1(41.27,94.45) ; v1(49.2,101.31) 49,101.31 48.11,102.2 47.81,102.2 U1.AK4 ; U1.AK46 47.8,82.69 47.98,82.69 48.45,83.16 v1(48.51,83.16) ; v1(107.7,113.34) 107.02,113.34 106.55,113.81 XU1.W3 ; v1(41.24,97.53) 41.14,97.42 U1.BC15 ; v1(41.24,97.53) 41.4,97.69 U1.BA14 ; U1.E10 59.92,99.7 v1(59.92,100.18) 59.63,100.46 U1.E8 59.85,100.86 U1.D8 ; U1.E15 59.84,97.81 v1(59.95,97.92) 59.63,98.23 U1.E13 ; 55.36,108.28 55.07,107.99 v1(54.85,107.99) ; U1.AE4 49.82,102.63 v1(50.27,102.63) 50.74,102.63 U1.AC4 ; U1.AA5 51.88,101.96 v1(52.02,101.82) 52.2,101.99 52.41,102.21 52.75,102.21 U1.V4 ; XU1.C18 119.56,128.88 v1(119.56,128.95) ; v1(45.23,102.01) 45.3,102.08 U1.AP4 ; v1(59.13,93.97) 59.55,93.97 U1.E22 59.63,94.36 59.53,94.46 59.53,94.92 U1.E19 ; v1(63.56,101.2) 63.11,100.74 U1.A8 ; U1.BC26 40.72,92.37 v1(40.84,92.5) 40.72,92.62 U1.BC24 ; U1.E35 59.84,87.49 59.49,87.84 59.49,88.51 U1.E33 59.28,89 v1(59.28,89.29) 59.46,89.29 U1.E31
  TOP w0.229: M1U4.3 120.76,158.55 120.5,158.28 120.2,158.28 119.94,158.02 v1(119.94,156.33)
  TOP w0.254: U1.AJ27 47.93,91.68 v1(47.55,92.06) ; 144.8,67 v1(144.07,67) 143.57,67.49 143.57,68.08 143.87,68.38 DIMM2.57 143.87,70.34 144.08,70.55 144.08,70.96 143.63,71.42 v1(143.59,71.42) 143.43,71.42 142.88,70.86 DIMM2.61 142.88,67.71 142.55,67.39 v1(142.36,67.39) 142.25,67.39 141.88,67.77 DIMM2.65 141.88,70.8 141.49,71.19 v1(141.37,71.19) 141.22,71.19 140.88,70.84 DIMM2.69 140.88,68.4 141.15,68.12 141.15,67.61 140.87,67.33 v1(140.56,67.33) 140.16,67.33 139.85,67.63 139.85,68.29 139.87,68.32 DIMM2.73 ; 144.8,67 v1(144.8,67) ; 144.8,67 145.01,67 145.37,67.37 DIMM2.51 145.37,70.87 v1(145.72,71.21) 146,71.21 146.37,70.84 DIMM2.47 146.37,67.71 146.71,67.38 v1(146.86,67.38) 147.06,67.38 147.37,67.69 147.37,67.89 147.37,67.89 DIMM2.43 147.37,70.99 v1(148,71.62) 148.46,71.16 148.46,70.46 148.37,70.38 DIMM2.39 148.37,67.63 148.66,67.35 v1(148.92,67.35) 149.09,67.35 149.45,67.71 149.45,68.24 149.37,68.32 DIMM2.35 149.37,70.65 149.38,70.65 ; U1.J26 57.39,91.64 v1(57.39,90.87) 57.39,90.55 U1.J29 ; v1(100.81,55.23) 100.18,54.6 v1(99.92,54.6) 99.86,54.6 99.38,55.07 99.38,55.67 ; v1(100.81,55.23) 101.19,55.23 101.19,55.23 101.43,55.23 v1(101.45,55.22) 101.53,55.22 101.97,55.66 101.97,56.24 101.88,56.32 DIMM1.217 101.88,58.24 101.75,58.37 101.75,59.07 v1(101.85,59.17) 102.43,59.17 102.88,58.72 DIMM1.213 102.88,55.67 103.19,55.37 v1(103.39,55.37) 103.74,55.37 103.88,55.51 ; v1(100.81,55.23) 100.75,55.23 100.32,55.66 100.32,56.08 100.38,56.14 DIMM1.223 100.38,58.61 ; HR84.2 72.69,114.54 72.69,114.55 HR82.2 ; 153.62,62.76 DIMM2.18 153.62,60.07 153.36,59.81 152.97,59.81 v1(152.96,59.82) 152.62,60.16 DIMM2.22 152.62,62.09 152.45,62.27 152.45,62.78 ; 153.62,62.76 153.62,63.18 v1(153.47,63.34) 153.01,63.34 152.45,62.78 ; 153.62,62.76 154.14,63.27 v1(154.42,63.27) 154.51,63.27 154.95,62.83 154.95,62.29 154.62,61.96 DIMM2.14 154.62,59.43 154.9,59.15 v1(155.14,59.15) 155.37,59.15 155.62,59.41 DIMM2.10 155.62,62.71 155.93,63.01 v1(156.23,63.01) 156.38,63.01 156.74,62.64 156.74,62.09 156.62,61.98 DIMM2.6 156.62,60.01 156.88,59.76 v1(157.07,59.76) 157.37,59.76 157.62,60.01 DIMM2.2 157.66,61.11 157.66,61.89 157.85,62.08 157.85,62.77 157.63,62.98 v1(157.12,62.98) ; 156.87,70.73 DIMM2.5 156.87,67.77 ; 103.88,55.51 DIMM1.209 103.88,58.69 ; 103.88,55.51 104.21,55.18 v1(104.37,55.18) 104.52,55.18 104.88,55.55 104.88,55.58 ; 45.44,98.57 v1(45.44,98.41) ; 45.44,98.57 45.11,98.89 U1.AR12 ; 45.44,98.57 45.44,98.64 45.69,98.89 U1.AN12 ; J69.10 55.32,146.12 v1(55.41,146.03) ; v1(105.93,63.17) 105.51,62.75 105.51,62.09 105.62,61.98 DIMM2.202 105.62,59.48 105.34,59.19 v1(105.09,59.19) ; 135.87,70.95 DIMM2.89 135.87,67.79 135.43,67.35 v1(135.13,67.35) ; v1(70.99,70.3) 71.33,69.96 PU5.19 ; 112.11,62.45 112.12,62.44 DIMM2.176 112.12,59.57 112.55,59.15 v1(112.7,59.15) 112.8,59.15 113.27,59.61 113.27,60.05 113.12,60.19 DIMM2.172 113.12,62 112.73,62.39 112.73,62.96 113.16,63.39 v1(113.23,63.39) 113.49,63.39 114.12,62.75 DIMM2.168 114.12,59.96 113.92,59.76 ; v1(47.45,86.43) 47.88,86.43 U1.AH38 ; HR82.2 71.93,115.07 HR85.2 71.08,114.21 HR49.2 HR48.2 HR54.2 HR55.2 ; HR82.2 HR47.2 HR46.2 71.65,116.9 71.35,116.6 70.61,116.6 v1(70.2,116.19) ; 100.2,67.74 99.73,67.27 v1(99.39,67.27) 99.01,67.27 98.37,67.91 DIMM2.231 98.37,70.93 97.97,71.34 v1(97.64,71.34) 97.22,70.92 97.22,70.32 97.37,70.16 DIMM2.235 97.37,67.82 96.94,67.39 v1(96.87,67.39) 96.61,67.39 96.37,67.62 DIMM2.239 96.37,70.66 ; 100.2,67.74 100.2,68.21 100.37,68.39 DIMM2.223 100.37,70.92 100.01,71.29 v1(99.44,71.29) 99.37,71.22 DIMM2.227 ; 100.2,67.74 v1(100.76,67.18) 100.76,67.17 v1(101.5,67.17) 102.03,67.71 102.03,68.19 101.87,68.35 DIMM2.217 101.87,70.92 102.13,71.18 v1(102.4,71.18) 102.52,71.18 102.87,70.82 DIMM2.213 102.87,67.8 103.34,67.34 v1(103.4,67.34) 103.56,67.34 103.87,67.66 DIMM2.209 103.87,70.96 104.13,71.21 v1(104.4,71.21) 104.62,71.21 104.87,70.96 DIMM2.205 104.87,67.71 105.2,67.38 v1(105.38,67.38) 105.51,67.38 105.87,67.75 DIMM2.201 105.87,70.79 ; J69.1 55.46,150.62 55.46,150.61 v1(55.44,150.61) ; 54.97,91.5 v1(54.97,91.48) U1.R26 ; DIMM2.252 93.12,62.01 92.99,62.14 92.99,62.58 ; 113.7,55.25 113.02,54.57 v1(112.88,54.57) 112.43,54.57 v1(111.94,55.06) ; 113.7,55.25 113.89,55.25 v1(113.89,55.25) 114.1,55.25 114.38,55.53 DIMM1.167 114.38,58.32 114.1,58.61 ; 113.7,55.25 113.38,55.56 DIMM1.171 113.38,58.33 v1(113.59,58.54) ; U1.N16 55.46,96.7 v1(54.99,96.23) 54.67,96.55 U1.R16 ; v1(49.1,96.59) 48.99,96.48 U1.AH17 ; v1(55.9,89.93) 55.9,89.48 U1.M32 56.19,88.84 v1(55.84,88.48) U1.N34 ; XU1.G15 117.22,124.78 v1(116.79,124.35) ; 144.98,55.13 145.34,54.78 v1(145.54,54.78) 145.85,54.78 146.38,55.32 146.38,55.41 ; 144.98,55.13 145.24,55.39 145.24,55.72 145.38,55.87 DIMM1.51 145.38,58.39 ; 144.98,55.13 144.91,55.06 v1(144.4,55.06) 143.84,55.06 143.46,55.44 143.46,55.97 143.88,56.4 DIMM1.57 143.88,58.89 143.55,59.22 v1(143.38,59.22) 143.3,59.22 142.88,58.81 DIMM1.61 142.88,55.66 142.56,55.34 v1(142.37,55.34) 142.21,55.34 141.88,55.66 DIMM1.65 141.88,58.32 142.2,58.63 ; DIMM1.103 132.38,56.27 132.04,55.93 v1(131.64,55.93) 131.38,56.18 DIMM1.107 ; v1(54.11,104.82) 54.11,105.21 54.74,105.83 54.74,107.01 54.85,107.12 v1(54.85,107.99) ; v1(132.38,72.51) 132.74,72.51 133.37,71.87 DIMM2.99 133.37,67.13 132.79,66.54 v1(132.48,66.54) ; 146.38,55.41 DIMM1.47 146.38,58.43 ; 146.38,55.41 146.68,55.11 147.14,55.11 v1(147.14,55.11) 147.4,55.11 147.67,55.38 147.67,56 147.42,56.25 147.42,57.24 DIMM1.43 147.38,58.92 147.64,59.17 148.45,59.17 v1(148.57,59.05) 148.57,58.5 148.38,58.31 DIMM1.39 148.38,56.4 148.16,56.17 148.16,55.52 148.41,55.26 v1(148.64,55.26) 148.72,55.26 149.38,55.93 DIMM1.35 149.38,58.55 149.38,58.55 ; 107.88,55.55 DIMM1.193 107.88,58.63 ; 107.88,55.55 107.88,54.99 108.15,54.73 108.86,54.73 109.24,55.11 109.24,55.24 v1(109.38,55.38) ; 107.88,55.55 107.57,55.23 v1(107.19,55.23) 107.02,55.23 106.63,55.63 106.63,56.07 106.88,56.32 DIMM1.197 106.88,58.58 106.88,58.59 ; SR703.2 30.63,105.78 32.15,105.78 32.31,105.63 32.31,105.64 v1(32.32,105.64) ; v1(133.63,94.98) 133.25,94.61 XU1.AW30 ; 140.88,58.8 DIMM1.69 140.88,55.64 140.63,55.39 v1(140.34,55.39) 140.18,55.39 139.88,55.68 DIMM1.73 139.88,58.62 139.89,58.62 ; v1(73.9,66.78) 73.9,66.78 73.77,66.91 PU5.4 ; v1(54.08,98.21) 54.08,97.88 U1.U15 ; 104.88,55.58 105.08,55.39 v1(105.37,55.39) 105.63,55.39 105.88,55.64 DIMM1.201 105.88,58.73 ; 104.88,55.58 DIMM1.205 104.88,58.99 v1(105.09,59.19) ; v1(131.54,62.43) 131.62,62.34 DIMM2.106 ; U1.AH33 48.02,88.42 v1(47.47,87.87) 47.03,88.32 U1.AL33 ; SC13.2 32.88,105.07 v1(32.32,105.64) ; v1(138.81,58.59) 139.39,58.59 140.12,59.32 DIMM2.72 140.12,62.11 140.08,62.16 140.08,62.6 140.46,62.98 v1(140.59,62.98) 140.74,62.98 141.12,62.6 DIMM2.68 141.12,59.6 141.58,59.15 141.73,59.15 v1(141.73,59.14) 141.87,59.14 142.25,59.51 142.25,60.06 142.12,60.18 DIMM2.64 142.12,62.78 142.38,63.04 v1(142.64,63.04) 142.87,63.04 143.12,62.78 ; v1(138.81,58.59) 138.88,58.51 DIMM1.77 138.88,55.7 138.58,55.39 v1(138.36,55.39) ; v1(138.81,58.59) 138.48,58.92 138.48,59.86 138.62,60 DIMM2.78 138.62,62.1 138.7,62.17 138.7,62.72 138.35,63.06 v1(138.2,63.06) 137.9,63.06 137.62,62.79 DIMM2.82 137.62,59.72 137,59.1 v1(136.94,59.1) 136.87,59.1 136.44,59.53 136.44,60.01 136.62,60.19 DIMM2.86 136.62,62.65 ; XU1.AW32 135.45,95.06 135.45,96.88 v1(135.43,96.9) ; v1(54.11,93.55) 54.11,93.28 U1.U24 ; v1(54.11,93.55) 54.14,93.58 54.14,94.18 U1.U21 53.54,94.77 U1.V20 ; v1(54.11,93.55) 53.66,94 U1.V22 ; 136.88,67.96 136.87,67.96 DIMM2.85 136.87,70.86 137.29,71.27 v1(137.42,71.27) 137.51,71.27 137.87,70.9 DIMM2.81 137.87,68.24 137.74,68.11 137.74,67.71 138.13,67.33 v1(138.33,67.33) 138.53,67.33 138.87,67.67 DIMM2.77 ; U1.BA44 42.47,82.92 v1(42.62,82.92) 42.63,82.92 43.11,82.45 U1.AW46 ; v1(49.1,92.06) 49.48,92.45 U1.AF25 ; v1(49.1,92.06) 48.73,92.44 U1.AG25 U1.AG23 ; v1(49.1,92.06) 48.73,91.69 U1.AG27 ; U1.Y17 52.29,96.01 v1(52.2,95.93) U1.AA19 ; v1(135,47.34) 134.63,47.7 DIMM1.94 134.63,50.62 v1(134.14,51.11) ; U1.AJ28 v1(47.57,90.52) 47.18,90.9 U1.AK28 ; v1(111.18,51.48) 110.87,51.48 110.13,50.74 DIMM1.184 110.13,47.69 v1(110.6,47.22) ; 152.45,62.78 151.99,63.24 v1(151.76,63.24) 151.72,63.24 151.29,62.81 151.29,62.33 151.62,62 DIMM2.26 151.62,59.62 151.05,59.04 v1(150.75,59.04) 150.37,59.43 150.37,59.94 150.62,60.2 DIMM2.30 150.62,62 150.84,62.21 150.84,62.92 150.47,63.29 v1(150.44,63.29) 149.36,63.29 149.35,63.3 v1(149.33,63.3) 149.33,63.22 148.93,62.82 148.93,62.16 149.12,61.96 DIMM2.36 149.12,60.16 149.48,59.81 ; v1(106.91,51.34) 106.81,51.25 v1(105.52,51.25) 105.45,51.18 105.45,50.16 105.63,49.98 DIMM1.202 105.63,48.1 105.33,47.8 v1(105.13,47.8) 104.92,47.8 104.63,48.08 DIMM1.206 104.63,50.54 104.21,50.97 v1(104.12,50.97) 103.96,50.97 103.63,50.65 DIMM1.210 103.63,47.5 103.3,47.16 v1(103.11,47.16) 102.89,47.16 102.63,47.42 DIMM1.214 102.63,50.64 102.3,50.97 v1(102.11,50.97) 101.89,50.97 101.63,50.72 DIMM1.218 101.63,48.09 101.34,47.8 v1(101.15,47.8) 100.93,47.8 100.63,48.09 DIMM1.222 100.63,50.76 100.38,51.01 v1(100.12,51.01) 99.89,51.01 99.46,50.59 v1(99.46,50.38) 99.63,50.21 DIMM1.226 99.63,47.54 99.25,47.16 v1(99.11,47.16) 98.94,47.16 98.63,47.46 DIMM1.230 98.63,50.95 ; v1(106.91,51.34) 107.3,50.96 ; v1(106.91,51.34) 107.18,51.62 v1(107.78,51.62) 108.05,51.62 v1(108.65,51.02) 108.58,51.02 108.13,50.57 DIMM1.192 108.13,47.49 107.75,47.1 v1(107.55,47.1) 107.13,47.52 DIMM1.196 107.13,50.23 107.31,50.41 ; v1(77.45,64.53) 77.31,64.66 PC105.2 ; U1.AA31 51.83,89.35 v1(52.21,89.74) 52.6,90.13 U1.W30 ; U1.W27 52.6,91.68 v1(52.22,91.3) ; U1.AA25 51.83,92.45 v1(52.2,92.83) 52.22,92.83 U1.W25 ; DIMM1.239 96.38,56.39 96,56.01 96,55.5 v1(96.39,55.11) 97,55.11 97.38,55.49 DIMM1.235 97.38,58.86 ; v1(107.03,63.28) 107.4,62.91 107.4,62.26 107.12,61.98 DIMM2.196 107.12,59.96 107.01,59.85 107.01,59.38 107.26,59.12 v1(107.57,59.12) 107.87,59.12 108.12,59.38 DIMM2.192 108.12,62.73 108.38,62.98 v1(108.58,62.98) 108.87,62.98 109.13,62.73 DIMM2.188 109.13,59.45 109.38,59.19 109.57,59.19 v1(109.57,59.19) 109.74,59.19 110.13,59.57 DIMM2.184 110.13,61.96 109.94,62.15 109.94,62.82 110.21,63.08 110.44,63.08 v1(110.46,63.11) 110.79,63.11 111.11,62.78 v1(111.11,62.39) 111.12,62.38 DIMM2.180 ; 112.39,58.61 112.38,58.6 DIMM1.175 112.38,56.26 112.49,56.15 112.49,55.56 111.99,55.06 v1(111.94,55.06) ; U1.AH12 47.85,98.85 v1(47.67,99.03) 47.51,98.87 U1.AL12 ; v1(109.38,55.38) 109.23,55.38 108.88,55.72 DIMM1.189 108.88,58.53 108.89,58.54 ; v1(109.38,55.38) 109.45,55.38 109.88,55.81 DIMM1.185 109.88,58.35 v1(109.7,58.54) 109.7,58.56 110.17,59.03 110.6,59.03 110.88,58.75 DIMM1.181 110.88,56.37 110.67,56.16 110.67,55.5 111.12,55.06 v1(111.31,55.06) v1(111.94,55.06) ; 135.88,58.69 DIMM1.89 v1(135.88,55.98) ; 55.36,108.28 55.78,108.7 v1(55.78,112.49) 55.78,112.67 55.52,112.92 54,112.92 53.87,113.05 51.49,113.05 51.33,112.89 51.33,112.54 50.78,111.98 50.78,111.49 51.28,110.99 51.28,109.72 51.09,109.53 51.09,108.53 SC32.2 ; U1.AR16 45.12,96.8 v1(45.49,96.43) 45.86,96.8 U1.AN16 ; 49.91,94.39 v1(49.91,94.39) 49.91,94.39 50.28,94.02 U1.AD22 ; U1.AM32 46.59,88.93 v1(46.23,88.56) 45.88,88.21 U1.AN34 ; 156.87,67.77 156.47,67.36 v1(156.36,67.36) 156.28,67.36 155.87,67.76 DIMM2.9 155.87,70.17 156.24,70.53 156.24,71.24 v1(155.95,71.52) v1(154.86,71.52) 154.37,71.02 154.37,70.18 154.37,70.18 DIMM2.15 154.37,68.4 154.52,68.25 154.52,67.73 154.06,67.27 v1(154,67.27) 153.82,67.27 153.37,67.72 DIMM2.19 153.41,69.32 153.41,70.2 153.52,70.3 153.52,71.14 153.21,71.44 v1(153.01,71.44) 152.83,71.44 152.37,70.98 DIMM2.23 152.37,67.6 152.1,67.33 v1(151.86,67.33) 151.56,67.33 151.31,67.58 151.31,68.33 151.37,68.4 DIMM2.27 151.37,70.76 150.94,71.2 v1(150.8,71.2) 150.59,71.2 150.21,70.83 150.21,70.32 150.37,70.16 DIMM2.31 ; 156.87,67.77 156.87,67.7 157.18,67.4 v1(157.58,67.4) 157.87,67.7 DIMM2.1 157.87,70.73 ; v1(50.34,86.32) 50.54,86.12 U1.AC38 ; U1.AJ31 47.95,89.35 v1(48.33,88.97) ; v1(98.09,51.15) 97.94,51.15 97.63,50.84 DIMM1.234 97.63,47.47 97.36,47.19 v1(97.14,47.19) 96.89,47.19 96.63,47.44 DIMM1.238 96.63,49.97 96.78,50.11 96.78,50.68 v1(96.2,51.26) v1(95.28,51.26) 94.93,50.9 94.93,50.24 95.13,50.04 DIMM1.244 95.13,47.45 v1(94.97,47.29) 94.29,47.29 94.13,47.44 DIMM1.248 94.13,50.06 94.27,50.19 94.27,50.7 v1(93.75,51.22) 93.72,51.25 93.01,51.25 92.71,50.95 92.71,50.39 93.13,49.96 DIMM1.252 93.13,48.19 92.94,48 v1(92.94,47.74) ; U1.AA30 52.17,90.47 52.37,90.67 U1.W28 52.6,90.9 v1(53,90.5) ; v1(39.24,73.57) 39.22,73.55 39.22,67.94 38.98,67.7 36.76,67.7 36.19,68.27 v1(36.19,68.72) 36.69,69.22 36.69,76 36.78,76.09 37.38,76.09 38.22,76.93 39.52,76.93 39.56,76.96 SC29.2 40.46,77.41 40.59,77.54 40.59,78.78 v1(41.07,79.26) ; v1(142.29,111.01) 142.19,111.01 141.4,110.22 XU1.AB39 ; v1(52.96,96.03) 53.51,96.58 U1.U17 53.64,96.58 U1.T17 U1.T18 ; v1(32.41,107.03) 32.56,106.87 R2352.2 ; U1.BA12 42.77,99.56 U1.AW10 42.85,99.79 43.13,100.08 v1(43.32,100.08) 43.3,100.06 U1.AV11 ; U1.AK30 47.18,90.11 v1(47.55,89.73) 47.95,90.13 U1.AJ30 ; U1.Y9 52.3,100.37 v1(52.02,100.09) 52.29,99.82 U1.Y10 53.05,98.87 U1.U12 54.17,99.51 v1(54.17,99.76) 54.3,99.89 54.35,99.94 v1(54.35,100.4) 54.35,100.85 U1.T7 ; 143.12,59.66 DIMM2.60 143.12,62.78 ; v1(47.55,92.06) 47.18,92.43 U1.AK25 ; v1(47.55,92.06) 47.94,92.45 U1.AJ25 ; DIMM1.6 156.63,47.46 156.91,47.19 v1(157.15,47.19) 157.35,47.19 157.63,47.48 DIMM1.2 157.63,50.75 157.38,51.01 v1(156.61,51.01) 155.91,51.01 155.63,50.73 DIMM1.10 155.63,47.45 155.31,47.13 v1(155.09,47.12) 154.89,47.12 154.63,47.38 DIMM1.14 154.63,50.7 154.36,50.98 v1(154.13,50.98) ; v1(115.8,156.33) 115.63,156.49 115.63,158.14 115.58,158.2 M1U3.8 ; SC18.2 30.94,93.86 v1(31.73,93.86) ; 94.17,55.36 93.98,55.17 93.36,55.17 93.18,55.35 93.18,56.19 93.38,56.4 DIMM1.251 93.38,58.53 ; 94.17,55.36 94.17,56.18 94.38,56.4 DIMM1.247 94.38,58.54 ; 94.17,55.36 94.42,55.11 v1(94.59,55.11) 95.03,55.11 95.29,55.36 95.29,56.3 95.35,56.36 95.35,56.36 95.38,56.4 DIMM1.243 95.38,58.52 ; U1.N12 56.12,98.89 v1(56.48,99.25) 56.75,99.53 U1.K11 57.6,99.53 U1.J10 57.85,99.78 U1.J9 57.85,100.66 U1.H8 ; U1.AL17 47.02,96.48 v1(47.55,95.95) ; 98.63,51 v1(99.12,51.49) ; DIMM2.222 100.62,62.79 100.18,63.24 v1(99.9,63.24) 99.8,63.24 99.43,62.87 99.43,62.16 99.62,61.96 DIMM2.226 99.62,59.56 99.16,59.1 v1(98.88,59.1) 98.77,59.1 98.44,59.43 98.44,60 98.62,60.19 DIMM2.230 98.62,62.52 v1(97.89,63.25) 97.88,63.25 97.38,62.76 97.38,62.21 97.62,61.96 DIMM2.234 97.62,59.55 97.39,59.31 96.73,59.31 v1(96.49,59.55) 96.49,59.81 96.62,59.94 DIMM2.238 96.62,62 96.75,62.13 96.75,62.93 96.34,63.34 v1(96.24,63.34) v1(95.48,63.34) 95.32,63.34 94.97,62.98 94.97,62.12 95.12,61.96 DIMM2.244 95.12,59.96 94.8,59.64 v1(94.4,59.64) 94.12,59.91 DIMM2.248 94.12,62.61 93.6,63.13 v1(93.57,63.13) ; 99.38,55.67 DIMM1.227 99.38,58.64 ; 99.38,55.67 99.07,55.35 v1(98.88,55.35) 98.77,55.35 98.38,55.73 DIMM1.231 98.38,58.75 ; v1(47.55,95.95) 47.18,95.58 U1.AK19 47.02,95.71 U1.AM18 ; v1(47.55,95.95) 47.55,95.95 U1.AJ19 ; v1(50.44,88.81) 50.1,88.81 U1.AE33 ; v1(50.44,88.81) 50.85,88.41 U1.AC33 ; v1(50.44,88.81) 50.98,89.35 U1.AB31 ; 143.13,50.67 143.44,50.97 v1(143.63,50.97) 143.89,50.97 144.13,50.73 DIMM1.56 144.13,47.44 144.39,47.19 v1(144.63,47.19) 144.88,47.19 145.13,47.44 DIMM1.52 145.13,50.18 v1(144.96,50.36) 144.96,50.59 145.34,50.97 v1(145.63,50.97) 145.85,50.97 146.13,50.69 DIMM1.48 146.13,47.44 146.39,47.19 v1(146.64,47.19) 146.88,47.19 147.13,47.45 DIMM1.44 147.13,50.61 146.77,50.98 v1(146.67,50.98) ; 95.38,70.58 95.37,70.58 DIMM2.243 95.37,67.58 95.12,67.33 v1(94.66,67.33) 94.3,67.68 94.3,68.31 94.37,68.38 DIMM2.247 94.37,70.42 ; v1(132.82,51.07) 132.43,51.07 v1(131.77,50.41) 131.8,50.41 ; U1.R34 v1(55.05,88.48) ; DIMM2.107 131.37,68.29 131.81,67.86 v1(132.48,67.86) 132.37,67.97 DIMM2.103 ; U1.AL38 46.79,86.03 v1(46.48,85.72) 46.2,86.01 U1.AN38 ; U1.BB9 41.5,100.12 v1(41.25,99.86) ; J69.19 55.4,141.62 v1(55.5,141.72) ; 143.12,62.78 143.12,62.98 v1(143.6,63.45) 144.13,62.92 144.13,62.42 144.09,62.38 144.09,62.02 144.12,61.98 DIMM2.56 144.12,59.69 144.13,59.69 ; v1(42.16,79.21) 42.42,78.96 42.42,75.3 41.83,74.72 41.32,74.72 41.21,74.6 SC30.2 ; v1(52.22,91.3) 51.85,91.68 U1.AA27 ; v1(52.22,91.3) 51.83,90.9 U1.AA28 ; J69.4 55.25,149.12 55.41,149.27 v1(55.41,149.29) ; 109.13,50.53 DIMM1.188 109.13,47.7 v1(109.55,47.28) ; v1(132.79,50.41) 132.63,50.25 DIMM1.102 132.63,47.72 v1(132.64,47.72) ; 136.88,58.68 136.88,58.67 DIMM1.85 136.88,55.51 137.23,55.16 v1(137.41,55.16) 137.59,55.16 137.88,55.45 DIMM1.81 137.88,58.68 ; v1(32.32,105.64) 32.64,105.96 R2344.2 ; v1(105.09,59.19) 105.01,59.19 104.57,59.63 104.57,59.99 104.62,60.04 DIMM2.206 104.62,62.73 ; U1.AG30 U1.AG28 49.12,91.3 v1(49.12,91.3) 49.5,90.92 U1.AF28 ; R2351.2 32.21,107.94 v1(32.37,107.94) 32.43,107.94 32.59,107.79 R2347.2 33.08,108.18 32.98,108.28 R99516.2 ; DIMM2.167 114.37,67.71 113.85,67.19 v1(113.61,67.19) 113.17,67.63 113.17,68.18 113.37,68.38 DIMM2.171 113.37,70.87 113.05,71.19 v1(112.87,71.19) 112.7,71.19 112.37,70.87 DIMM2.175 112.37,67.47 v1(111.87,66.97) v1(111.22,66.97) 111.16,66.97 110.6,67.53 110.6,68.1 110.87,68.38 DIMM2.181 110.87,70.88 110.55,71.2 v1(110.23,71.2) 110.03,71.2 109.78,70.95 109.78,70.27 109.87,70.18 DIMM2.185 109.87,67.63 109.6,67.36 v1(109.37,67.36) 109.33,67.36 108.87,67.81 DIMM2.189 108.87,70.94 108.62,71.19 v1(108.33,71.19) 108.13,71.19 107.87,70.94 DIMM2.193 107.87,67.74 107.52,67.39 v1(107.37,67.39) 107.2,67.39 106.87,67.71 DIMM2.197 106.87,70.77 ; 134.88,58.73 DIMM1.93 v1(134.88,55.98) ; 103.48,62.37 103.62,62.23 DIMM2.210 103.62,60.19 103.91,59.91 103.91,59.68 v1(103.38,59.15) 103,59.15 102.62,59.52 DIMM2.214 102.62,61.98 102.84,62.2 102.84,62.79 102.59,63.05 v1(102.33,63.05) 101.96,63.05 101.62,62.71 DIMM2.218 ; v1(55.45,144.51) 55.33,144.62 J69.13 ; U1.BA6 42.15,101.58 v1(42.52,101.95) ; 133.63,62.37 133.62,62.37 DIMM2.98 133.62,59.55 133.24,59.17 v1(132.82,59.17) 132.46,59.53 132.46,60.03 132.62,60.2 DIMM2.102 132.62,62.56 ; v1(85.23,72.08) 85.06,72.08 84.76,71.77 D4R10.2 ; v1(148.06,59.76) 148.12,59.83 DIMM2.40 148.12,62.46 147.56,63.02 v1(147.53,63.02) 147.05,62.54 147.05,62.05 147.12,61.98 DIMM2.44 147.12,59.36 146.56,58.79 v1(145.97,58.79) 145.79,58.79 145.48,59.11 145.48,59.63 145.77,59.92 145.85,59.92 146.12,60.2 DIMM2.48 146.12,62.49 145.55,63.07 v1(145.31,63.07) 144.95,62.71 144.95,62.21 145.12,62.04 DIMM2.52 145.12,59.71 145.12,59.71 ; 93.37,70.65 DIMM2.251 93.37,68.03 ; v1(134.01,47.28) 133.63,47.66 DIMM1.98 133.63,50.19 v1(133.46,50.37) ; v1(49.88,92.85) U1.AD25 U1.AB25 ; U1.AB19 51.05,95.62 v1(50.7,95.98) 50.86,96.13 U1.AC17 ; U1.AV39 43.54,85.37 44.07,85.91 44.07,85.91 v1(44.06,85.91) ; v1(157.93,59.36) 158.39,58.9 158.39,58.46 157.88,57.95 DIMM1.1 157.88,56.33 157.51,55.96 v1(157.28,55.96) 157.21,55.96 156.88,56.28 DIMM1.5 156.88,58.78 156.59,59.07 156.16,59.07 v1(155.76,58.67) 155.88,58.54 DIMM1.9 155.88,56.39 156.06,56.22 156.06,55.42 v1(155.73,55.1) v1(154.62,55.1) 154.27,55.45 154.27,56.27 154.38,56.39 DIMM1.15 154.38,58.17 154.76,58.54 v1(154.76,58.56) 154.76,58.7 154.31,59.16 153.9,59.16 153.38,58.65 DIMM1.19 153.38,56.33 153.44,56.28 153.44,55.62 153.17,55.35 v1(152.94,55.35) 152.64,55.35 152.38,55.6 DIMM1.23 ; v1(53.48,143.53) 53.48,143.4 53.77,143.12 J69.16 ; U1.AK27 46.88,91.68 U1.AL26 46.69,92.14 v1(46.35,92.47) 46.69,92.8 U1.AL24 ; DIMM1.176 v1(112.13,47.82) 112.13,47.68 111.89,47.43 v1(111.89,46.83) ; DIMM1.99 133.38,56.08 134.23,55.24 134.23,54.54 133.89,54.2 v1(133.64,54.2) ; 135.62,59.82 DIMM2.90 135.62,62.1 135.35,62.38 v1(134.97,62.38) 134.62,62.03 DIMM2.94 134.62,59.71 ; U1.U33 54.01,88.32 v1(54.28,88.59) 54.28,88.87 U1.T32 ; v1(52.53,104.37) 52.74,104.58 52.74,106.32 52.14,106.91 52.14,107.2 v1(52.09,107.25) ; U1.J40 57.92,85.33 v1(57.92,85.71) 57.59,85.71 U1.K39 ; DIMM1.168 v1(114.13,47.77) 114.13,47.48 113.84,47.19 v1(113.62,47.19) 113.4,47.19 113.13,47.45 DIMM1.172 ; v1(41.35,86.19) 41.07,85.91 41.07,85.63 U1.BC40 ; v1(153.14,50.98) 153.37,50.98 153.63,50.72 DIMM1.18 153.63,47.46 153.36,47.19 v1(153.09,47.19) 152.9,47.19 152.63,47.45 DIMM1.22 152.63,50.83 152.46,51.01 v1(152.13,51.01) 151.89,51.01 151.63,50.75 DIMM1.26 151.63,47.57 151.63,47.56 151.24,47.17 v1(151.14,47.17) 150.93,47.17 150.63,47.47 DIMM1.30 150.63,50.19 150.74,50.3 150.74,51.25 v1(150.65,51.35) 150.6,51.39 v1(149.27,51.39) 148.99,51.11 148.99,50.13 149.13,49.99 DIMM1.36 149.13,47.45 148.88,47.2 148.65,47.2 v1(148.65,47.19) 148.4,47.19 148.13,47.45 DIMM1.40 148.13,50.66 147.79,51.01 v1(147.63,51.01) ; v1(135.12,67.99) 134.87,68.23 DIMM2.93 134.87,70.83 ; v1(135.63,50.35) DIMM1.90 135.63,47.82 v1(136.14,47.31) 136.63,47.8 DIMM1.86 136.63,50.53 137.07,50.97 v1(137.12,50.97) 137.28,50.97 137.63,50.61 DIMM1.82 137.63,47.4 137.91,47.12 v1(138.12,47.12) 138.38,47.12 138.63,47.37 DIMM1.78 138.63,49.97 138.45,50.15 138.45,51.08 138.71,51.34 v1(138.77,51.34) v1(139.88,51.34) 140.21,51.01 140.21,50.06 140.13,49.99 DIMM1.72 140.13,47.5 140.45,47.19 v1(140.65,47.19) 140.88,47.19 141.13,47.44 DIMM1.68 141.13,50.68 141.45,51 v1(141.63,51) 141.77,51 142.13,50.64 DIMM1.64 142.13,47.46 142.43,47.16 v1(142.67,47.16) 142.74,47.16 143.13,47.56 DIMM1.60 143.13,50.64 ; v1(55.57,147.89) 55.3,147.62 J69.7 ; 150.37,58.52 150.38,58.5 DIMM1.31 150.38,55.49 150.73,55.15 v1(150.88,55.15) 151.01,55.15 151.38,55.52 DIMM1.27 151.38,58.62 v1(152.02,59.25) ; v1(88.62,143.55) 88.6,143.55 88.35,143.3 PU93004.6 ; v1(52.86,88.42) U1.Y33 ; v1(40.92,83.35) 40.92,83.4
  TOP w0.279: v1(64.35,19.07) 64.36,19.05 D4003.8 D4003.3 v1(64.36,17.08) ; v1(14.49,117.07) 14.69,116.87 J219.45 ; v1(115.47,160.1) 115.58,159.98 M1U3.3 M1U3.8 ; J219.21 8.69,114.44 8.25,114 8.16,114 v1(8.12,113.96) 8.09,114 7.75,114 7.19,114.55 J219.15 ; 120.76,158.91 M1U4.8 120.76,160.17 120.83,160.24 v1(120.83,160.24) ; v1(71.09,154.52) D3603.8 D3603.3 v1(71.09,151.86) ; v1(110.6,47.22) 111,47.61 111,48 111.13,48.13 DIMM1.180 ; PU93001.6 163.16,123.59 PU93001.9
  TOP w0.305: v1(43,58.36) 42.7,58.66 J218.33 ; v1(140.94,94.13) 140.48,94.59 XU1.AW38 ; v1(140.02,111.55) 139.99,111.55 XU1.Y37 ; XU1.AM14 v1(118.08,101.46) 118.54,101.92 XU1.AL14 ; XU1.AM27 130.42,101 v1(129.97,100.55) ; v1(109.48,100.61) 109.08,101.01 XU1.AN6 ; v1(118.15,97.81) 118.15,97.74 XU1.AT14 ; v1(106.72,104.2) 107.18,104.66 XU1.AJ4 ; XU1.AN24 127.68,100.07 v1(128.09,99.66) ; XU1.AM11 115.71,101.01 v1(115.29,101.43) 115.77,101.92 XU1.AL11 ; XU1.F7 109.94,125.77 110.37,126.21 v1(110.39,126.21) ; XU1.AT36 138.65,97.3 v1(139.09,96.86) 139.57,97.34 XU1.AT37 ; v1(110.4,111.54) 110.84,111.98 XU1.AA8 ; XU1.A7 109.45,130.76 v1(108.58,130.76) ; XU1.V35 138.18,113.37 v1(138.19,113.37) ; v1(39.72,53.65) 39.42,53.65 38.95,53.18 J218.18 ; XU1.AN5 XU1.AN4 107.18,101.01 v1(106.72,100.54) ; v1(104.82,125.24) 104.82,125.32 XU1.F1 ; v1(111.3,100.61) 110.9,101.01 XU1.AN8 ; XU1.AU4 107.19,97.34 v1(107.65,96.88) ; v1(141.85,115.2) 141.84,115.2 XU1.T39 ; v1(130.86,102.38) 131.32,102.84 XU1.AK28 ; J219.57 17.69,114.79 17.5,114.59 v1(16.05,114.59) 16.19,114.74 J219.51 ; v1(133.63,102.38) 133.17,102.83 XU1.AK30 ; XU1.AK6 109.02,103.75 v1(109.47,104.2) ; v1(107.65,96.88) 108.11,97.34 XU1.AU5 ; v1(107.65,96.88) 108.1,96.43 XU1.AV5 ; XU1.A15 117.25,130.37 117.26,130.38 117.26,130.88 117.26,130.88 117.33,130.95 v1(117.33,131.19) ; v1(130.01,96.91) 130.42,97.32 XU1.AT27 130.42,97.37 v1(129.99,97.8) 129.99,97.83 XU1.AR27 ; XU1.U33 136.38,115.2 v1(136.39,115.2) ; XU1.AM31 134.08,100.93 v1(133.7,100.55) ; 140.02,105.12 v1(140.05,105.12) 140.05,105.1 XU1.AH38 ; XU1.G3 106.71,124.35 106.71,124.35 v1(106.72,124.34) XU1.H4 ; Q93033.1 132.02,167.84 131.85,168.01 v1(131.42,168.01) ; v1(113.31,50.89) 113.13,50.72 DIMM1.172 ; v1(133.63,94.98) 133.17,95.44 XU1.AV30 ; J219.27 10.19,114.79 10.41,114.57 v1(11.68,114.57) 11.69,114.58 J219.33 ; v1(132.65,99.63) 133.09,99.18 XU1.AP30 ; XU1.AU25 128.59,96.46 v1(128.14,96.91) 127.7,97.35 XU1.AT24 ; XU1.AK27 130.42,102.83 v1(129.97,102.38) 129.51,102.83 XU1.AK26 ; v1(4.62,117.92) 4.62,117.62 4.19,117.19 J219.3 ; J219.73 21.69,116.86 21.91,117.08 22.77,117.08 ; v1(132,47.72) 131.98,47.72 131.63,48.06 DIMM1.106 131.63,50.27 v1(131.77,50.41) ; XU1.AH40 143.3,104.66 143.83,105.19 v1(143.83,105.48) ; XU1.R33 136.36,117 v1(136.36,117.02) ; XU1.A11 113.18,130.68 v1(113.18,130.88) ; XU1.AH5 108.11,105.52 v1(107.64,105.05) ; v1(103.83,107.51) 103.93,107.41 XU1.AF1 ; v1(137.31,96.9) 137.29,96.9 XU1.AU34 ; XU1.H35 138.19,123.4 v1(138.19,123.45) ; XU1.AM24 127.68,100.98 v1(128.09,100.57) ; XU1.AR24 127.68,98.24 128.11,97.8 v1(128.14,97.8) ; XU1.AR34 137.28,97.81 v1(137.28,97.8) XU1.AT34 ; XU1.AK5 108.06,103.75 v1(107.65,103.34) 108.11,102.88 XU1.AL5 ; XU1.AT6 109.02,98.27 v1(108.57,98.71) ; v1(134.55,100.58) 134.98,101.01 XU1.AM32 ; XU1.AV39 141.39,95.52 v1(140.94,95.96) 140.5,95.52 XU1.AV38 ; v1(36.07,58.64) 36.2,58.77 J218.7 ; XU1.AM30 133.15,101.01 v1(132.71,100.57) 133.17,100.11 XU1.AN30 ; v1(108.58,124.34) 109.02,124.78 XU1.G6 ; XU1.F30 131.43,126.16 v1(131.43,126.17) ; XU1.AM17 120.82,100.54 v1(120.76,100.54) 120.37,100.14 XU1.AN16 ; XU1.T37 139.99,115.21 v1(139.99,115.2) ; XU1.K39 141.81,121.54 v1(141.81,121.56) ; XU1.AR17 v1(120.81,98.73) ; v1(140.02,118.83) 140.01,118.83 139.57,119.27 XU1.M37 ; XU1.AR36 138.59,98.26 v1(138.14,97.81) 137.74,98.2 XU1.AR35 ; J218.75 53.2,58.42 ; v1(104.03,104.19) 104.45,104.61 XU1.AJ1 103.9,105.21 v1(103.9,105.24) ; v1(125.34,100.54) 125.79,100.09 XU1.AN22 ; v1(138.19,117.02) 138.18,117.02 XU1.P35 ; J218.13 37.7,61.16 ; v1(139.99,121.55) 139.99,121.55 XU1.K37 ; XU1.AU39 141.4,96.44 v1(140.94,96.9) 140.93,96.91 140.93,96.91 XU1.AT38 ; XU1.AT5 108.12,98.26 v1(108.57,98.71) ; XU1.AD39 141.38,108.32 v1(140.94,107.89) 140.51,108.32 XU1.AD38 ; XU1.AN27 129.97,99.64 v1(129.97,99.61) ; v1(130.95,95.06) 131.34,95.45 XU1.AV28 ; XU1.AN19 123.05,100.09 v1(122.66,100.48) 122.66,100.56 XU1.AM19 ; v1(140.08,98.72) 140.03,98.72 XU1.AP37 ; XU1.AW9 111.84,95.52 v1(112.29,95.97) 111.82,96.43 XU1.AV9 ; XU1.AH36 138.22,105.09 v1(138.22,105.12) 138.22,105.15 XU1.AG36 ; XU1.A17 119.08,130.85 v1(119.15,130.92) ; XU1.AL30 133.13,101.92 v1(132.71,102.34) ; XU1.AJ36 XU1.AH37 139.12,105.12 v1(139.12,105.13) ; XU1.AP14 118.54,99.17 118.14,98.77 v1(118.14,98.73) ; XU1.AT7 109.94,98.2 v1(110.33,97.81) ; v1(108.57,98.71) 108.11,99.18 XU1.AR5 ; J218.57 48.7,58.95 48.65,58.9 48.65,58.36 49.02,57.99 49.39,57.99 49.61,57.77 v1(49.77,57.77) 49.99,57.77 50.3,58.08 50.3,58.91 50.2,59.01 J218.63 ; XU1.AJ35 137.74,103.74 v1(138.19,103.29) 138.64,102.84 XU1.AK36 ; v1(103.13,114.78) 103.19,114.72 XU1.V1 ; v1(128.16,98.73) 128.13,98.73 XU1.AP24 ; v1(111.36,93.31) 111.56,93.31 112,93.75 112,94.37 XU1.AY9 ; XU1.AJ33 136.31,104.15 136.36,104.15 v1(136.39,104.18) 136.4,104.18 XU1.AJ34 ; XU1.P1 104.89,117.94 v1(104.89,117.94) ; XU1.AA3 v1(105.39,111.98) ; v1(124,129.83) 123.65,129.49 XU1.C22 ; v1(109.96,160.82) 109.75,160.62 109.75,160.11 109.98,159.88 AQ19.4 ; XU1.D4 XU1.C5 v1(108.58,128.91) XU1.B6 ; v1(118.08,99.63) 118.54,100.09 XU1.AN14 ; XU1.C20 121.82,128.95 v1(121.94,129.07) ; XU1.AN23 126.8,100.09 v1(127.24,99.65) ; v1(105.83,103.34) 106.28,102.89 XU1.AL3 ; XU1.AT15 XU1.AR16 v1(120.81,97.82) ; XU1.AL36 139.11,101.47 v1(139.11,101.4) 139.5,101.01 XU1.AM37 ; XU1.U3 106.28,115.87 106.79,116.38 107.02,116.38 XU1.T4 v1(106.73,117.01) ; XU1.AR3 105.82,98.72 v1(105.82,98.65) ; XU1.AT26 129.48,97.35 v1(129.01,97.82) ; XU1.AK29 132.25,102.83 v1(131.8,102.38) ; v1(140.96,122.52) XU1.H39 ; XU1.AA33 136.36,111.51 v1(136.36,111.51) ; v1(141.82,117.02) 141.82,117.04 XU1.P39 ; SC25.2 30.91,64.84 v1(30.91,64.46) ; J219.9 5.69,116.87 5.66,116.91 v1(5.66,116.91) ; XU1.T1 104.37,116.55 v1(103.88,117.03) ; v1(138.16,115.2) 138.16,115.21 XU1.T35 ; XU1.AF37 139.57,106.55 v1(139.11,107.01) 139.11,106.95 XU1.AF36 ; J218.39 44.2,58.97 44.07,58.84 44.07,58.2 44.61,57.66 44.81,57.66 45.21,58.06 v1(45.6,58.06) ; v1(103.2,96.92) 104.02,96.92 XU1.AU1 ; v1(51.95,57.83) 51.7,58.08 J218.69 ; v1(138.23,121.55) 138.16,121.55 XU1.K35 ; XU1.AK37 v1(140.01,102.39) ; v1(140.04,117.02) 140.04,117.02 139.59,117.47 XU1.P37 ; XU1.V37 139.89,113.49 140.01,113.37 v1(140.02,113.37) ; v1(130.87,94.14) XU1.AY27 ; XU1.AD36 139.09,107.88 v1(139.14,107.88) 139.57,108.31 XU1.AD37 ; v1(141.82,118.83) 141.82,118.87 XU1.M39 ; v1(12.85,114.56) 12.88,114.56 13.19,114.87 J219.39 ; XU1.C10 112.23,127.99 v1(112.23,127.97) ; XU1.AW36 139.14,94.12 v1(139.16,94.12) ; XU1.AH39 141.4,104.73 v1(141.85,105.18) ; XU1.AM40 143.07,101.01 v1(143.53,101.47) ; v1(143.5,103.54) 143.5,103.29 143.39,103.18 143.39,103.17 143.08,102.86 143.08,102.86 143.05,102.84 XU1.AK40 142.31,102.84 v1(141.86,103.28) ; XU1.AK7 109.96,103.75 v1(110.39,104.18) ; XU1.AR23 126.75,98.26 v1(126.3,98.71) XU1.AR22 ; XU1.AF40 143.18,106.49 ; v1(112.22,121.61) 111.76,121.15 XU1.L9 XU1.M10 ; XU1.AT39 141.4,97.35 v1(141.85,96.9) XU1.AU40 ; v1(131.8,96.96) 132.19,97.35 XU1.AT29 XU1.AU30 ; v1(138.16,111.51) 138.16,111.55 138.06,111.66 XU1.Y35 ; v1(104.91,102.44) 104.91,102.44 104.97,102.44 XU1.AL2 ; v1(104.91,98.65) 105.36,99.1 XU1.AR2 ; XU1.AL4 107.22,102.84 107.62,102.44 v1(107.64,102.44) 108.11,101.97 XU1.AM5 ; v1(78.98,19.15) D3301.8 D3301.3 v1(78.98,17) ; XU1.AV26 129.29,95.74 129.24,95.74 v1(129.06,95.92) ; v1(115.55,131.23) 115.55,131.19 115.42,131.06 XU1.A13 ; v1(105.83,106) 106.28,106.45 XU1.AG3 ; XU1.AT28 131.29,97.35 v1(130.88,96.94) ; XU1.AK22 125.91,102.84 v1(126.37,102.37) ; XU1.C14 115.91,128.01 v1(115.87,128.01) ; v1(106.73,98.65) 106.73,98.72 106.74,98.73 106.74,98.73 XU1.AR4 ; XU1.AT10 112.68,98.19 v1(112.29,97.8) 111.83,98.26 XU1.AT9 ; XU1.V39 141.84,113.37 v1(141.85,113.37) ; v1(133.62,94.14) 133.17,93.69 XU1.AY30 ; v1(137.28,100.49) 137.74,100.96 XU1.AM35 XU1.AM36 ; XU1.H37 139.43,122.81 139.38,122.76 139.14,122.53 v1(139.14,122.48) ; PC24.2 51.46,139.59 51.65,139.78 51.65,139.78 51.76,139.89 v1(51.76,140.05) ; XU1.AV34 XU1.AW34 v1(136.31,94.09) ; v1(136.36,113.37) 136.36,113.35 XU1.W33 ; XU1.AN10 112.62,101.01 v1(112.23,100.61) 111.83,101.01 XU1.AN9 ; XU1.AJ24 v1(127.68,104.41) ; v1(116.26,96.89) 115.79,97.35 XU1.AT11 ; v1(135.42,97.82) 135.42,97.78 XU1.AT32 ; XU1.AM39 141.4,101.08 v1(140.94,101.54) 140.48,101.08 XU1.AM38 ; J219.75 22.19,114.67 v1(22.12,114.59) 22.05,114.52 21.41,114.52 21.19,114.73 J219.71 ; XU1.AR19 123.05,98.26 v1(122.59,98.71) ; XU1.AR20 124.02,98.31 v1(124.42,98.71) 124.87,98.26 XU1.AR21 ; XU1.AG2 105.36,106.48 v1(104.89,106) 104.45,106.45 XU1.AG1 ; XU1.AL27 130.42,101.92 v1(129.99,101.49) ; XU1.AP36 139.05,99.58 v1(139.05,99.63) 138.65,100.03 XU1.AN36 ; v1(18.64,55.3) 18.57,55.23 SR221.2 ; XU1.AM33 135.91,100.96 v1(136.38,100.49) 136.82,100.94 XU1.AM34 ; XU1.AT30 XU1.AR31 134.5,97.85 v1(134.55,97.85) ; XU1.AJ5 108.15,104.66 v1(108.57,105.09) ; v1(111.38,97.81) 110.92,98.26 XU1.AT8 ; v1(111.31,103.36) 111.37,103.36 XU1.AK9
  TOP w0.356: XU1.AK18 122.19,102.81 v1(121.73,102.35) 121.28,102.8 XU1.AK17 ; XU1.AK15 119.45,102.8 v1(119.88,102.37) 120.34,102.84 XU1.AK16 ; XU1.AK19 123.12,102.84 v1(123.56,102.4) 124,102.84 XU1.AK20 ; XU1.AK12 116.77,102.84 v1(117.21,102.4) 117.62,102.81 XU1.AK13 ; v1(114.96,124.27) 114.96,124.32 115.29,124.65 XU1.G13 ; XU1.AK10 112.95,104.02 v1(113.22,104.02) ; v1(111.31,103.36) 111.24,103.36 XU1.AK8 ; XU1.AK25 128.59,102.83 v1(129.06,102.37) ; XU1.AH8 v1(111.3,106.03) ; AQ20.4 70.47,140.37 70.66,140.55 70.94,140.55 71.14,140.35 v1(71.14,140.22) ; v1(109.59,93.28) 109.64,93.28 110.1,93.74 110.1,94.44 XU1.AY7 ; v1(126.37,102.37) 126.77,102.76 XU1.AK23 ; XU1.AL21 124.94,101.92 v1(125.41,102.4) ; XU1.E37 139.98,126.11 v1(139.98,126.13) 139.98,126.19 XU1.D37 ; v1(110.39,104.18) 110.85,104.64 XU1.AJ8 ; M1C114.2 113.36,157.76 113.36,158.36 113.14,158.58 AQ19.1 ; XU1.F36 138.25,124.38 v1(138.25,124.32) ; XU1.H7 XU1.J6 ; v1(128.1,101.46) 128.1,101.5 XU1.AL24 ; v1(123.18,126.14) 123.18,126.16 XU1.E21 ; XU1.H11 113.59,123.9 v1(114.03,124.34) 114.51,123.87 XU1.H12 ; AQ20.1 69.17,136.86 v1(69.65,136.39)
  TOP w0.381: XU1.K4 106.75,122.48 v1(106.72,122.48) 106.72,122.51 XU1.J3 ; XU1.B24 125.7,129.58 125.7,130.05 XU1.A24 126.27,131.06 v1(126.44,131.06) ; v1(131.43,122.48) 131.41,122.48 XU1.K30 ; XU1.E23 124.12,126.16 v1(124.12,126.14) 124.09,126.14 XU1.F22 ; XU1.E33 136.23,126.01 136.35,126.14 v1(136.35,126.17) ; v1(108.55,119.77) 109.02,119.29 XU1.N6 ; v1(114.07,123.39) XU1.J12 ; XU1.F28 129.6,126.15 v1(129.6,126.17) ; XU1.G33 136.31,124.26 v1(136.37,124.26) ; XU1.F26 127.51,125.9 127.75,126.14 v1(127.75,126.17) ; v1(142.96,126.61) XU1.D40 XU1.D39 v1(140.95,126.16) ; XU1.G11 113.16,124.35 v1(113.16,124.34) ; XU1.M17 118.63,120.66 v1(118.63,120.67) ; XU1.K15 116.81,121.6 v1(116.8,121.6) ; v1(127.75,128) 127.75,127.97 XU1.D26 ; v1(113.16,122.48) 113.15,122.48 XU1.J10 ; v1(117.69,126.14) 117.69,126.17 XU1.E15 ; XU1.K28 129.58,122.48 v1(129.6,122.48) ; v1(129.6,128) 129.6,127.98 XU1.D28 ; XU1.C24 125.92,128 v1(125.92,128) 125.92,127.97 125.81,127.85 125.68,127.72 XU1.D24 ; XU1.E3 106.72,126.17 v1(106.72,126.13) 106.76,126.13 XU1.F4 ; v1(125.92,120.67) 125.94,120.67 XU1.M25 ; v1(138.14,128) 138.14,127.93 137.74,127.52 XU1.C35 ; v1(125.03,120.67) 125.02,120.67 XU1.M23 ; XU1.L3 v1(106.72,120.68) XU1.M4 ; v1(127.75,129.8) 127.75,129.79 XU1.B26 ; v1(118.63,122.54) 118.58,122.54 XU1.J16 ; v1(125.92,122.48) 125.92,122.48 XU1.K24 ; v1(108.53,122.49) 108.56,122.49 XU1.J6 ; v1(135.45,122.54) 135.45,122.49 XU1.J32 ; XU1.Y5 108.55,113.34 v1(108.57,113.34) 108.57,113.36 XU1.W6 ; XU1.P4 v1(106.72,118.85) 106.28,119.29 XU1.N3 ; v1(34.44,93.67) 34.26,93.67 33.98,93.94 SR184.2 ; XU1.H1 104.19,123.87 v1(103.87,123.54) ; XU1.M27 127.77,120.67 v1(127.75,120.67) ; v1(123.18,124.34) 123.21,124.34 123.32,124.45 XU1.G22 ; v1(143.24,124.9) 143.13,124.78 XU1.F40 ; v1(136.36,118.84) XU1.N33 ; XU1.E9 v1(112.23,126.14) XU1.F10 112.71,125.7 v1(113.16,126.14) 113.16,126.15 113.16,126.18 113.46,126.48 XU1.E11 ; XU1.L6 109.48,121.58 v1(109.48,121.6) 109.49,121.6 XU1.K7 ; XU1.C33 136.35,127.97 v1(136.35,128) ; XU1.J34 136.37,122.5 v1(136.37,122.55) ; v1(135.49,119.78) 135.42,119.78 XU1.L32 ; v1(111.25,114.26) 111.25,114.32 XU1.V8 ; v1(107.67,130.75) XU1.A4 ; XU1.M21 122.29,120.66 v1(122.29,120.67) ; XU1.M35 137.74,119.27 138.16,118.84 v1(138.16,118.83) ; XU1.G31 133.66,124.29 v1(133.62,124.29) ; XU1.H30 131.39,124.29 v1(131.43,124.29) ; v1(116.8,120.67) 116.8,120.66 XU1.M15 ; XU1.M12 114.95,120.65 v1(114.95,120.67) ; XU1.E31 134.54,126.15 v1(134.54,126.17) ; v1(108.6,116.11) 108.6,116.06 XU1.U6 ; XU1.L13 115.42,121.13 v1(115.89,121.6) 115.89,121.6 XU1.K14 ; v1(105.06,129) 105.06,128.74 XU1.C2 ; XU1.H28 129.56,124.29 v1(129.6,124.29) ; v1(129.6,129.8) 129.58,129.8 XU1.B28 ; XU1.D30 131.43,127.99 v1(131.43,128) ; XU1.G17 119.07,124.78 v1(118.63,124.34) ; XU1.M1 104.86,120.62 v1(104.86,120.66) ; XU1.J20 122.24,122.54 v1(122.29,122.54) ; XU1.B30 131.41,129.8 v1(131.43,129.8) ; XU1.E6 v1(108.54,126.13) ; XU1.N8 v1(110.38,119.77) XU1.M7 ; XU1.G19 121.35,124.34 v1(121.37,124.34) ; v1(138.21,126.2) 137.74,125.72 XU1.E35 ; v1(134.54,128) 134.54,127.98 134.4,127.84 XU1.C31 ; XU1.E19 120.6,126.3 120.46,126.16 v1(120.46,126.14) ; XU1.H26 127.73,124.29 v1(127.75,124.29) ; v1(121.37,122.54) 121.35,122.51 121.35,122.48 XU1.K19 ; XU1.D7 110.38,127.97 v1(110.39,127.97) 110.39,127.98 XU1.C8 ; v1(119.55,122.54) 119.55,122.5 XU1.K17 ; XU1.H21 122.29,123.42 v1(122.29,123.4) ; v1(119.55,127.05) 119.52,127.05 XU1.E17 ; XU1.K1 104.86,122.45 v1(104.86,122.48) ; v1(127.75,122.48) 127.75,122.48 XU1.K26 ; v1(129.6,120.67) XU1.M29 ; XU1.H24 125.9,124.29 v1(125.92,124.29) ; XU1.M10 113.15,120.68 v1(113.16,120.68) 113.16,120.69 XU1.L11 ; v1(140,127.09) XU1.C37 ; XU1.G8 110.85,124.78 v1(111.3,124.34) 111.3,124.33 XU1.H9 ; XU1.K22 124.1,122.48 v1(124.12,122.48) ; v1(120.46,122.54) 120.41,122.54 XU1.J18 ; XU1.E13 115.87,126.16 v1(115.87,126.14) ; v1(136.37,120.67) XU1.K33 ; v1(120.46,120.67) 120.46,120.66 XU1.M19 ; v1(111.68,117.46) 111.68,117.47 XU1.R8 ; XU1.C16 118.59,128.01 v1(118.63,128.01) ; M1R14.1 153.86,161.67 ; v1(108.59,117.9) XU1.R6 ; XU1.B38 v1(140.96,128.92) ; v1(105.86,117.94) 105.86,117.89 XU1.R3
  TOP w0.406: v1(76.44,26.2) 76.44,25.62 SR213.2 ; v1(33.76,74.68) 33.76,75.24 SCB27.2 33.48,75.52 HC15.1 ; C2726.2 32.98,70.56 v1(33.11,70.69) ; v1(31.88,68.7) 32.36,68.21 SR7923.2 ; SR7876.2 44.37,41.61 v1(44.37,42.03) ; SC14.2 30.69,104.08 v1(30.57,104.2) ; SCB125.2 29.14,70.09 29.03,70.09 SCB127.2 ; v1(32.61,72.98) 32.14,72.51 31.97,72.51 C2715.2
  TOP w0.432: HC4.2 86.13,123.98 86.43,124.29 HC5.2 87.6,124.29 88.06,124.75 v1(88.27,124.75) ; v1(67.69,140.73) 68.38,141.42 SR8002.1 ; v1(129.94,154.73) 129.94,154.98 129.83,155.09 M1R19.2 ; SR7932.2 36.77,47.61 SR7933.2 36.77,46.38 37.16,45.99 37.32,45.99 v1(37.34,45.98) ; OR59.2 13.37,99.32 v1(13.22,99.47) ; SR122.2 32.78,84.79 32.83,84.74 33.61,84.74 v1(34.05,84.29) 33.71,83.95 SR121.2 ; 67.19,48.17 C941636.2 66.69,48.76 ; PR7301.2 79.84,63.96 v1(79.96,63.85) ; v1(47.12,68.09) 47.12,68.44 48.02,69.34 SR222.2 ; R99529.2 33.07,31.61 v1(33.43,31.25) ; SR35.2 45.71,73.27 v1(46.34,73.27) 46.36,73.29 47.06,73.29 47.13,73.23 47.68,73.23 CB4134.1 CB4133.1 ; OR118.2 11.94,93.83 v1(11.76,93.83) ; SC16.2 32.88,101.04 32.68,100.84 32.68,100.55 SC15.2 33.38,100.47 v1(33.4,100.46) ; O2R9.2 11.01,104.44 10.57,104.89 v1(10.39,104.89) ; PC89002.2 89.5,158.73 89.53,158.77 89.53,160.54 PU89001.54 ; SR7904.2 M1C113.2 v1(123.89,159.6) ; v1(20.9,31.36) 21.4,31.85 SR220.2
  TOP w0.457: v1(45.79,132.49) 46.26,132.96 PR47.2 ; M1C102.2 111.82,167.58 v1(112.34,167.58) 112.34,166.79 M1R22.2 ; v1(16.43,150.28) 16.43,150.26 16.58,150.12 LC5.2 D3106.2 ; v1(89.25,72.26) 89.51,72.01 D4C8.2 ; SC85.2 47.86,110.3 v1(48.31,110.3) ; LC8.2 35.9,157 35.87,157.04 D3103.2 ; v1(33.44,87.44) 33.54,87.34 SR7875.1 ; O2CB19.2 16.93,90.07 16.94,90.06 v1(16.95,90.06) ; PU89001.56 90.31,165.48 PC89021.2 PR89035.1 ; R2104.2 61.06,109.01 v1(60.65,109.41) ; LC7.2 26.69,150.5 26.69,150.37 27.02,150.04 v1(27.02,149.34) ; PU89001.57 94.04,165.05 PR89063.1 PC89033.2 ; M1C114.2 113.09,156.97 113.79,156.28 v1(113.79,156.02) ; R93100.2 157.62,170 157.54,170.08 C941629.2 ; v1(86.84,169.43) 86.84,169.75 PC89001.2 ; HCB3.1 71.25,109.86 v1(70.74,110.38) ; S1C81.2 57.36,45.41 57.78,45.41 v1(57.86,45.33) ; PR46.2 52.74,133.09 v1(52.74,133.57) ; v1(39.24,73.57) 39.27,73.6 39.27,74.45 SC30.2 ; v1(22.84,99.73) 23.54,99.73 23.65,99.84 O2CB7.2 ; v1(70.43,117.41) 70.99,117.41 71.41,117.83 HR45.2 ; C12.2 15.52,106.62 15.13,107.02 v1(15.13,107.05) ; v1(22.41,75.45) 22.4,75.45 21.99,75.05 SR7983.2 ; v1(39.33,65.45) 39.33,64.75 39.06,64.48 SC26.2 SR291.2 ; 28.93,114.25 SR699.2 29.51,113.69 ; v1(109.96,160.82) 110.07,160.94 M1C112.2 ; PR89073.2 v1(141.83,144.67) ; v1(57.83,47.91) 57.54,48.2 57.47,48.2 S1C80.1 ; PR89038.2 92.44,156.82 v1(92.84,156.43) ; v1(70.66,119.36) 71.05,119.75 HR83.2 ; v1(99.72,7.79) 99.65,7.72 PC9416.2 ; SC17.2 31.53,91.62 v1(31.57,91.58) ; HC3.2 v1(87.21,136.39) ; v1(70.43,118.05) 70.8,118.05 71.54,118.79 HR44.2 ; v1(84.81,67.99) 84.76,68.04 D4R11.2 ; v1(87.48,164.1) 87.48,164.29 PC89017.2 ; v1(63.65,108.75) 63.59,108.82 R2103.2 62.89,108.81 SR322.2 ; OR144.1 10.37,101.74 v1(10.4,101.72) ; PC89035.1 97.92,161.1 v1(97.92,161.1) ; v1(8.54,25.09) AC204.1 ; SR7870.1 33.36,86.48 v1(33.39,86.5) 33.4,86.5 33.48,86.43 SR7874.1 ; C941625.2 131.88,166.49 131.42,166.94 v1(131.42,168.01) ; v1(30.82,90.26) 31.16,90.6 SR230.2 ; SR185.2 34.52,92.31 v1(34.32,92.51) ; SR7868.1 31.99,82.98 v1(32.1,83.1) ; v1(21.44,148.81) 21.23,148.61 SR818.2 ; v1(82.07,106.59) 82,106.53 PC30.2 ; PC7899.2 v1(34.75,23.95) ; C941488.2 29.74,32.06 C941489.2 29.4,31.19 29.7,30.89 v1(29.94,30.89) ; PC21.2 50.32,139.52 v1(50.32,139.93) ; SC84.2 SR292.2 39.01,108.45 v1(39.01,107.97) ; SC32.2 51.63,107.72 v1(52.09,107.25) ; SC21.2 SC22.2 33.65,89.73 v1(33.17,89.73) ; v1(32.41,107.03) 31.94,106.56 R2348.2 ; v1(148.92,83.2) 148.56,83.2 148.1,82.74 HR7.2 ; R93118.1 19.07,94.45 v1(19.23,94.3) ; SC31.2 54.34,108.7 54.85,108.2 v1(54.85,107.99) ; PR1016.1 PC95.2 72.31,65 72.31,64.5 71.87,64.06 71,64.06 v1(70.69,64.38) 70.65,64.42 PC808.2 ; v1(30.91,64.46) 31.08,64.29 SC83.2 ; O2R24.1 17.73,93.67 v1(17.57,93.83) ; 149.81,73.09 HR8.2 ; v1(93.66,71.88) 93.53,72.01 D4C7.2 ; PR89071.2 PRT89003.2 123.19,145.24 v1(123.19,145.61) ; v1(83.55,123.51) 84.16,124.12 HR81.2 ; v1(168.27,75.91) FCB1.2
  TOP w0.483: v1(68.71,15.38) D3302.2 v1(68.71,17.39)
  TOP w0.508: v1(78,81.52) 78,81.52 Q7.2 ; v1(152.31,75.35) 151.99,75.67 HQ1.2 ; v1(73.38,57.39) 73.29,57.49 J303.7 ; Q9435.2 v1(28.14,53.94) ; P305.2 v1(66.15,9.01) ; PC941666.2 v1(168.32,139.25) ; U9434.4 58.37,68.21 59.05,68.9 v1(59.33,68.9) 59.88,68.35 59.88,68.02 60.27,67.63 E61.10 U9435.10 ; SW_RST1.4 v1(1.88,20.72) ; C98.2 17.91,147.56 v1(18.01,147.67) ; v1(93.45,8.75) 93.74,8.46 PC941613.2 ; v1(166.72,37.53) 166.68,37.58 Q9346.2 ; PR122.1 v1(29.45,22.04) ; C3102.1 16,169.81 15.9,169.92 ; v1(72.41,23.18) 73.01,23.77 TUC34.2 ; Y18.2 55.03,109.93 v1(55.03,108.9) ; v1(27.89,22.04) 27.89,22.95 28.4,23.46 C941649.2 ; Q9535.2 28.39,25.89 v1(28.65,26.15) ; v1(1.7,22.16) 2.08,22.55 2.08,23.08 1.88,23.28 SW_RST1.3 ; v1(122.6,156.59) 123.04,157.02 R99508.2 ; PR89064.1 93.79,160.81 PU89001.55 ; v1(165.4,34.38) 165,34.38 164.7,34.68 R4816.2 ; v1(168.51,25.5) 168.51,25.64 CR22.2 ; v1(98.55,169.74) 98.86,169.43 PC89006.2 ; Q9534.2 28.39,29.19 v1(28.65,29.45) ; v1(9.83,72.05) 9.71,72.16 R7209.2 ; CB4152.2 0.84,131.33 ; v1(38.33,164.54) 38.25,164.54 38.25,164.55 37.88,164.55 D3104.2 ; AC24.2 22.5,17.03 v1(22.04,17.03) ; C3101.1 v1(36.24,169.99) ; P12.11 0.92,121.6 ; Q17.2 24.95,73.72 v1(24.79,73.88) ; AC70.2 42.31,111.09 42.74,111.52 v1(42.74,111.93) ; v1(58.84,119.65) 58.01,119.65 PCE4.2 56.71,118.35 v1(56.03,118.35) ; v1(28.82,57.49) Q9434.2 ; PQ93012.2 49.31,142.37 v1(49.45,142.23) ; v1(4.88,56.63) 4.55,56.96 SR217.2 ; M1Q9.2 136.53,160.55 v1(137.06,161.08) ; v1(153.95,80.28) 153.5,79.83 HQ2.2 ; CR4.2 168.46,30.24 v1(168.46,30.02) ; PQ101.2 37.31,108.61 v1(37.31,108.04) ; v1(19.5,31.36) 19.45,31.41 SC87.2 ; J68.18 76.78,149.15 76.61,149.32 v1(76.05,149.32) ; AC1.2 17.66,26.03 v1(17.65,26.03) ; v1(79.6,112.64) 79.4,112.44 HCB6.1 ; Q5.2 v1(84.63,77.69) ; UU22.2 39.59,165.15 v1(39.95,164.79) ; D4C6.2 89.94,73.73 v1(89.94,73.89) ; v1(76.59,141.37) 76.81,141.15 J68.2 ; v1(16.66,148.76) 16.74,148.83 C97.2 ; C941623.2 v1(158.47,168.39) ; R79.2 48.53,140.23 v1(48.34,140.05) 48,140.05 47.72,140.33 PC36.2 ; v1(81.99,143.57) 81.99,143.78 82.36,144.15 J68.7 ; CR5.2 168.46,28.71 v1(168.46,28.5) ; 81.49,139.82 82.78,139.82 83.39,140.43 J68.1 ; PC17.2 v1(47.39,136.72) ; v1(81.38,72.63) 81.38,72.35 Q6.2 ; AC92.2 24.67,31.17 25.94,31.17 ; v1(41.63,155.09) D3702.2 v1(41.63,156.96) ; SR7814.1 SR916.1 5.58,27.32 6.22,27.96 v1(6.81,27.96) ; M1R20.2 125.45,159.5 v1(125.32,159.63) ; v1(150.71,158.33) 150.91,158.13 D4310.2 ; v1(1.68,31.03) Q16.2 ; v1(82.37,111.14) 82.36,111.13 81.64,111.13 81.62,111.15 PC25.2 ; CR23.2 167.87,33.3 v1(167.89,33.27) ; C248.2 13.52,12.68 ; v1(14.9,123.85) 15.47,123.28 15.59,123.28 PQ45.2 ; SR552.2 50.6,110.91 v1(50.52,110.99) ; v1(106.08,166.89) C941645.2 ; P12.9 0.97,122.6 ; D3106.2 18.58,150 C49.2 ; v1(168.49,27) 168.49,27.16 CR6.2 ; 35.13,158.13 35.34,157.92 D3103.2 ; v1(143.42,142.53) PRT89004.2 ; Q9438.2 30.74,37.31 v1(30.78,37.35) 30.1,38.04 C941648.2 ; v1(48.31,109.67) 48.87,109.67 SC86.2 ; PC97.2 v1(68.58,66.79) ; SR289.2 36.75,63.49 v1(36.93,63.67) ; UU66.2 75.56,20.11 v1(75.62,20.06) ; HR57.2 115.03,118.59 v1(114.95,118.67) ; J68.13 84.37,147.15 v1(84.58,147.35) ; v1(51.36,111.8) 51.57,112.02 Y18.4 ; PC941497.2 168.34,141.76 v1(168.4,141.7) ; C249.2 v1(15.14,13.53) ; PC93007.1 v1(163.78,121.9) ; v1(76.61,146.2) 76.62,146.2 76.68,146.15 J68.12 ; C941629.2 157.54,171.51
  TOP w0.635: 1.4,12.27 SW10.5 ; SW10.5 2.43,13.3 ; SW10.5 1.4,14.33 ; J200.10 65.37,9.55 ; 165.92,164.46 J1.4 ; J1.4 165.14,165.55 ; J1.4 166.71,165.55 ; J1.4 165.92,166.64 ; 78.8,14.34 J133.7 ; 167.15,162.67 J1.8 ; J1.8 166.39,163.74 ; J1.8 166.39,161.6 ; J1.8 165.63,162.67 ; J200.11 52.23,10.32 52.96,9.59 ; 4.6,12.27 SW10.6 3.57,13.3 ; J133.4 82.3,12.72 ; 166.71,170.3 J1.3 ; J1.3 165.92,169.21 ; J1.3 165.14,170.3 ; J133.10 83.32,11.78 ; J133.10 85.37,13.88 ; J133.10 85.37,9.73 ; 70.91,10.46 J133.11 73.55,10.46
  IN1 w0.127: 67.16,56.66 67.16,58.16 65.66,59.65 65.66,60.19 65.91,60.44 66.85,60.44 67.23,60.06 68.4,60.06 70.2,61.86 70.2,63.72 69.47,64.45 69.47,67.55 74.12,72.2 74.12,81.32 69.67,85.77 69.67,91.66 70.03,92.01 70.03,93 69.47,93.56 68.23,93.56 65.22,96.57 61.73,96.57 v1(59.13,93.97) 58.62,93.46 56.46,93.46 56.18,93.18 55.73,93.18 54.99,93.92 v1(54.99,96.23) 54.99,96.64 54.08,97.55 v1(54.08,98.21) 53.39,98.9 52.75,98.9 52.45,98.59 52.45,98.06 54.11,96.4 v1(54.11,93.55) 54.54,93.55 55.47,92.62 56.39,92.62 56.72,92.96 58.52,92.96 58.54,92.98 58.97,92.98 v1(59.42,92.52) 59.42,93.2 59.92,93.69 59.92,94.01 61.97,96.07 64.96,96.07 68.07,92.95 68.91,92.95 v1(69.24,92.62) 69.24,92.06 69.11,91.94 69.11,85.54 73.56,81.09 73.56,72.41 71.45,70.3 v1(70.99,70.3) 70.99,69.87 68.88,67.76 68.88,67.1 v1(68.58,66.79) 68.91,66.46 68.91,64.15 69.59,63.46 69.59,62.07 68.17,60.65 67.47,60.65 67.13,60.99 67.13,61.06 v1(66.91,61.28) 66.63,61 65.63,61 65.05,60.42 65.05,59.41 66.44,58.02 66.44,57.7 v1(66.33,57.6) 65.77,57.04 PU7601.10 65.43,56.73 64.11,56.73 63.55,56.17 60.43,56.17 59.71,55.46 58.01,55.46 57.86,55.62 57.25,55.62 56.99,55.36 56.99,55.01 57.32,54.68 57.52,54.68 v1(57.87,54.32) 58.41,54.85 60.09,54.85 60.81,55.57 63.75,55.57 64.29,56.1 66.6,56.1 67.16,56.66
  IN1 w0.635: 2.42,16.39 SW10.A 2.42,14.61 ; SW10.5 2.43,13.3 ; SW10.5 1.4,14.33 ; SW10.5 1.4,12.27 ; SW10.6 4.6,14.33 ; SW10.6 5.63,13.3 ; SW10.6 3.57,13.3 ; SW10.6 4.6,12.27
  IN2 w0.635: 2.42,14.61 SW10.A 2.42,16.39 ; 3.57,13.3 SW10.6 ; SW10.6 4.6,14.33 ; SW10.6 4.6,12.27 ; SW10.6 5.63,13.3 ; SW10.5 2.43,13.3 ; SW10.5 1.4,12.27 ; SW10.5 1.4,14.33
  BOTTOM w0.178: SR7947.1 40.02,82.55 40.03,82.54 40.46,82.54 40.74,82.81 40.74,83.15 40.92,83.33 v1(40.92,83.35)
  BOTTOM w0.191: v1(9.41,94.69) 9.34,94.76 U104.66 ; U104.59 11.91,93.68 v1(11.76,93.83) ; U104.17 22.91,100.36 22.72,100.17 22.72,99.85 v1(22.84,99.73) 23,99.73 23.23,99.96 U104.18 ; v1(20.47,93.89) 21.06,93.89 21.51,93.44 U104.35 ; v1(19.23,94.3) 19.23,93.94 19.51,93.66 U104.40 ; v1(10.4,101.72) 9.45,102.67 9.45,104.03 9.12,104.36 U104.90 ; U104.117 17.91,107.39 17.72,107.2 16.64,107.2 16.48,107.05 v1(15.13,107.05) ; U104.1 22.82,106.76
  BOTTOM w0.203: v1(21.11,104.23) 21.11,105.32 22.55,106.76 22.82,106.76 ; PU9.14 138.93,27.66 PU9.22 ; v1(40.92,83.35) 40.75,83.52 40.12,83.52 40.06,83.58 SR272.2 ; PU9.24 137.49,27.26 PU9.1 ; PU9.3 v1(136.24,28.06)
  BOTTOM w0.229: PU8402.11 95.19,11.01 94.72,10.53 v1(94.59,10.53)
  BOTTOM w0.254: PJP89004.2 143.49,124.65 v1(143.24,124.9) ; v1(77.93,106.19) 78.51,105.6 79.14,105.6 79.58,106.03 79.58,106.71 79.32,106.96 XDP1.59 ; HR40.2 79.74,115.43 v1(79.71,115.46) XDP1.25 ; HR39.2 79.83,116.83 v1(79.7,116.96) XDP1.19 ; HR38.2 80.92,118.19 80.92,118.26 HR37.2 79.78,118.73 v1(79.7,118.66) 79.51,118.46 XDP1.13 ; XDP1.49 79.22,109.46 79.42,109.26 79.42,108.35 80.14,107.64 81.02,107.64 v1(82.07,106.59) ; v1(56.75,76.56) 56.75,76.3 56.5,76.05 SR7816.2 ; HR43.2 80.21,112.41 80.11,112.51 79.73,112.51 v1(79.6,112.64) 79.43,112.46 XDP1.37 ; v1(26.41,60.9) 26.36,60.9 25.03,59.57 SR216.2 ; SC20.2 34.35,92.55 v1(34.32,92.51) ; PU93002.9 159.13,121.53 PU93002.6 ; PU8402.15 PU8402.11 ; SR7946.1 43.6,86.45 43.63,86.45 44.06,86.02 v1(44.06,85.91) ; HR42.2 HR41.2 79.97,113.91 v1(79.73,113.91) 79.67,113.96 XDP1.31 ; PJP89002.2 v1(139.03,130.37)
  BOTTOM w0.279: XDP3.37 12.65,50.64 v1(12.72,50.71) 13.08,50.71 14.15,49.64 XDP3.31 ; XDP1.50 71.07,109.46 70.74,109.79 v1(70.74,110.38) ; XDP3.1 21.65,50.58 21.35,50.88 v1(21.34,50.89) ; PU90002.6 102.9,150.04 v1(103.02,150.15) ; XDP3.25 15.65,49.37 17.12,50.84 17.44,50.84 v1(17.57,50.98) 17.68,50.87 17.68,50.08 17.15,49.55 XDP3.19 ; v1(9.98,52.26) 9.65,52.58 XDP3.50 ; v1(70.43,118.05) 70.85,118.46 XDP1.14 ; v1(79.57,119.96) XDP1.7 ; XDP3.14 18.65,55.3 v1(18.64,55.3) ; XDP3.38 12.65,55.39 v1(12.93,55.67) ; v1(70.43,117.41) 70.88,116.96 XDP1.20 ; v1(10.39,68.95) 10.52,69.08 U7201.16 11.84,69.08 U7201.35 ; XDP3.59 7.15,50.75 8.05,51.66 v1(8.07,51.66) ; XDP3.20 17.15,55.22 17.47,55.54 v1(17.47,55.67) 17.45,55.69 16.79,55.69 16.33,55.23 15.8,55.23 15.65,55.09 XDP3.26 ; v1(70.23,121.42) 70.27,121.46 XDP1.2 ; XDP3.49 9.65,50.04 v1(10.36,50.75) ; PU90001.6 118.49,149.26 v1(118.8,149.57) ; XDP1.8 71.03,119.96 70.66,119.6 v1(70.66,119.36) ; XDP3.13 18.65,49.63 18.72,49.7 18.72,50.54 v1(18.74,50.56) 18.92,50.56 20.15,49.33 XDP3.7 ; U7201.23 14.84,69.08 U7201.34 ; XDP3.8 20.15,55.11 v1(20.34,55.3) ; v1(13.71,52.11) 14.15,52.55 XDP3.32 ; XDP1.32 70.84,113.96 ; 70.84,113.96 70.76,114.04 70.76,114.75 70.2,115.31 v1(70.2,116.19) 70.94,115.46 XDP1.26 ; 70.84,113.96 70.59,113.71 70.59,112.74 70.86,112.46 XDP1.38 ; XDP3.2 v1(21.65,55.4)
  BOTTOM w0.295: v1(58.19,151.02) 58.04,150.87 v1(58.04,147.28) ; v1(71.09,151.86) D3601.3 D3601.8 v1(71.09,149.88)
  BOTTOM w0.305: HR36.2 79.73,119.8 v1(79.57,119.96) ; D4C33.2 D4R20.2 121.21,46.47 v1(121.64,46.47) ; v1(120.86,50.25) 120.93,50.19 120.93,49.78 D4C20.2 ; v1(52.93,86.48) 53.07,86.62 SC146.2 ; HCB4.2 10.52,44.73 10.05,44.25 7.6,44.25 7.14,44.72 v1(6.98,44.72)
  BOTTOM w0.356: O2Q4.1 39.42,111.46 39.67,111.71 39.67,111.93 39.43,112.17 v1(39.43,112.32) ; O2Q4.4 36.54,110.16 36.12,109.74 v1(36.12,109.72) ; O2Q5.4 45.59,136.77 45.72,136.9 v1(45.72,137.53) ; O2Q5.1 44,134.95 v1(44.06,134.89) ; v1(87.73,155.64) 87.73,156.16 PR89040.1 ; v1(68.15,97.25) 68.49,96.9 PQ22.1
  BOTTOM w0.381: SR7938.2 44.03,91.18 v1(44.13,91.07) ; PC110.2 PC941669.2 101.88,37.84 v1(101.93,37.79) ; PC115.2 v1(34.8,26.79) ; SC72.2 33.13,87.68 33.2,87.68 v1(33.44,87.44) ; PC6307.2 31.34,140.34 31.34,140.96 v1(31.57,141.19) ; PC7801.2 34.8,24.01 v1(34.75,23.95) ; v1(52.61,79.63) 52.63,79.63 52.64,79.62 52.65,79.62 52.68,79.59 53.15,79.59 SR86.2 ; PC128.2 139.99,32.81 v1(140.32,33.14) ; SCB124.1 44.82,91.84 44.23,92.42 v1(44.19,92.42) ; v1(135.45,122.54) 135.45,121.71 134.52,120.78 HC30.2 ; SR7950.2 57.81,84.57 57.68,84.7 57.68,85.47 v1(57.92,85.71)
  BOTTOM w0.406: v1(55.34,87.15) 55.48,87.01 SR85.2 ; D4C34.2 114.4,59.04 113.89,58.54 v1(113.59,58.54) ; v1(25.73,112.77) 25.99,112.51 O2CB21.2 ; v1(61.24,75.96) 61.01,76.19 SR7831.2 ; v1(44.37,42.03) 44.33,41.99 PC8499.2 ; AC53.2 23.42,22.01 v1(23.42,22.06) ; v1(57.63,80.86) 57.36,80.6 56.65,80.6 56.2,80.14 SR298.2 ; PR93162.1 PR93163.1 32.15,140.6 v1(31.57,141.19) ; SR7948.2 57.02,80.04 56.78,79.8 v1(56.69,79.8) ; v1(54.23,79.87) 54.18,79.92 SR88.2 ; v1(53.58,83.01) 53.51,82.94 53.22,82.94 SR84.2 ; PC941605.2 46.43,42.35 v1(46.56,42.48) ; PC8498.2 v1(45.6,44.29) ; C941635.2 PC941582.2 64.79,45.89 v1(65,46.09)
  BOTTOM w0.432: APR122.2 7.66,114 8.09,114 v1(8.12,113.96) ; D4C5.2 132.6,60.23 v1(133.02,59.81) ; v1(36.07,58.64) 36.75,59.32 38.54,59.32 R3107.2 ; v1(91.13,76.16) 91.69,76.72 C8310.2 ; SR288.2 33.37,81.98 v1(33.69,81.66) 33.69,81.61 33.42,81.35 33.36,81.35 SC28.2 ; v1(33.62,99.24) 33.82,99.24 34.12,99.55 R2343.2 ; v1(10.59,111.43) 11.12,111.43 O2CB17.2 ; SR7829.2 55.21,69.96 SR7817.2 55.49,70.88 55.89,71.28 v1(56.07,71.28) ; C8303.2 4.99,72.39 v1(5.61,71.77) ; SR315.2 54.91,106.47 v1(55.24,106.8) ; SR7954.2 56.86,86.98 v1(56.56,86.98) ; v1(90.51,48.18) 90.42,48.27 D4R22.2 D4R21.2 ; PR60.1 104.29,26.46 v1(104.12,26.46) ; R3106.2 60.63,20.01 61.09,19.55 v1(61.47,19.55) ; v1(6.98,46.34) 7.17,46.34 SR151.2 ; v1(4.65,95.7) 5,95.34 5.26,95.34 SCB75.2 ; SR290.2 SC27.2 38.92,79.94 v1(38.89,79.99) ; CB4132.1 130.91,61.8 v1(131.54,62.43) ; v1(31.73,93.86) 31.68,93.91 SR219.2 ; M1R15.1 38.53,92.65 v1(38.5,92.68) ; PC941609.2 PC941604.2 37.78,40.14 v1(37.92,40) ; D4C25.2 118.21,47.59 v1(118.08,47.46) ; v1(103.75,25.94) 103.17,25.37 PC67.2 ; v1(54.33,122.06) 54.14,121.87 UBC1.2 ; C85.2 26.84,111.66 v1(26.9,111.6) ; R7213.1 18.59,66.05 v1(18.59,66.13) ; v1(22.38,69.94) 22.06,69.63 21.79,69.63 21.32,70.09 O2R10.1 ; v1(102.18,32.88) PC75.2 ; SR57.2 60.03,71.35 59.71,71.03 v1(59.71,70.55) ; SR778.2 5.42,55.86 4.88,56.4 v1(4.88,56.63) ; C8301.2 v1(3.93,46.02) ; D4C22.2 117.27,48.21 v1(116.82,47.77) 116.33,48.26 D4C24.1 ; M1C44.1 v1(128.05,39.91) ; PR7701.1 140.31,30.9 140.71,31.31 v1(140.71,31.61) ; PR76.2 v1(101.56,30.98) ; v1(111.68,117.46) HC31.2 ; R93117.1 38.97,113.34 39.43,112.88 v1(39.43,112.32) ; HR383.2 85.29,125.72 v1(85.4,125.83) ; v1(106.03,32.64) PR63.1 ; PC73.2 v1(104.99,33.4) ; PC89011.2 v1(84.52,157.8) ; v1(71.11,46.79) PC941579.2 PC941580.2
  BOTTOM w0.457: D4R12.2 113.1,66.07 v1(113.1,66.11) ; v1(79.03,124.21) 79.75,123.48 HR346.1 ; PC941502.2 v1(33.37,144.41) ; v1(29.03,100.23) 29.02,100.23 28.93,100.32 SCB70.1 ; PR89046.2 98.84,164.45 v1(99.19,164.45) ; v1(32.1,83.1) 32.13,83.07 C15.2 ; SR212.2 32.61,76.96 v1(32.03,76.39) ; v1(28.54,91.61) 28.52,91.61 28.32,91.81 O2CB20.2 ; C4005.2 15.34,134.76 15.04,134.46 v1(15.04,134.25) ; v1(59.64,84.78) 59.5,84.64 SR7815.2 ; v1(18.98,142.86) 19.48,142.37 R4002.2 ; M1C88.2 73.38,151.87 v1(73.38,152.44) ; 112.53,106.53 HR64.1 ; HR64.1 113.09,107.12 ; HR64.1 112.53,107.72 112.56,107.75 v1(112.57,107.75) ; v1(26.77,135.6) 26.77,136.14 Y4000.2 ; O2R14.2 v1(13.62,122.44) ; v1(27.72,102.86) 27.71,102.86 ; 27.71,102.86 28.1,102.47 SCB68.2 ; 27.71,102.86 27.61,102.96 SCB119.1 ; v1(8.96,66.22) 8.75,66 R99511.1 ; SR75.2 40.02,107.97 v1(39.01,107.97) ; v1(40.63,100.12) 40.49,100.27 C200.2 39.99,100.46 39.58,100.87 SR7920.2 ; v1(43.64,133.09) 43.67,133.05 AC209.2 ; v1(135.9,33.45) 135.87,33.42 PR93024.2 ; v1(5.66,116.91) 5.66,116.67 RO2.2 ; v1(33.39,86.5) 33.22,86.5 32.76,86.05 C18.2 ; PC941483.2 134.59,36.35 v1(134.59,37.13) ; C82.2 20.75,112.84 v1(20.75,112.38) ; C83.2 75.67,140.45 v1(76.59,141.37) ; v1(30.57,104.2) 30.24,104.52 PR761.1 ; SC23.2 O2CB15.2 22.52,90.25 v1(22.96,90.69) ; v1(61.24,75.96) 61.26,75.94 SR7830.2 ; v1(38.4,103.42) 38.4,103.6 38.09,103.91 SR7914.2 ; C17.2 34.05,84.57 v1(34.05,84.29) 33.74,83.98 C16.2 ; C7204.2 8.74,68.49 8.23,69 v1(8.21,69) ; PC7606.2 69.14,53.23 v1(69.16,53.2) ; M1R10.2 46.19,99.64 45.71,99.16 SR7925.2 45.6,98.58 v1(45.44,98.41) ; v1(32.56,142.23) 33.13,142.23 PR93164.1 PR93165.1 ; SCB121.1 31.4,85.41 v1(30.81,86) ; PC89015.2 85.97,160.35 v1(85.88,160.25) ; LC6.2 v1(14.32,147.91) ; v1(38.42,90.65) 38.72,90.35 SR7883.1 ; v1(4.66,103.63) ECR131.2 ; PC89022.1 v1(85.83,162.97) ; M1C43.1 121.37,36.84 v1(121.36,36.83) ; v1(22.41,75.45) 22.29,75.33 OR154.2 ; PC760.2 33.63,100.69 v1(33.4,100.46) ; v1(116.1,63.77) 115.35,63.77 D4C23.1 D4C11.2 ; SC52.1 26.95,94.96 27,94.91 v1(27.05,94.91) 27.05,94.96 27.09,95 O2CB10.2 ; SR115.2 49.93,79.24 49.54,79.63 v1(49.54,79.86) 49.54,80.1 49.8,80.36 49.8,80.42 SR297.2 ; 90.08,171.48 90.08,168.95 PC89009.2 ; O2CB5.2 18.9,112.31 v1(19.45,112.31) 19.45,111.97 C81.2 ; PR89070.2 92.02,169.53 v1(92.53,170.04) 92.96,169.61 PC89004.2 ; ECR129.2 ECR130.2 5.33,102.71 5.1,102.94 v1(4.67,102.94) ; v3(160.88,71.59) 160.77,71.48 FCB2.2 ; PR93060.2 45.07,140.88 v1(45.49,140.88) ; SCB69.1 v1(27.14,104.84) 27.16,104.87 O2CB8.2 ; v1(16.03,137.94) 15.66,137.57 C4004.2 ; O2CB3.2 9.48,91.1 v1(9.46,91.09) ; SC24.2 50.76,104.78 v1(50.9,104.92) ; v1(16.95,90.06) O2CB6.2 ; SR7879.1 38.3,86.71 38.33,86.68 SC73.2 37.87,86.27 v1(37.71,86.12) ; v1(101.25,28.09) 101.46,27.89 PR62.2 PC62.2 ; v1(30.62,145) PR93062.2 ; v1(22.12,114.59) 21.94,114.42 OR34.1 ; PR89049.2 v1(90.14,155.93) ; v1(83.03,105.65) 83.03,105.18 HCB5.1 ; v1(41.81,144.88) 41.98,145.06 PC6306.2 ; v1(33.69,81.66) 33.75,81.66 34.15,82.06 SR7854.2 ; C4023.1 v1(23.85,139.46) ; v1(66.91,61.28) 66.91,60.78 PR7602.2 ; D4C16.2 132.17,47.55 v1(132,47.72) ; v1(87.48,164.1) 87.46,164.11 PR89019.2 ; v1(18.46,145.32) 18.57,145.32 C4024.2 ; v1(38.51,94.41) 38.89,94.02 SR229.2 ; v1(22.73,134.95) 22.58,135.1 R4010.2 ; OR152.1 36.12,109.25 v1(36.12,109.72) 35.75,110.08 AC6.2 ; R113.2 20.1,23.49 ; v1(86.84,169.43) 86.84,169.09 PC89007.2 ; v1(8.16,67.81) 7.73,67.81 C7208.1 ; SCB75.2 O2CB4.2 ; PC761.2 36.14,104.74 36.28,104.6 36.97,104.6 v1(36.98,104.59) 36.98,104.18 36.63,103.83 C86.2 ; O2CB11.2 25.69,97.07 v1(25.57,96.95) ; SC12.2 48.11,109.47 v1(48.31,109.67) 48.56,109.67 49.04,109.18 SR93.2 ; v1(4.8,105.5) 4.84,105.46 ECR132.2 ; PC6301.1 35.11,147.94 v1(34.06,147.94) ; v1(34.44,93.67) SC19.2 ; PC124.2 v1(138.03,33.09) ; D4C19.2 93.5,65.56 v1(93.5,64.94) ; v1(136.79,33.45) PC120.2 ; C94.2 v1(112.63,41.14) ; PC6302.2 37.62,140.39 PC6308.2 36.8,139.74 v1(36.54,139.47) ; O2CB1.2 27.36,99.07 v1(28.59,99.07) ; v1(95.25,170.07) PC89037.2 PR89036.2 ; v1(88.27,124.75) 88.27,125.37 87.82,125.83 CB4135.1 ; C7203.2 v1(8.21,69.64) ; v1(4.65,98.34) 4.88,98.11 AC47.2 O2CB16.2 ; v1(14.01,64.23) R99513.1 ; O2CB2.2 12.39,90.73 12.85,90.28 v1(13.08,90.28) ; v1(133.64,31.26) 133.64,30.59 PC941488.2 ; PC6304.2 35.86,139.51 35.9,139.47 v1(35.9,139.46) ; R93105.1 v1(114.76,40.68) ; v1(69.03,99.3) 69.06,99.33 69.06,100.28 PR113.2 ; C4022.1 v1(23.99,135.97)
  BOTTOM w0.508: v1(62.71,80.48) 62.24,80.48 HC20.1 62.04,79.2 ; v1(66.33,57.6) 66.33,58.07 66.14,58.26 PU7601.8 ; v1(165.12,40.25) 164.87,39.99 Q9308.2 ; v1(53.31,58.44) 52.03,59.72 APR135.1 ; D521.1 v1(108.67,38.87) ; Q9436.2 v1(29.94,30.89) ; PC6305.2 40.97,141.98 v1(41.04,142.05) ; D5502.1 1.67,23.03 v1(1.45,22.8) ; v1(24.92,25.09) 24.62,25.38 AC52.2 ; UU64.2 76.4,149.67 v1(76.05,149.32) ; SR7991.2 51.84,100.27 v1(52.02,100.09) ; v1(114.51,38.76) 114.8,39.04 Q93035.2 ; PC7605.2 60.73,54.17 61.24,54.68 v1(61.72,54.68) ; v1(34.75,23.95) 34.43,23.95 33.98,24.41 PU7.2 ; Q9540.2 v1(126.29,32.35) ; Q9437.2 33.96,26.85 v1(34.6,27.49) ; v1(116.36,39.46) 116.57,39.25 R93108.2 ; v1(98.19,24.86) 98.64,24.86 98.75,24.97 99.15,25.36 UU65.2 ; v1(126.41,29.78) 125.7,29.07 Q9542.2 ; PQ93031.2 32.28,112.06 v1(32.78,112.56) ; v1(2.87,24.45) 2.91,24.41 D5503.1 ; v1(45.72,137.53) 45.41,137.84 AC208.2 ; v1(57.86,45.33) 58.55,45.33 59.42,46.21 Q93.2 ; SR215.2 26.31,42.79 v1(26.29,42.81) ; v1(26.52,46.75) 26.86,47.09 SR214.2 ; D5501.1 4.89,23.75 5.13,23.51 v1(5.43,23.51) ; Q8.2 121.04,20.22 121.98,21.16 v1(122.26,21.16) ; v1(41.96,142.95) PU93003.4 ; v1(120.5,21.36) 120.14,21.36 119.88,21.62 119.88,22.89 120.29,23.31 Q9541.2 ; PQ25.2 137.22,39.63 v1(137.2,39.65) ; PC108.2 66.46,103.63 v1(66.15,103.94) ; D4C18.2 94.28,60.9 D4C17.2 94.28,59.76 v1(94.4,59.64) ; v1(165.43,42.82) 164.9,43.35 Q9309.2 ; Q940.2 54.51,47.46 v1(54.74,47.23) ; v1(34.03,56.81) 34.03,56.86 33.84,57.05 APR134.1 ; v1(125.1,41.4) 125.12,41.39 Q9543.2 ; AC5.2 23.53,25.49 24.57,24.45 v1(24.92,24.45) ; v1(122.81,31.32) 122.83,31.31 Q93038.2 ; UB1.4 v1(51.38,116.81) ; PU76.2 32.26,101.56 31.81,101.11 v1(30.48,101.11) ; SR7833.2 SR7832.2 48.07,79.47 v1(48.6,80) ; PC109.2 v1(102.59,41.24) ; v1(101.07,11.83) 100.81,11.57 M1C99.1 ; v1(28.04,36.77) 27.58,36.31 Q941.2 ; Q93037.2 121.78,27.16 v1(121.78,27.16) ; SR117.2 v1(59.71,70.55) ; HC12.1 58.24,106.22 v1(58.65,105.81) ; v1(9.22,128.69) 9.26,128.69 9.77,128.18 PQ9823.2 ; R3110.2 52.49,102.29 52.2,101.99 v1(52.02,101.82) ; MQ27.2 82.76,144.58 81.99,143.8 v1(81.99,143.57) ; C8304.2 3.95,46 v1(3.93,46.02) ; PC97035.2 v3(156.15,115.74) ; v1(114.7,47.31) 115.19,47.79 D4C21.2 ; C8302.2 4.81,129.64 v1(4.9,129.73) ; v1(8.89,56.37) 9.36,56.83 9.36,57.39 M1C67.2 ; v1(123.8,33.9) 123.68,33.78 Q9537.2 ; PQ24.2 v1(140.78,39.64) ; PQ93030.2 27.6,109.4 v1(26.69,108.5) ; v1(62.71,82.26) 62.7,82.26 HC19.1 ; v1(93.13,11.74) 93.66,11.2 PC941619.2 ; SR218.2 27.87,53.29 28.14,53.56 v1(28.14,53.94) ; v1(99.84,161.97) 99.79,161.92 99.66,161.92 99.66,161.91 PC89029.2 ; v1(87.04,155.76) 87.1,155.82 PC89036.2 ; v1(18.01,147.67) 17.58,147.67 17.07,147.16 D3105.2 ; v1(28.85,147.13) 28.96,147.02 PQ6301.2 ; v1(29.79,138.2) Y4000.4 ; v1(92.84,156.43) 92.29,156.43 PR89065.1 ; v1(100.94,10.91) 100.66,10.63 PC941614.2 ; v1(130.83,40.17) 131.16,40.17 131.38,39.96 Q9544.2 ; v1(88.33,155.87) 88.6,155.87 89.13,156.4 PC89005.2 ; v1(29.11,144.19) 29.16,144.24 PQ93010.2 ; v1(21.62,25.96) 22.09,26.43 AC82.2 ; v1(12.46,58.91) 12.4,58.86 M1C66.2 ; PC107.2 69.74,98.63 v1(69.95,98.41) ; PC89028.2 v1(98.14,165.85) ; v1(58.98,108.3) 58.91,108.23 HC11.1 ; v1(104.99,29.66) 104.52,30.13 PC54.2 ; v1(32.23,37.33) 32.2,37.3 Q942.2 ; v1(64.31,148.71) 64.58,148.71 65.09,148.2 UU19.2 ; v1(38.8,138.67) 38.96,138.67 39.57,139.28 PC6303.2 38.47,139.54 PC6302.2 ; v1(22.04,17.03) 22.43,17.03 22.7,17.31 AC88.2 ; v1(91.16,155.93) PR89041.2
  BOTTOM w0.635: 5.72,13.3 SW10.6 ; SW10.6 4.6,12.18 ; SW10.6 3.48,13.3 ; 165.92,169.12 J1.3 ; J1.3 166.8,170.3 ; J1.3 165.05,170.3 ; 159.65,170.3 J1.1 ; J1.1 158.77,169.12 ; J1.1 157.9,170.3 ; 1.4,12.18 SW10.5 2.52,13.3 ; 17.89,23.86 U6.51 17.89,23.23
  vias: v1(0.79,170.55) v1(0.79,168.34) v1(0.79,166.36) v1(0.79,164.45) v1(0.77,161.87) v1(0.79,160.24) v1(0.77,156.79) v1(0.77,154.25) v1(0.77,151.71) v1(0.77,149.17) v1(0.77,146.63) v1(0.77,144.09) v1(0.77,141.55) v1(0.77,136.47) v1(0.77,134.03) v1(0.77,133.39) v1(0.77,130.98) v1(0.77,128.97) v1(0.77,127.59) v1(0.77,125.78) v1(0.77,123.97) v1(0.77,122.97) v1(0.79,121.47) v1(0.77,120.11) v1(0.8,118.11) v1(0.77,115.03) v1(0.77,112.49) v1(0.77,109.95) v1(0.77,107.41) v1(0.77,104.87) v1(0.77,102.33) v1(0.77,99.79) v1(0.77,97.25) v1(0.77,94.71) v1(0.77,92.17) v1(0.77,89.63) v1(0.77,87.09) v1(0.77,84.55) v1(0.77,82.01) v1(0.77,79.47) v1(0.77,76.93) v1(0.77,74.39) v1(0.77,71.85) v1(0.77,69.31) v1(0.77,66.77) v1(0.77,64.23) v1(0.77,61.69) v1(0.77,59.15) v1(0.77,56.61) v1(0.77,54.07) v1(0.77,51.53) v1(0.77,48.99) v1(0.77,46.45) v1(0.77,43.91) v1(0.77,41.37) v1(0.77,38.83) v1(0.77,36.29) v1(0.77,33.75) v1(0.77,31.21) v1(0.8,30.27) v1(0.77,28.67) v1(0.77,26.12) v1(0.77,23.58) v1(0.77,21.04) v1(0.77,18.84) v1(0.77,16.31) v1(1.18,11.07) v1(1.7,149.44) v1(1.75,150.46) v1(1.75,148.53) v1(2.21,171.47) v1(3.2,170.45) v1(3.72,11.07) v1(4.24,171.49) v1(5.66,170.4) v1(6.26,11.07) v1(6.55,171.52) v1(7.03,19.6) v1(8.1,170.4) v1(8.46,14.14) v1(8.79,124.17) v1(9.04,124.98) v1(9.41,106.5) v1(9.5,171.49) v1(9.83,124.54) v1(10.4,12.56) v1(10.49,170.37) v1(11.53,171.52) v1(12.24,13.3) v1(12.72,170.37) v1(12.88,13.3) v1(12.94,12.56) v1(13.16,63.54) v1(13.16,62.52) v1(13.54,124.55) v1(13.84,171.52) v1(14.43,124.45) v1(14.69,143.86) v1(15.42,170.37) v1(15.44,132.09) v1(15.48,12.56) v1(15.81,72.93) v1(16.24,144.99) v1(16.17,132.09) v1(16.28,171.47) v1(16.5,143.08) v1(16.86,169.69) v1(17.12,134.76) v1(17.91,133.49) v1(18.03,63.55) v1(18.03,62.87) v1(18.02,12.56) v1(19.97,8.46) v1(20.19,6.56) v1(20.37,69.26) v1(20.72,24.81) v1(22.22,133.12) v1(22.34,6.56) v1(22.79,105.77) v1(23.16,116.75) v1(24.33,23.36) v1(24.79,23.82) v1(24.97,125.19) v1(25.73,115.08) v1(25.73,114.44) v1(25.73,113.4) v1(25.65,24.53) v1(25.91,61.69) v1(25.86,51.73) v1(25.88,19.83) v1(26.54,54.09) v1(26.52,51.73) v1(26.57,69.56) v1(26.67,56.43) v1(26.69,23.05) v1(26.82,36.74) v1(27.2,19.83) v1(27.41,133.67) v1(28.7,19.4) v1(28.7,18.58) v1(29.5,123.04) v1(29.91,147.61) v1(29.87,125.14) v1(30.25,119.33) v1(30.28,47.4) v1(30.28,46.76) v1(30.4,19.17) v1(31.03,119.34) v1(31.01,19.75) v1(31.72,52.64) v1(32.35,120.64) v1(34.39,19.8) v1(34.39,19.17) v1(35.33,171.29) v1(35.33,169.13) v1(35.33,161.53) v1(35.33,159.86) v1(35.36,162.96) v1(36.69,171.54) v1(36.65,20.23) v1(37.18,102.17) v1(37.29,20.23) v1(37.92,55.57) v1(37.92,20.23) v1(38.07,57.88) v1(38.55,168.11) v1(38.52,167.38) v1(38.56,20.23) v1(39.23,171.54) v1(39.5,160.87) v1(40.31,105.36) v1(40.26,57.01) v1(40.56,120.21) v1(40.97,18.25) v1(41.3,102.79) v1(41.35,40.48) v1(41.55,59.15) v1(41.6,18.25) v1(41.77,171.54) v1(43.88,147.2) v1(43.92,55.41) v1(44.12,61.51) v1(44.19,88.64) v1(44.31,171.54) v1(44.73,95.28) v1(44.8,120.23) v1(44.98,146.21) v1(45.34,50.33) v1(45.42,46.7) v1(46.1,147.44) v1(46.48,15.94) v1(46.85,171.54) v1(46.91,17.11) v1(47.5,9.87) v1(47.47,8.93) v1(47.57,95.16) v1(47.75,50.77) v1(47.85,18.79) v1(48.13,9.87) v1(48.11,8.93) v1(49.18,55.38) v1(49.39,171.54) v1(49.39,140.05) v1(49.53,16.32) v1(49.97,0.77) v1(50.24,99.86) v1(50.18,18.89) v1(51.38,119.52) v1(51.41,118.86) v1(51.45,98.36) v1(51.62,149.07) v1(51.93,171.54) v1(52.27,144.39) v1(52.51,0.77) v1(52.98,149.21) v1(54.47,171.54) v1(54.94,89.91) v1(55.04,151.93) v1(55.05,0.77) v1(55.52,99.47) v1(55.74,102.64) v1(55.88,93.67) v1(56.01,119.07) v1(56.29,132.08) v1(56.46,101.31) v1(56.87,56.99) v1(56.87,21.38) v1(57.01,171.54) v1(56.96,97.64) v1(57.23,92.41) v1(57.3,95.19) v1(57.61,101.21) v1(57.95,82.27) v1(58.14,18.05) v1(58.24,64.81) v1(58.55,110.63) v1(58.56,96.83) v1(59.13,130.65) v1(59.12,95.93) v1(59.26,151.83) v1(59.33,62.18) v1(59.38,112.3) v1(59.55,171.54) v1(59.56,140.35) v1(59.79,145.1) v1(60.02,146.74) v1(59.99,139.87) v1(59.99,81.45) v1(60.07,151.04) v1(60.06,92.5) v1(60.15,64.68) v1(60.17,110.94) v1(60.27,124.55) v1(60.53,129.4) v1(60.58,121.33) v1(61.14,168.04) v1(61.08,143.18) v1(61.24,62.4) v1(61.39,61.05) v1(61.39,59.2) v1(61.5,90.29) v1(61.47,57.27) v1(61.7,140.55) v1(61.77,168.04) v1(61.82,135.26) v1(61.87,106.83) v1(62.09,171.54) v1(62.1,146.8) v1(62.1,103.24) v1(62.14,90.29) v1(62.18,144.52) v1(62.53,105.93) v1(62.71,104.23) v1(62.67,0.77) v1(62.94,51.3) v1(62.89,25.42) v1(63.23,93.79) v1(63.27,140.58) v1(63.4,143.37) v1(63.37,106.92) v1(63.85,104.41) v1(64.1,151.91) v1(64.09,102.5) v1(64.06,90.36) v1(64.36,88.15) v1(64.54,107.58) v1(64.53,1.06) v1(64.63,171.54) v1(64.62,86.2) v1(64.8,4.59) v1(64.9,24.68) v1(64.96,151.34) v1(65.05,140.53) v1(65.2,85.6) v1(65.47,101.96) v1(65.76,23.64) v1(65.89,140.43) v1(65.9,88.38) v1(65.86,86.93) v1(65.96,90.31) v1(66.11,101.96) v1(66.27,106.47) v1(66.5,19.73) v1(66.68,131.76) v1(67.17,171.54) v1(67.18,100.04) v1(67.39,131.94) v1(67.37,5.08) v1(67.51,32.17) v1(67.51,31.51) v1(67.51,30.85) v1(67.51,30.19) v1(67.57,118.97) v1(67.79,82.77) v1(67.77,49.96) v1(68.14,48.89) v1(68.3,20.36) v1(68.42,119.11) v1(68.68,19.7) v1(68.86,49.62) v1(69.71,171.54) v1(70.2,19.83) v1(70.25,15.05) v1(70.29,5.08) v1(70.86,17.34) v1(71.5,18.66) v1(71.58,20.51) v1(71.8,133.37) v1(72.25,171.54) v1(72.2,135.15) v1(72.59,88.84) v1(72.66,89.5) v1(73.26,5.08) v1(73.43,92.19) v1(73.43,91.56) v1(73.76,101.84) v1(74.04,104.08) v1(74.04,84.67) v1(74.04,82.91) v1(74.06,83.55) v1(74.35,84.12) v1(74.55,97.2) v1(74.53,11.68) v1(74.67,97.83) v1(74.79,171.54) v1(74.79,7.11) v1(75.18,97.2) v1(75.31,97.83) v1(75.49,19.4) v1(75.49,18.28) v1(75.61,152.14) v1(75.61,73.88) v1(75.57,73.2) v1(75.57,72.56) v1(75.57,71.93) v1(75.59,71.29) v1(75.82,97.2) v1(75.75,41.04) v1(76.15,19.4) v1(76.15,18.25) v1(76.22,9.62) v1(76.39,41.04) v1(76.4,27.78) v1(76.56,13.84) v1(77.06,27.78) v1(77.07,7.11) v1(77.33,171.54) v1(77.83,11.81) v1(77.95,66.79) v1(78.66,72.99) v1(78.69,72.35) v1(78.69,71.69) v1(78.74,26.2) v1(78.79,139.89) v1(79.17,148.83) v1(79.55,81.38) v1(79.49,7.11) v1(79.87,171.54) v1(79.87,9.65) v1(80.36,82.41) v1(80.82,148.95) v1(80.88,14.22) v1(81.13,26.23) v1(81.51,153.47) v1(81.51,148.95) v1(81.77,14.73) v1(81.9,7.11) v1(82.17,148.95) v1(82.41,171.54) v1(82.4,84.24) v1(82.79,9.52) v1(83.69,96.54) v1(83.67,83.57) v1(84.02,152.87) v1(84,79.34) v1(84.06,7.11) v1(84.22,96) v1(84.17,84.95) v1(84.5,78.93) v1(84.58,151.86) v1(84.95,171.54) v1(84.91,83.17) v1(84.89,80.66) v1(84.89,65.73) v1(85.67,80.08) v1(86.04,94.58) v1(86.03,85.82) v1(86.26,84.24) v1(86.51,78.93) v1(86.74,92.73) v1(86.84,80.69) v1(87.04,141.87) v1(87.11,7.11) v1(87.96,82.39) v1(87.96,80.43) v1(88.44,90.92) v1(88.49,73.5) v1(88.77,92.8) v1(88.87,171.52) v1(89.13,141.87) v1(89.06,58.62) v1(89.07,57.99) v1(89.07,57.35) v1(89.07,56.66) v1(89.51,24.5) v1(89.48,7.08) v1(90.14,24.5) v1(90.96,142.71) v1(90.99,38.03) v1(91.31,7.08) v1(91.36,171.52) v1(91.54,118.2) v1(91.65,38.03) v1(91.67,15.59) v1(92.21,58.82) v1(92.57,171.54) v1(92.73,7.08) v1(92.89,43.29) v1(93.22,50.74) v1(93.37,7.08) v1(93.57,47.74) v1(93.63,43.29) v1(93.87,71.17) v1(93.95,171.52) v1(94.16,7.08) v1(94.46,63.67) v1(94.94,7.08) v1(95.11,171.54) v1(95.1,30.47) v1(95.6,127.37) v1(95.73,30.47) v1(95.71,7.08) v1(95.83,25.01) v1(96.24,171.52) v1(96.24,14.26) v1(96.44,7.08) v1(96.62,30.5) v1(96.67,9.15) v1(97.23,7.08) v1(97.26,30.5) v1(97.38,20.56) v1(97.53,58.56) v1(97.53,24.88) v1(97.65,171.54) v1(97.92,7.08) v1(98.02,20.56) v1(98.58,7.08) v1(99.29,7.08) v1(100.61,41.19) v1(100.81,134.6) v1(101.34,155.97) v1(101.27,152.97) v1(101.29,148.76) v1(101.37,150.87) v1(101.73,9.08) v1(102.27,135.29) v1(102.64,167.1) v1(102.83,156.38) v1(103.13,51.06) v1(103.22,103.39) v1(103.26,101.23) v1(103.49,171.54) v1(103.58,133.75) v1(103.61,9.08) v1(103.88,98.63) v1(104.11,62.98) v1(104.52,51.5) v1(104.89,109.73) v1(104.9,95.99) v1(105.23,9.08) v1(105.54,133.92) v1(105.83,109.73) v1(105.82,95.97) v1(105.8,95.05) v1(106.03,171.54) v1(106.38,93.24) v1(106.72,109.73) v1(107.26,9.08) v1(107.52,134.31) v1(107.66,106.96) v1(107.7,95.08) v1(107.66,94.1) v1(108.02,166.94) v1(108.57,171.54) v1(108.57,111.54) v1(108.59,109.73) v1(109.27,9.06) v1(109.63,51.01) v1(109.9,162.7) v1(110.32,106.95) v1(110.33,96.89) v1(110.32,95.98) v1(110.32,95.06) v1(110.26,7.97) v1(110.39,100.61) v1(111.05,164.45) v1(111.11,171.54) v1(111.07,135.52) v1(111.3,105.12) v1(111.44,7.07) v1(112.18,102.41) v1(112.56,109.02) v1(112.56,108.39) v1(112.89,26.79) v1(112.97,29.93) v1(113.07,102.38) v1(113.09,99.64) v1(113.23,134.93) v1(113.26,73.27) v1(113.26,72.63) v1(113.65,171.54) v1(113.58,110.29) v1(113.58,109.66) v1(113.9,32.38) v1(113.98,7.07) v1(114.25,144.29) v1(114.25,143.65) v1(114.25,143.02) v1(114.43,20.94) v1(114.47,108.26) v1(114.6,116.88) v1(114.68,115.08) v1(114.66,113.08) v1(114.66,111.17) v1(115.06,20.94) v1(115.21,94.24) v1(115.23,92.69) v1(115.29,72.89) v1(115.72,168.16) v1(115.7,20.94) v1(115.8,155.67) v1(115.95,135.17) v1(116.05,67.38) v1(116.12,62.34) v1(116.19,171.54) v1(116.18,55.34) v1(116.15,53.76) v1(116.25,99.56) v1(116.52,7.07) v1(116.75,91.81) v1(117.12,150.04) v1(117.09,96.89) v1(117.11,95.05) v1(117.16,103.33) v1(117.26,52.79) v1(117.3,51.68) v1(117.42,147.97) v1(117.8,156.43) v1(117.8,155.79) v1(117.75,136.31) v1(117.94,134.34) v1(118.12,171.52) v1(118.38,107.37) v1(118.36,67.22) v1(118.45,92.61) v1(118.78,171.54) v1(119.05,160.21) v1(118.97,100.57) v1(119.01,95.06) v1(119,64.31) v1(119,62.98) v1(119.06,7.07) v1(119.26,135.3) v1(119.36,51.08) v1(119.58,133.42) v1(119.67,117.66) v1(119.67,116.26) v1(119.67,114.99) v1(119.67,113.72) v1(119.67,112.2) v1(119.67,111.56) v1(119.94,155.69) v1(119.91,65.97) v1(120.12,52.39) v1(120.51,134.26) v1(120.82,95.01) v1(121,51.37) v1(121.27,171.54) v1(121.59,60.44) v1(121.64,51.12) v1(121.6,49.48) v1(121.6,7.07) v1(121.72,98.71) v1(121.71,96.89) v1(121.76,93.28) v1(121.89,156.33) v1(122.1,133.57) v1(122.09,106.23) v1(122.38,67.39) v1(122.64,95.03) v1(122.56,55.38) v1(122.64,51.18) v1(122.81,142.31) v1(123.34,62.98) v1(123.36,65.19) v1(123.68,171.54) v1(123.67,53.66) v1(124.14,7.07) v1(124.47,117.53) v1(124.47,116.9) v1(124.47,115.75) v1(124.47,115.12) v1(124.47,113.98) v1(124.47,113.34) v1(124.47,111.94) v1(124.47,111.31) v1(124.49,102.36) v1(124.47,95.07) v1(124.45,93.09) v1(124.63,109.91) v1(124.63,109.15) v1(124.56,63.04) v1(125.74,171.54) v1(125.73,92.42) v1(125.74,51.44) v1(125.84,63.25) v1(125.78,59.11) v1(125.9,73.3) v1(125.9,72) v1(126.04,52.68) v1(126.12,54.74) v1(126.25,95.98) v1(126.18,94.29) v1(127.18,59.32) v1(127.2,7.08) v1(127.3,95.98) v1(127.37,72.65) v1(127.49,55.35) v1(127.61,66.46) v1(127.86,70.93) v1(128.18,94.16) v1(128.28,171.54) v1(128.34,110.84) v1(128.57,63.82) v1(128.63,52.3) v1(128.66,51.01) v1(128.82,107.97) v1(128.82,107.19) v1(128.84,54.03) v1(128.91,55.32) v1(129.13,115.79) v1(129.16,72.37) v1(129.27,46.76) v1(129.51,112.21) v1(129.52,107.95) v1(129.52,107.18) v1(129.56,110.85) v1(129.72,92.25) v1(129.93,46.76) v1(129.99,98.72) v1(130.05,7.08) v1(130.21,107.97) v1(130.21,107.19) v1(130.27,66.21) v1(130.57,115.8) v1(130.55,110.7) v1(130.8,151.63) v1(130.79,52.48) v1(130.92,107.95) v1(130.92,107.18) v1(130.92,106.55) v1(130.92,53.77) v1(131.04,20.92) v1(131.06,51.09) v1(131.56,171.54) v1(131.73,98.71) v1(131.8,100.55) v1(131.83,95.09) v1(131.76,7.07) v1(131.96,115.77) v1(132.41,92.93) v1(132.37,92.16) v1(132.38,71.21) v1(132.76,107.86) v1(132.76,107.15) v1(132.92,112.21) v1(132.92,7.08) v1(133.01,110.8) v1(133.12,152.44) v1(133.38,115.77) v1(133.4,28.69) v1(133.65,7.08) v1(133.75,152.44) v1(133.84,108.48) v1(133.94,107.82) v1(134.1,171.54) v1(134.13,23.49) v1(134.13,22.86) v1(134.3,106.58) v1(134.3,7.07) v1(134.52,13.78) v1(134.58,107.82) v1(134.83,106.93) v1(134.77,23.49) v1(134.77,22.83) v1(135.08,7.08) v1(135.15,13.78) v1(135.29,109.22) v1(135.42,23.52) v1(135.4,22.83) v1(135.45,107.86) v1(135.48,106.99) v1(135.46,98.74) v1(135.81,7.08) v1(136.07,156.64) v1(136.44,102.38) v1(136.64,171.54) v1(136.99,7.24) v1(137.28,109.66) v1(137.67,7.48) v1(138.2,107.81) v1(138.22,95.95) v1(138.18,93.3) v1(138.3,7.76) v1(138.4,155.93) v1(139.18,171.54) v1(139.56,8.23) v1(140.06,92.27) v1(140.18,8.5) v1(140.59,155.93) v1(140.94,107.02) v1(140.94,99.57) v1(141.72,171.54) v1(142.7,9.08) v1(143.2,98.64) v1(143.18,97.73) v1(143.27,28.57) v1(143.27,27.89) v1(143.27,27.23) v1(144.26,171.54) v1(144.85,9.08) v1(146.8,171.54) v1(147,9.06) v1(148.22,86.97) v1(149.41,171.54) v1(149.54,9.06) v1(149.71,54.98) v1(149.68,54.35) v1(150.24,13.22) v1(150.21,12.11) v1(152.08,9.06) v1(152.6,161.53) v1(154.48,161.64) v1(154.62,9.06) v1(154.92,171.54) v1(155.01,162.5) v1(155.78,165.17) v1(155.85,161.79) v1(156.16,59.63) v1(157.21,171.54) v1(157.16,9.06) v1(157.78,121.81) v1(159.09,12.81) v1(159.15,126.23) v1(159.92,121.81) v1(160.51,171.54) v1(160.5,13.07) v1(161.02,41.98) v1(161.02,41.35) v1(161.02,40.71) v1(162.16,50.92) v1(162.8,50.92) v1(162.91,122.77) v1(163.31,50.16) v1(163.43,171.54) v1(163.4,151.96) v1(163.4,151.32) v1(163.47,125.11) v1(164.06,50.15) v1(167.75,50.09) v1(167.88,171.54) v1(168.07,81.7) v1(168.07,81.07) v1(168.07,80.43) v1(168.46,50.14) v1(169.24,169.54) v1(169.24,166.75) v1(169.24,164.84) v1(169.24,162.18) v1(169.24,160.14) v1(169.21,157.72) v1(169.24,155.19) v1(169.24,152.65) v1(169.24,150.11) v1(169.24,147.67) v1(169.22,145.16) v1(169.22,142.62) v1(169.22,140.71) v1(169.22,138.17) v1(169.22,128.01) v1(169.2,127.28) v1(169.2,126.36) v1(169.21,125.44) v1(169.22,124.51) v1(169.22,123.59) v1(169.22,122.76) v1(169.22,120.39) v1(169.22,117.85) v1(169.21,116.91) v1(169.21,114.95) v1(169.21,114.32) v1(169.21,113.68) v1(169.21,113.05) v1(169.21,112.41) v1(169.21,111.78) v1(169.21,111.11) v1(169.21,110.45) v1(169.21,109.79) v1(169.22,105.15) v1(169.22,102.61) v1(169.22,100.07) v1(169.22,95.96) v1(169.22,84.83) v1(169.22,82.29) v1(169.22,79.75) v1(169.22,77.21) v1(169.22,74.67) v1(169.22,72.13) v1(169.22,69.59) v1(169.22,67.05) v1(169.22,64.51) v1(169.22,59.43) v1(169.22,56.89) v1(169.22,54.35) v1(169.22,51.81) v1(169.22,49.27) v1(169.22,46.73) v1(169.22,44.19) v1(169.22,41.65) v1(169.22,39.11) v1(169.22,36.57) v1(169.22,34.03) v1(169.22,31.49) v1(169.22,28.95) v1(169.22,26.41) v1(169.22,23.87) v1(169.21,21.66) v3(6.68,62.91) v3(29.92,114.09) v3(29.97,114.98) v3(30.96,114.98) v3(31.22,114.11) v3(39.27,168.35) v3(39.37,169.28) v3(40.26,168.75) v3(40.89,39.82) v3(41.83,39.84) v3(42.26,162.93) v3(79.5,27.7) v3(80.47,27.7) v3(81.43,27.7) v3(82.37,27.7) v3(84.81,38.83) v3(84.83,37.94) v3(84.83,37.02) v3(84.83,36.08) v3(85.7,38.83) v3(85.72,37.94) v3(85.72,37.05) v3(85.72,36.16) v3(92.1,151.32) v3(92.1,150.43) v3(92.94,151.02) v3(92.94,150.08) v3(102.08,10.79) v3(102.08,9.9) v3(102.97,11.68) v3(102.97,10.79) v3(102.97,9.9) v3(103.86,11.68) v3(103.86,10.79) v3(103.86,9.9) v3(105.38,151.42) v3(105.38,150.54) v3(105.38,149.62) v3(106.58,14.09) v3(107.54,15) v3(107.52,14.06) v3(108.46,15) v3(108.46,14.09) v3(115.04,143.22) v3(115.06,144.11) v3(115.95,144.13) v3(115.95,143.25) v3(119.02,144.41) v3(119.02,143.53) v3(119.02,142.64) v3(123.32,150.64) v3(123.32,149.75) v3(123.29,148.86) v3(124.94,19.93) v3(124.92,19.01) v3(124.92,18.13) v3(125.7,8.74) v3(125.73,7.85) v3(125.83,16.45) v3(125.8,15.53) v3(126.64,8.74) v3(126.69,7.85) v3(127.58,8.74) v3(127.63,7.85) v3(128.52,8.74) v3(128.55,7.85) v3(129.44,8.74) v3(129.44,7.85) v3(130.88,145.91) v3(131.01,143.6) v3(130.99,142.69) v3(131.77,145.91) v3(131.9,143.58) v3(131.88,142.69) v3(132.21,154.14) v3(132.79,143.58) v3(132.78,142.67) v3(133.68,142.69) v3(133.96,7.86) v3(134.62,142.69) v3(134.85,7.86) v3(135.74,7.86) v3(137.23,19.29) v3(137.26,18.4) v3(137.26,17.52) v3(137.26,16.63) v3(137.29,15.74) v3(138.12,19.29) v3(138.15,18.4) v3(138.15,17.52) v3(138.15,16.63) v3(138.17,15.74) v3(140.79,154.19) v3(141.55,153.71) v3(144.71,23.24) v3(144.71,22.35) v3(144.78,28.29) v3(144.79,27.33) v3(144.79,26.11) v3(144.79,25.22) v3(156.23,109.74) v3(156.23,108.8) v3(161.02,106.04) v3(161.02,105.15) v3(161.01,104.23) v3(160.99,103.32) v3(160.99,102.44) v3(161.01,101.54) v3(161.01,100.65) v3(161.02,99.74) v3(161.02,98.85) v3(161.03,97.93) v3(161.77,144.16) v3(166.8,147.26) v3(166.83,144.19) v3(166.8,143.25) v3(167.6,164.64) v3(167.6,163.73) v3(167.6,162.77) v3(167.71,147.26) v3(167.71,144.19) v3(167.71,143.25) v3(168.39,166.93) v3(168.39,166.01) v3(168.39,165.1) v3(168.39,164.18) v3(168.39,163.27) v3(168.39,162.35)
