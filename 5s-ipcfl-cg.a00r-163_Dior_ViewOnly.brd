# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Nets (continued)
+1P2V_DUAL_PHASE: PC118.1 PC123.2 PC125.1 PL14.1 PQ23.9(S1/D2) PR130.2 PR133.1 PU9.16(PHASE)
+1P2V_DUAL_SUR: PC127.1 PR133.2
+1P2V_DUAL_VID: PR7701.2 PR7702.2 PU9.11(VID)
+1P2V_DUAL_VIN: PC121.1 PC122.1 PC93003.1 PC941601.1 PL93004.1 PQ23.2(D1_1) PQ23.3(D1_2) PQ23.4(D1_3) PQ23.10(D1_4) PR126.1
+1P5V: L16.1 PC116.1 PC7607.1 PC7802.1 PR121.1 PU7.5(VOUT)
+1P5V_FB: PC7607.2 PR121.2 PR122.2 PU7.4(NC/ADJ)
+1P05V_SA_DISCH_A: Q9537.3(DRAIN) R651.2
+1P05VSB: CB4135.2 HR58.1 HR422.2 HR423.2 M1C66.1 O2Q2.1 PC802.1 PC803.1 PC804.1 PC812.1 PC813.1 PC814.1 PC815.1 PC816.1 PJP8.1 PL13.2 PR7401.1 R60757.1 R60758.1 R60759.1 R60760.1 R60761.1 SR153.1 SR158.1 SR167.1 SR173.1 SR758.1 SR767.1 SR773.1 XDP1.43(VCC_OBS_AB) XDP1.44(VCC_OBS_CD) XDP3.43(VCC_OBS_AB) XDP3.44(VCC_OBS_CD)
+1P05VSB_EN: PC95.1 PR96.2 PU5.2(EN) R93166.2
+1P05VSB_FB_A: PC104.2 PR107.1 PR109.1 PU5.5(FB)
+1P05VSB_FB_PJP: PJP8.2 PR108.2
+1P05VSB_FB_RC_A: PC104.1 PC105.1 PR107.2 PR108.1 R99522.1
+1P05VSB_PFM: PR1016.2 PR1017.2 PU5.3(PFM#)
+1P05VSB_PG: PR93097.2 PU5.1(PGOOD)
+1P05VSB_PHASE: PC96.2 PC99.1 PL13.1 PR101.1 PU5.10(LX1) PU5.16(LX2) PU5.17(LX3) PU5.18(LX4)
+1P05VSB_SS: PC808.1 PU5.22(SS)
+1P05VSB_SUR: PC102.1 PR101.2
+1P05VSB_TON: PR808.1 PU5.6(TON)
+1P05VSB_VBST: PR97.1 PU5.20(BST)
+1P05VSB_VBST_RC: PC96.1 PR97.2
+1P05VSB_VCC: PC97.1 PR99.2 PU5.21(VCC)
+1P05VSB_VIN: PC92.1 PC93.1 PC7310.1 PR95.1 PR808.2 PU5.7(IN)
+1P8VSB: HR424.1 PC7601.1 PC7602.1 PC7603.1 PR7601.2 PU7601.6(VOUT)
+1P8VSB_EN_A: PC7606.1 PR7607.2 PR93166.2 PU7601.2(EN)
+1P8VSB_PG: PR7609.2 PU7601.1(POK) R93166.1
+1P8VSB_VDD_A: PC7605.1 PR7608.2 PU7601.4(VDD)
+1P8VSB_VREF_A: PC7603.2 PR7601.1 PR7602.1 PU7601.7(FB)
+1P24V_FB: PC762.2 PR760.1 PR761.2 PU76.4(NC/ADJ)
+1P24VSB: HR73.2 PC761.1 PC762.1 PR760.2 PU76.5(VOUT)
+2P5VPP: D4C4.1 D4C15.1 DIMM1.257(VPP1) DIMM1.259(VPP2) DIMM2.257(VPP1) DIMM2.259(VPP2) PC112.1 PC113.1 PC114.1 PR119.1 PU6.6(VOUT) R93121.1
+2P5VPP_DISCH_A: Q93037.3(DRAIN) R93121.2
+2P5VPP_EN_A: PC109.1 PR118.2 PU6.2(EN)
+2P5VPP_VDD_A: PC110.1 PC941669.1 PR117.2 PU6.4(VDD)
+2P5VPP_VREF_A: PC114.2 PR119.2 PR120.1 PU6.7(FB)
+3P3V: AC88.1 AR29.1 AR40.2 C941645.1 CR7.1(ANODE) D4C6.1 D4C7.1 D4C8.1 D4C17.1 D4C18.1 D4C19.1 D4R5.1 D4R6.1 D4R7.1 D4R16.1 D4R17.1 D4R18.1 DIMM1.255(VDDSPD) DIMM2.255(VDDSPD) FR1.1 HR399.1 J69.23 J69.24 J69.25 L120.1 M1Q7.1(GATE) M1Q9.1(GATE) M1R21.1 M1R23.1 M1R24.1 O2CB8.1 O2R12.1 O2R13.2 O2R15.1 OR37.2 OR72.2 OR73.2 OR74.2 OR75.2 OR76.2 OR77.2 OR78.2 OR79.2 OR134.2 OR136.2 OR146.2 OR147.2 OR148.2 OR149.2 OR150.1 P110.P1(3.3V_POWER_1) P110.P2(3.3V_POWER_2) PC941608.1 PR29.1 PR89008.1 PR89105.1 PR93170.1 PU8401.8(VOUT2_1) PU8401.9(VOUT2_2) Q9432.2(G1) Q9432.5(G2) Q9433.2(SOURCE) Q93041.2(SOURCE) R39.1 R40.1 R62.2 R658.1 R2341.1 R2345.1 R2349.1 R2350.1 R2353.1 R2354.1 R4001.1 R4009.1 R4818.1 R6501.1 R7216.1 R7217.1 R70263.2 R70264.2 R70279.1 R70280.1 R70291.2 R70292.2 R70293.2 R70299.1 R70300.1 R93110.1 R99527.1 R99531.1 RO1.1 SR16.1 SR34.1 SR39.1 SR40.1 SR70.1 SR71.1 SR108.1 SR134.1 SR258.1 SR264.1 SR344.1 SR345.1 SR674.1 SR777.1 SR7794.2 SR7834.2 SR7838.2 SR7841.1 SR7847.1 SR7848.1 SR7887.1 SR7895.1 SR7896.1 SR7897.1 SR7902.1 SR7906.1 SR7943.1 SR7953.1 U6.36(CPVDD) U104.4(VCC)
+3P3V_DEBUG: CB4152.1 P12.1 P12.3 Q9433.3(DRAIN)
+3P3V_DISCH_A: Q9542.3(DRAIN) R658.2
+3P3V_DPC: AC207.1 C204.1 J302.20(DP_PWR) M1C100.1 M1F2.2
+3P3V_DPC_SW: M1F2.1 Q93041.3(DRAIN)
+3P3V_HDD: P110.P3(3.3V_POWER_PRECHARGE) R99527.2
+3P3V_L: C4012.1 Q4000.2(SOURCE) R4000.2 R4003.1
+3P3V_LDOOUT: PC54.1 PR51.2 PU4.3(LDO3)
+3P3V_LDOOUT_R: PR51.1 ST1.1
+3P3V_LED_R: CR7.2(CATHODE) R4816.1
+3P3V_MSATA: AC20.1 AC25.1 C1.1 C2.1 C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 J219.2 J219.4 J219.12 J219.14 J219.16 J219.18 J219.72 J219.74 PC941603.1 PU8401.13(VOUT1_1) PU8401.14(VOUT1_2) R934.1 R3138.1 R70290.2 SR416.2 X3R14.1
+3P3V_MSATA_DISCH_A: Q942.3(DRAIN) R934.2
+3P3V_MSATA_EN: PC8498.1 PR93155.1 PU8401.3(EN1)
+3P3V_WLAN: APR136.1 APR137.1 C316.1 J218.2(3.3V_2) J218.4(3.3V_4) J218.72(3.3V_72) J218.74(3.3V_74) M1C49.2 M1C50.2 M1C51.2 M1C52.2 PC81.1 PU10.8(VOUT2_1) PU10.9(VOUT2_2) R932.1 R3136.1 RF3.1 SR7885.1 SR7886.1
+3P3V_WLAN_DISCH_A: Q940.3(DRAIN) R932.2
+3P3VA: AC47.1 AR17.1 HR379.1 HT61.1 HT62.1 HT63.1 HT64.1 HT65.1 O2CB1.1 O2CB2.1 O2CB3.1 O2CB4.1 O2CB5.1 O2CB6.1 O2CB16.1 O2CB17.1 O2CB20.1 P466.3 P466.7 PC69.1 PC70.1 PC71.1 PC111.1 PC115.1 PC760.1 PC7604.1 PC7801.1 PCE7.1 PCE690.1 PJP7.1 PL12.2 PR58.1 PR132.1 PR7001.1 PR7002.1 PR8401.1 PR8402.1 PR8403.1 PR8405.1 PR8406.1 PR93157.1 PR93158.1 PU6.3(VIN) PU7.1(VIN) PU76.1(VIN) PU7601.3(VIN) R182.1 R663.1 R931.1 R933.1 R99515.1 R99535.1 R99536.1 SR251.1 SR252.1 SR253.1 SR254.1 SR255.1 SR256.1 SR817.1 SR7877.1 SR7922.1 SR7998.1 U104.22(V3_DUAL1) U104.32(V3_DUAL2) U104.45(HV3_DUAL) U104.55(V3_DUAL3) U104.60(V3_DUAL4) U104.65(V3_DUAL5) U104.77(V3_DUAL6) U104.104(V3_DUAL7) U104.120(V3_DUAL8)
+3P3VA_BST: PR65.1 PU4.9(BOOT2)
+3P3VA_BST_RC: PC65.1 PR65.2
+3P3VA_CS: PR63.2 PU4.5(CS2)
+3P3VA_EN: PC73.1 PR74.2 PU4.6(EN2)
+3P3VA_FB: PC74.2 PR75.2 PR76.1 PU4.4(FB2)
+3P3VA_FB_RC_A: PC74.1 PC75.1 PJP7.2 PR75.1
+3P3VA_HG: PR67.1 PU4.10(UGATE2)
+3P3VA_HG_R: PC66.1 PQ8.1(G1) PR67.2 PR68.1
+3P3VA_LG: PR71.1 PU4.11(LGATE2)
+3P3VA_LG_R_D: PC68.1 PQ8.8(G2) PR71.2 PR73.1
+3P3VA_PHASE: PC65.2 PC66.2 PL12.1 PQ8.9(S1/D2) PR68.2 PR72.1 PU4.8(PHASE2)
+3P3VA_SN_C: PC72.1 PR72.2
+3P3VEN: ECR154.2 PC8499.1 PU8401.5(EN2)
+3P3VSB: APR128.2 C7202.1 C7206.1 C7207.1 CB4133.2 CB4134.2 CR1.1(ANODE) CR2.1(ANODE) E16.6 E61.2 F3R1.2 F3R2.2 F3R71.1 FR10.1 HR1.1 HR2.1 HR59.1 HR61.1 HR67.1 HR74.1 HT46.1 HT47.1 HT48.1 HT49.1 HT50.1 J303.2 O2CB11.1 O2R25.2 OR22.2 OR29.1 OR109.2 OR111.2 OR112.2 OR119.2 OR120.2 OR122.2 OR123.2 OR124.1 OR125.1 OR126.1 OR127.1 OR128.1 OR129.1 OR130.1 OR132.2 OR133.2 OR135.2 OR137.2 OR141.1 OR142.1 OR153.1 P466.1 PC78.1 PR96.1 PR116.1 PR131.1 PR135.1 PR7609.1 PR93083.2 PR93166.1 PU10.13(VOUT1_1) PU10.14(VOUT1_2) R38.2 R56.1 R60.1 R181.1 R2101.1 R2102.1 R2342.1 R2346.1 R4000.1 R4814.1 R4815.1 R4817.1 R7210.1 R7211.1 R7215.1 R7218.1 R69693.1 R70297.1 R93111.1 R99512.1 R99514.1 R99519.1 R99530.1 R99532.1 SR9.1 SR17.1 SR18.1 SR20.1 SR21.1 SR22.1 SR23.1 SR25.1 SR41.1 SR44.2 SR46.1 SR50.1 SR52.1 SR53.1 SR72.1 SR73.1 SR103.1 SR104.1 SR105.1 SR110.1 SR111.1 SR112.1 SR116.1 SR118.1 SR123.2 SR160.1 SR161.1 SR168.1 SR169.1 SR170.1 SR171.1 SR211.1 SR226.1 SR228.1 SR237.1 SR267.1 SR277.1 SR342.1 SR343.1 SR346.1 SR400.2 SR401.2 SR402.2 SR403.2 SR404.1 SR406.1 SR407.1 SR410.1 SR411.2 SR420.2 SR669.2 SR672.1 SR673.1 SR774.1 SR897.1 SR909.1 SR912.1 SR3701.1 SR7796.1 SR7803.1 SR7842.1 SR7843.1 SR7844.1 SR7849.1 SR7850.2 SR7851.2 SR7852.2 SR7853.1 SR7857.1 SR7862.1 SR7871.1 SR7872.1 SR7873.1 SR7878.1 SR7880.1 SR7882.1 SR7928.1 SR7929.1 SR7930.1 SR7931.1 SR7934.1 SR7935.1 SR7939.1 SR7940.1 SR7941.1 SR7942.1 SR7944.1 SR7945.1 SR7949.1 SR7951.1 SR7955.1 SR7956.1 SR7982.1 SR7993.1 U1.AN21(VCCPGPPG_3P3) U1.AT44(VCCPRIM_3P3_1) U1.AW9(VCCPRIM_3P3_2) U1.AY8(VCCPRIM_3P3_3) U1.BB7(VCCPRIM_3P3_4) U1.V23(VCCPRIM_3P3_5) U104.27(V3_S5) U7201.1(VSB) U9434.8(VCC) U9435.2(VCC) UB1.1(VDD) UB1.8(OE) UBC1.1
+3P3VSB_LAN: C4004.1 C4005.1 C4006.1 C4011.1 C4016.1 C4017.1 LR9.1 LR10.1 PC941617.1 PU8402.8(VOUT2_1) PU8402.9(VOUT2_2) Q4000.3(DRAIN) R4004.1 R4005.1 SR163.1 SR164.1 SR911.1 U114.11(AVDD33_1) U114.23(VDDREG) U114.32(AVDD33_2)
+3P3VSB_LAN_EN: ECR156.2 ECR157.2 PC9416.1 PU8402.5(EN2)
+3P3VSB_LED: CR23.1(ANODE) R4817.2
+ADP_19V: M1R16.1 PC49.1 PC94.1 PC119.1 PC998.1 PC999.1 PC6301.2 PC90100.1 PJP2.1 PL7.2 PL8.2 PL9.2 PL10.2 PL90010.2 PL90011.2 PL90012.2 PL90013.2 PL93004.2 PR1.2 PR95.2 PR6399.1 PR6801.2 PR89005.1 PU93003.8(VCC) R93098.1 R93106.1 R93116.2
+BATT: C49.1 C2715.1 C2726.1 D3.3(CATHODE) R71.1 R80.1 SR257.1 U1.BC49(VCCRTC_1) U1.BD49(VCCRTC_2)
+BATT_SIO: D525.3(CATHODE) O2CB7.1 R93118.2 U104.21(VBAT)
+USB3_FRONT0: C201.1 C8316.1 C941646.1 C941647.1 J133.1(VBUS) J200.1(VBUS) M1C115.1 R99523.2 SC53.1 TUC33.1 TUC34.1 TUC38.1 UU66.1(OUT)
+USB3_P7: D4C28.1 J13.5 M1C80.1 R70259.2 TUC23.1 TUC30.1 TUC36.1 UU19.1(OUT)
+USB3_P8: C3907.1 D4C29.1 J13.1 M1C83.1 R70261.2 TUC24.1 TUC31.1 TUC35.1 UU22.1(OUT)
+USB3_P56: C202.1 J12.1(VBUS_1) J12.10(VBUS_2) M1C89.1 R99517.2 SR698.1 TUC26.1 TUC32.1 TUC37.1 UU64.1(OUT)
+VCORE: C205.1 C206.1 C207.1 HT66.1 HT67.1 HT68.1 HT69.1 HT70.1 HT71.1 HT72.1 HT73.1 HT74.1 HT75.1 PC97001.1 PC97002.1 PC97003.1 PC97004.1 PC97005.1 PC97006.1 PC97007.1 PC97008.1 PC97009.1 PC97010.1 PC97011.1 PC97012.1 PC97013.1 PC97014.1 PC97015.1 PC97016.1 PC97017.1 PC97018.1 PC97019.1 PC97020.1 PC97021.1 PC97022.1 PC97023.1 PC941489.1 PC941490.1 PC941491.1 PC941492.1 PC941493.1 PC941494.1 PC941663.1 PC941664.1 PC941665.1 PCE97027.1 PCE97028.1 PCE97030.1 PCE97031.1 PCE97032.1 PCE97037.1 PJP89001.2 PJP90002.1 PJP90004.1 PJP93005.1 PL90001.2 PL90002.2 PL93006.2 XU1.A25(VCC_1) XU1.A26(VCC_2) XU1.A27(VCC_3) XU1.A28(VCC_4) XU1.A29(VCC_5) XU1.A30(VCC_6) XU1.AJ11(VCC_7) XU1.AJ12(VCC_8) XU1.AJ13(VCC_9) XU1.AJ14(VCC_10) XU1.AJ15(VCC_11) XU1.AJ16(VCC_12) XU1.AJ17(VCC_13) XU1.AJ18(VCC_14) XU1.AJ19(VCC_15) XU1.AJ20(VCC_16) XU1.AJ21(VCC_17) XU1.AJ25(VCC1) XU1.AJ26(VCC2) XU1.AJ27(VCC3) XU1.AJ28(VCC4) XU1.AJ29(VCC5) XU1.AK21(VCC6) XU1.B25(VCC_19) XU1.B27(VCC_20) XU1.B29(VCC_21) XU1.B31(VCC_22) XU1.B32(VCC_23) XU1.B33(VCC_24) XU1.B34(VCC_25) XU1.B35(VCC_26) XU1.B36(VCC_27) XU1.B37(VCC_28) XU1.C25(VCC_29) XU1.C26(VCC_30) XU1.C27(VCC_31) XU1.C28(VCC_32) XU1.C29(VCC_33) XU1.C30(VCC_34) XU1.C32(VCC_35) XU1.C34(VCC_36) XU1.C36(VCC_37) XU1.D25(VCC_38) XU1.D27(VCC_39) XU1.D29(VCC_40) XU1.D31(VCC_41) XU1.D32(VCC_42) XU1.D33(VCC_43) XU1.D34(VCC_44) XU1.D35(VCC_45) XU1.D36(VCC_46) XU1.E24(VCC_47) XU1.E25(VCC_48) XU1.E26(VCC_49) XU1.E27(VCC_50) XU1.E28(VCC_51) XU1.E29(VCC_52) XU1.E30(VCC_53) XU1.E32(VCC_54) XU1.E34(VCC_55) XU1.E36(VCC_56) XU1.F23(VCC_57) XU1.F24(VCC_58) XU1.F25(VCC_59) XU1.F27(VCC_60) XU1.F29(VCC_61) XU1.F31(VCC_62) XU1.F32(VCC_63) XU1.F33(VCC_64) XU1.F34(VCC_65) XU1.F35(VCC7) XU1.F37(VCC8) XU1.G23(VCC_66) XU1.G24(VCC_67) XU1.G25(VCC_68) XU1.G26(VCC_69) XU1.G27(VCC_70) XU1.G28(VCC_71) XU1.G29(VCC_72) XU1.G30(VCC_73) XU1.G32(VCC_74) XU1.G34(VCC9) XU1.G35(VCC10) XU1.H22(VCC_75) XU1.H23(VCC_76) XU1.H25(VCC_77) XU1.H27(VCC_78) XU1.H29(VCC_79) XU1.H31(VCC_80) XU1.H32(VCC_81) XU1.H33(VCC11) XU1.H34(VCC12) XU1.J21(VCC_82) XU1.J22(VCC_83) XU1.J23(VCC_84) XU1.J24(VCC_85) XU1.J25(VCC_86) XU1.J26(VCC_87) XU1.J27(VCC_88) XU1.J28(VCC_89) XU1.J29(VCC_90) XU1.J30(VCC_91) XU1.J31(VCC_92) XU1.J33(VCC14) XU1.J35(VCC16) XU1.K16(VCC_93) XU1.K18(VCC_94) XU1.K20(VCC_95) XU1.K21(VCC_96) XU1.K23(VCC_97) XU1.K25(VCC_98) XU1.K27(VCC_99) XU1.K29(VCC_100) XU1.K31(VCC_101) XU1.K32(VCC13) XU1.K34(VCC17) XU1.L14(VCC_102) XU1.L15(VCC_103) XU1.L16(VCC_104) XU1.L17(VCC_105) XU1.L18(VCC_106) XU1.L19(VCC_107) XU1.L20(VCC_108) XU1.L21(VCC_109) XU1.L22(VCC_110) XU1.L23(VCC_111) XU1.L24(VCC_112) XU1.L25(VCC_113) XU1.L26(VCC_114) XU1.L27(VCC_115) XU1.L28(VCC_116) XU1.L29(VCC_117) XU1.L30(VCC_118) XU1.L31(VCC15) XU1.L33(VCC19) XU1.M13(VCC_119) XU1.M14(VCC_120) XU1.M16(VCC_121) XU1.M18(VCC_122) XU1.M20(VCC_123) XU1.M22(VCC_124) XU1.M24(VCC_125) XU1.M26(VCC_126) XU1.M28(VCC_127) XU1.M30(VCC_128) XU1.M32(VCC18)
+VTT_A_DDR_VTTSNS: PR93029.1 PU9.2(VTTSNS)
+VTT_A_REF: PC941488.1 PU9.4(VTTREF)
+VTT_DDR: D4C1.1 D4C2.1 D4C3.1 D4C12.1 D4C13.1 D4C14.1 DIMM1.258(VTT) DIMM2.258(VTT) PC134.1 PC135.1 PC941485.1 PC941670.1 PR93029.2 PU9.20(VTT)
A20GATE: OR22.1 U104.119(GP064/A20M)
ACPRESENT: SR253.2 U1.BG42(GPD1/ACPRESENT)
ADAPTOR_PSID: D521.3(ANODE2) R93109.2 R93110.2 R99530.2 SR7888.2
ADAPTOR_PSID_B11: SR7888.1 U1.AP29(GPP_B11/I2S_MCLK)
AMP3_1: AR31.1 C258.2 HC7.1 P6.1 R204.1
AMP3_2: AR30.1 C258.1 HC6.1 P6.2 R203.1
APS_PIN4: APR127.1 APR128.1 P466.4
AQ2_1: AQ2.1(GATE) AQ3.3(DRAIN) AR17.2
AQ3_1: AC53.1 AQ3.1(GATE) AR19.2 AR29.2
AQ20_PIN2: AQ20.2(G1) AQ20.3(D2) SR7998.2
AQ20_PIN5: AQ20.5(G2) SR7999.2
BATLOW_N: SR252.2 U1.BF44(GPD0/BATLOW#)
BOARD_ID0: SR7862.2 SR7868.2 U1.BD38(GPP_A17/SD_VDD1_PWR_EN#/ISH_GP7)
BOARD_ID1: SR7870.2 SR7871.2 U1.BF35(GPP_A18/ISH_GP0)
BOARD_ID2: SR7872.2 SR7874.2 U1.BD34(GPP_A19/ISH_GP1)
BOARD_ID3: SR7873.2 SR7875.2 U1.BE34(GPP_A20/ISH_GP2)
BOARD_ID4: SR7948.1 SR7949.2 U1.L47(GPP_K0)
BOARD_ID5: SR7950.1 SR7951.2 U1.L46(GPP_K1)
BT_DISABLE#_R: APD1.1(ANODE) APR137.2 J218.54(RESERVED_W_DISABLE2*) R3109.1
CAP1: C85.1 U104.128(CAP1)
CATERR#: HR30.2 Q9346.1(BASE) XU1.D13(CATERR#)
CATERR_LED_E: CR4.1(ANODE) Q9346.3(COLLECTOR) R4818.2
CBN: AC14.2 U6.35(CBN)
CBP: AC14.1 U6.37(CBP)
CFG_RCOMP_W8S6L200MIL: HR57.1 XU1.M11(CFG_RCOMP)
CHA_DIMM0_EVENT#: D4R2.2 DIMM2.134(EVENT_N/NF)
CHAR_EN: SR117.1 U1.Y47(GPP_K16/GSXCLK)
CHB_DIMM0_EVENT#: D4R14.2 DIMM1.134(EVENT_N/NF)
CK_14M_SIO: SC73.1 SCB68.1 SR24.1 U104.16(PCICLK)
CK_24M_SIO: ECR103.2 R637.1 SR19.1
CK_100M_PCIE1_WLAN: J218.47(REFCLKP0) U1.AH10(CLKOUT_PCIE_P1)
CK_100M_PCIE1_WLAN#: J218.49(REFCLKN0) U1.AH9(CLKOUT_PCIE_N1)
CK_100M_PCIE2_LAN: U1.AE15(CLKOUT_PCIE_P2) U114.15(REFCLK_P)
CK_100M_PCIE2_LAN#: U1.AE14(CLKOUT_PCIE_N2) U114.16(REFCLK_N)
CK_100M_PCIE3_SSD: J219.55 U1.AE7(CLKOUT_PCIE_P3)
CK_100M_PCIE3_SSD#: J219.53 U1.AE6(CLKOUT_PCIE_N3)
CK_PCIE_N5: ST24.1 U1.AB2(CLKOUT_PCIE_N5)
CK_PCIE_P5: ST25.1 U1.AB3(CLKOUT_PCIE_P5)
CL_CLK: APR29.1 U1.AR2(CL_CLK)
CL_CLK_R: APR29.2 J218.42(RESERVED_42)
CL_DATA: APR30.1 U1.AT5(CL_DATA)
CL_DATA_R: APR30.2 J218.40(RESERVED_40)
CL_RST#: APR31.1 U1.AU4(CL_RST#)
CL_RST#_R: APR31.2 J218.38(RESERVED_38)
CL_SENSE: SR104.2 U1.T46(GPP_K20)
CLK_24M_NSSC_CPU: U1.D7(CLKOUT_CPUNSSC_P) XU1.K9(CLK24P)
CLK_24M_NSSC_CPU#: U1.C6(CLKOUT_CPUNSSC_N) XU1.J9(CLK24N)
CLK_100M_BCLK_CPU: U1.B8(CLKOUT_CPUBCLK_P) XU1.W5(BCLKP)
CLK_100M_BCLK_CPU#: U1.C8(CLKOUT_CPUBCLK_N) XU1.W4(BCLKN)
CLK_100M_ITPXDP_CPU: U1.Y4(CLKOUT_ITPXDP_P) XDP1.40(ITPCLK/HOOK4)
CLK_100M_ITPXDP_CPU#: U1.Y3(CLKOUT_ITPXDP_N) XDP1.42(ITPCLK#/HOOK5)
CLK_100M_PCIBCLK_CPU: U1.A6(CLKOUT_CPUPCIBCLK_P) XU1.W1(PCI_BCLKP)
CLK_100M_PCIBCLK_CPU#: U1.B6(CLKOUT_CPUPCIBCLK_N) XU1.W2(PCI_BCLKN)
CLKOUT_LPC1_SIO: ECR103.1 SCB69.2 U104.7(CLOCKI)
CNV_BRI_DT: R3128.1 SR7919.1 SR7920.1 U1.AV4(GPP_J4/CNV_BRI_DT/UART0_RTS#)
CNV_BRI_DT_R: J218.36(UART_RTS) R3128.2
CNV_BRI_RSP: R3125.1 U1.AY2(GPP_J5/CNV_BRI_RSP/UART0_RXD)
CNV_BRI_RSP_R: J218.22(UART_RX) R3125.2 SR7996.2
CNV_DET_S: D524.3(ANODE) MQ26.2(SOURCE) SR7993.2
CNV_RGI_DT: R3126.1 SR7921.1 SR7991.1 U1.BA4(GPP_J6/CNV_RGI_DT/UART0_TXD)
CNV_RGI_DT_R: J218.32(UART_TX) R3126.2
CNV_RGI_RSP: R3127.1 U1.AV3(GPP_J7/CNV_RGI_RSP/UART0_CTS#)
CNV_RGI_RSP_R: J218.34(UART_CTS) R3127.2 SR7997.2
CNV_WR_0_DN: R3115.2 U1.BB3(CNV_WR_D0N)
CNV_WR_0_DP: R3116.2 U1.BB4(CNV_WR_D0P)
CNV_WR_1_DN: R3113.2 U1.BA3(CNV_WR_D1N)
CNV_WR_1_DP: R3114.2 U1.BA2(CNV_WR_D1P)
CNV_WR_CLK_DN: R3117.2 U1.BD4(CNV_WR_CLKN)
CNV_WR_CLK_DP: R3118.2 U1.BE3(CNV_WR_CLKP)
CNV_WR_R_0_DN: J218.15(SDIO_DATA1) R3115.1
CNV_WR_R_0_DP: J218.17(SDIO_DATA2) R3116.1
CNV_WR_R_1_DN: J218.9(SDIO_CLK) R3113.1
CNV_WR_R_1_DP: J218.11(SDIO_CMD) R3114.1
CNV_WR_R_CLK_DN: J218.21(SDIO_WAKE*) R3117.1
CNV_WR_R_CLK_DP: J218.23(SDIO_RESET*) R3118.1
CNV_WT_0_DN: R3121.2 U1.BE6(CNV_WT_D0N)
CNV_WT_0_DP: R3122.2 U1.BD7(CNV_WT_D0P)
CNV_WT_1_DN: R3119.2 U1.BG6(CNV_WT_D1N)
CNV_WT_1_DP: R3120.2 U1.BF6(CNV_WT_D1P)
CNV_WT_CLK_DN: R3123.2 U1.BC5(CNV_WT_CLKN)
CNV_WT_CLK_DP: R3124.2 U1.BB6(CNV_WT_CLKP)
CNV_WT_R_0_DN: J218.65(RESERVED/REFCLKP1) R3121.1
CNV_WT_R_0_DP: J218.67(RESERVED/REFCLKN1) R3122.1
CNV_WT_R_1_DN: J218.59(RESERVED_2ND_PETP1) R3119.1
CNV_WT_R_1_DP: J218.61(RESERVED_2ND_PETN1) R3120.1
CNV_WT_R_CLK_DN: J218.71(RESERVED_2ND_PERN1) R3123.1
CNV_WT_R_CLK_DP: J218.73(RESERVED_2ND_PERP1) R3124.1
CNV_WT_RCOMP: R99516.1 U1.BA1(CNV_WT_RCOMP)
CNVI_DET: J218.19(SDIO_DATA3) R3107.1 SR7966.1
COM_1: PD8.1(ANODE1) PQ93012.1(GATE) PR93061.2 PU93003.1(OUT1)
COM_2: PC6307.1 PR93046.2 PR93055.2 PR93162.2 PR93163.2 PU93003.2(-IN1)
COM_3: PC6305.1 PC6306.1 PR93038.2 PU93003.3(+IN1)
COM_5: PC6302.1 PC6303.1 PC6308.1 PR93039.2 PU93003.5(+IN2)
COM_6: PC6304.1 PR93051.2 PR93052.2 PR93164.2 PR93165.2 PU93003.6(-IN2)
COM_7: PC941502.1 PD8.2(ANODE2) PQ93010.1(GATE) PR93054.2 PU93003.7(OUT2)
CONFIG_0: SR7849.2 U1.M45(GPP_K23/IMGCLKOUT1)
CONFIG_1: SR7802.1 U1.AC48(GPP_H1/SRCCLKREQ7#)
CONFIG_3: APR117.2 SR416.1 U1.AE41(GPP_H2/SRCCLKREQ8#)
CORE_PWM1_BOOT: PR90003.1 PU90001.1(BST)
CORE_PWM1_BOOT_R_C: PC90005.2 PR90003.2
CORE_PWM1_EN: PR90005.2 PU90001.3(EN)
CORE_PWM1_HG_D: PR90001.1 PU90001.8(DRVH)
CORE_PWM1_HG_D_R: PC90006.1 PQ90001.1(HSG) PR90001.2 PR90004.1
CORE_PWM1_LG_D: PR90007.1 PU90001.5(DRVL)
CORE_PWM1_LG_D_R: PC90010.1 PQ90001.8(LSG) PR90007.2 PR90008.1
CORE_PWM1_SW_D: PC90005.1 PC90006.2 PQ90001.2(GR) PR90004.2 PU90001.7(SW)
CORE_PWM1_SW_S: PC90008.1 PJP90001.1 PL90001.1 PQ90001.5(SW1) PQ90001.6(SW2) PQ90001.7(SW3) PR90006.1
CORE_PWM1_VCC: PC90007.1 PR90002.2 PU90001.4(VCC)
CORE_PWM2_BOOT: PR90010.1 PU90002.1(BST)
CORE_PWM2_BOOT_R_C: PC90016.2 PR90010.2
CORE_PWM2_EN: PR90013.2 PU90002.3(EN)
CORE_PWM2_HG_D: PR90011.1 PU90002.8(DRVH)
CORE_PWM2_HG_D_R: PC90017.1 PQ93008.1(HSG) PR90011.2 PR90012.1
CORE_PWM2_LG_D: PR90015.1 PU90002.5(DRVL)
CORE_PWM2_LG_D_R: PC90021.1 PQ93008.8(LSG) PR90015.2 PR90016.1
CORE_PWM2_SW_D: PC90016.1 PC90017.2 PQ93008.2(GR) PR90012.2 PU90002.7(SW)
CORE_PWM2_SW_S: PC90018.1 PJP90003.1 PL90002.1 PQ93008.5(SW1) PQ93008.6(SW2) PQ93008.7(SW3) PR90014.1
CORE_PWM2_VCC: PC90019.1 PR90009.2 PU90002.4(VCC)
CORE_PWM3_BOOT: PR93098.1 PU93004.1(BST)
CORE_PWM3_BOOT_R_C: PC941588.2 PR93098.2
CORE_PWM3_EN: PR93071.2 PU93004.3(EN)
CORE_PWM3_HG_D: PR93070.1 PU93004.8(DRVH)
CORE_PWM3_HG_D_R: PC941591.1 PQ93018.1(HSG) PR93069.1 PR93070.2
CORE_PWM3_LG_D: PR93067.1 PU93004.5(DRVL)
CORE_PWM3_LG_D_R: PC941589.1 PQ93018.8(LSG) PR93067.2 PR93099.1
CORE_PWM3_SW_D: PC941588.1 PC941591.2 PQ93018.2(GR) PR93069.2 PU93004.7(SW)
CORE_PWM3_SW_S: PC941586.1 PJP93006.1 PL93006.1 PQ93018.5(SW1) PQ93018.6(SW2) PQ93018.7(SW3) PR93066.1
CORE_PWM3_VCC: PC941590.1 PR93068.2 PU93004.4(VCC)
CPU_CFG0: AR41.2 HR36.1 HR364.2 XDP1.9(OBSDATA_A0) XU1.H15(CFG[0])
CPU_CFG1: HR37.1 XDP1.11(OBSDATA_A1) XU1.F15(CFG[1])
CPU_CFG2: HR38.1 XDP1.15(OBSDATA_A2) XU1.F16(CFG[2])
CPU_CFG3: HR39.1 HR385.2 PT264.1 XDP1.17(OBSDATA_A3) XU1.H16(CFG[3])
CPU_CFG3_R: HR346.2 HR385.1 XDP1.1(GND1)
CPU_CFG4: HR40.1 XDP1.27(OBSDATA_B0) XU1.F19(CFG[4])
CPU_CFG5: HR41.1 XDP1.29(OBSDATA_B1) XU1.H18(CFG[5])
CPU_CFG6: HR42.1 XDP1.33(OBSDATA_B2) XU1.G21(CFG[6])
CPU_CFG7: HR43.1 XDP1.35(OBSDATA_B3) XU1.H20(CFG[7])
CPU_CFG8: HR44.1 XDP1.10(OBSDATA_C0) XU1.G16(CFG[8])
CPU_CFG9: AR43.1 HR45.1 XDP1.12(OBSDATA_C1) XU1.E16(CFG[9])
CPU_CFG10: HR46.1 XDP1.16(OBSDATA_C2) XU1.F17(CFG[10])
CPU_CFG11: HR47.1 XDP1.18(OBSDATA_C3) XU1.H17(CFG[11])
CPU_CFG12: HR48.1 XDP1.28(OBSDATA_D0) XU1.G20(CFG[12])
CPU_CFG13: HR49.1 XDP1.30(OBSDATA_D1) XU1.F20(CFG[13])
CPU_CFG14: HR54.1 XDP1.34(OBSDATA_D2) XU1.F21(CFG[14])
CPU_CFG15: HR55.1 XDP1.36(OBSDATA_D3) XU1.H19(CFG[15])
CPU_DDR_VTT_CNTL: HR4.1 XU1.AC36(DDR_VTT_CNTL)
CPU_FAN_CTL: ST31.1 U1.T48(GPP_K19/SMI#)
CPU_FAN_CTRL_SIO: FR1.2 FR2.2 U104.47(GP022/PWM1)
CPU_FAN_TACH_SIO: FD1.1(ANODE1) FD1.2(ANODE2) R62.1 U104.37(TACH1/GP017)
CPU_TRST#: HR366.1 U1.AM4(CPU_TRST#)
CPU_VCCIO_PWR_GATEB: R99518.1 SR75.1 U1.AY3(GPP_J1/CPU_VCCIO_PWR_GATE#)
CPU_VIDALERT#_L500MIL: HR23.2 XU1.E39(VIDALERT#)
CPU_XDP_BPM0: HR426.1 XU1.D16(BPM#[0])
CPU_XDP_BPM0_R: HR426.2 XDP1.21(OBSFN_B0)
CPU_XDP_BPM1: HR427.1 XU1.D17(BPM#[1])
CPU_XDP_BPM1_R: HR427.2 XDP1.23(OBSFN_B1)
CPU_XDP_HOOK1: HCB6.2 HR96.1 HR379.2 XDP1.41(HOOK1)
CPU_XDP_HOOK2: HR364.1 HR365.2 XDP1.45(HOOK2)
CPU_XDP_HOOK3: HCB5.2 HR98.1 HR381.1 SR774.2 XDP1.47(HOOK3)
CPU_XDP_HOOK6: HR377.1 HR378.2 SR773.2 XDP1.46(HOOK6/RESET#)
CPU_XDP_HOOK7: HCB3.2 HR380.1 HR399.2 XDP1.48(HOOK7/DBR#)
CPUFAN_PWM_CON: FCB1.1 FR2.1 P70.4
CPUFAN_TACH_C: FCB2.1 FD1.3(CATHODE) P70.1
CPUPWRGD: HR24.2 HR392.1 SC85.1 SR275.2
CPUPWRGD_R: HR24.1 XU1.F8(PROCPWRGD)
CPVEE: AC24.1 U6.34(CPVEE)
D3_1: D3.1(ANODE1) SR817.2 SR818.1
D3_2: D3.2(ANODE2) D525.1(ANODE1) R70.2
D9_D9.5_ID: R38.1 SR57.1 U1.AV46(GPP_F20/EDP_BKLTEN)
D521_2: D521.2(CATHODE) R99531.2 R99532.2
DC_DET: AR40.1 U6.4(DC_DET)
DC_IN_ID_ADAP: C94.1 L93006.1 PR8.2
DCPRTC: SCB27.1 U1.BF47(DCPRTC_1) U1.BG47(DCPRTC_2)
DDR_VTT_CNTL: HQ1.3(COLLECTOR) HR1.2 PR128.1
DDR_VTT_CNTL_R: HQ2.1(BASE) HR4.2
DDRA_VREF_CA_R: D4C34.1 D4R8.2 D4R9.1 PR93064.1
DDRA_VREF_CA_R_W10S12: HC1.1 HR5.1 XU1.AB40(DDR_VREF_CA)
DDRA_VREF_CA_W10S12: D4C10.1 D4C11.1 D4C23.2 DIMM2.164(VREFCA) HR5.2 PR93064.2
DDRB_VREF_CA_R: D4C33.1 D4R19.2 D4R20.1 PR93065.1
DDRB_VREF_CA_R_W10S12: HC2.1 HR6.1 XU1.AC39(DDR1_VREF_DQ)
DDRB_VREF_CA_W10S12: D4C21.1 D4C22.1 D4C24.2 D4C25.1 DIMM1.164(VREFCA) HR6.2 PR93065.2
DEBUG_CLK: P12.12 R637.2 SCB121.2
DEBUG_SPI_IO0: F3R23.1 HR381.2 SR166.2
DEBUG_SPI_IO2: F3R22.1 HR367.2 SR760.2
DEVSLP_N: APR17.1 SR7915.2
DEVSLP_SSD_SLEEP_MODE: APR17.2 J219.38
DISCH_PSON_EN: M1C43.2 Q5.1(GATE) Q6.1(GATE) Q7.1(GATE) Q8.1(GATE) Q9537.1(GATE) Q9540.1(GATE) Q9541.1(GATE) Q9542.1(GATE) SR7890.2
DISCH_S4_EN: Q9544.1(GATE) SR7889.2
DISCH_SSD_EN: Q941.1(GATE) SR79.2
DISCH_SSD_EN_D: Q941.3(DRAIN) Q942.1(GATE) R933.2
DISCH_WLAN_EN: Q93.1(GATE) SR78.2
DISCH_WLAN_EN_D: Q93.3(DRAIN) Q940.1(GATE) R931.2
DISPA_BCLK_L200MIL: SR137.2 U1.AM3(HDACPU_SCLK)
DISPA_SDO_L200MIL: SR136.2 U1.AM2(HDACPU_SDO)
DMI_RXN0: U1.C29(DMI3_TXN) XU1.Y4(DMI_RXN[0])
DMI_RXN1: U1.C31(DMI2_TXN) XU1.AA5(DMI_RXN[1])
DMI_RXN2: U1.C32(DMI1_TXN) XU1.AB3(DMI_RXN[2])
DMI_RXN3: U1.C33(DMI0_TXN) XU1.AC5(DMI_RXN[3])
DMI_RXP0: U1.B29(DMI3_TXP) XU1.Y3(DMI_RXP[0])
DMI_RXP1: U1.B31(DMI2_TXP) XU1.AA4(DMI_RXP[1])
DMI_RXP2: U1.B32(DMI1_TXP) XU1.AB4(DMI_RXP[2])
DMI_RXP3: U1.B33(DMI0_TXP) XU1.AC4(DMI_RXP[3])
DMI_TXN0: U1.G30(DMI3_RXN) XU1.AC1(DMI_TXN[0])
DMI_TXN1: U1.K32(DMI2_RXN) XU1.AD2(DMI_TXN[1])
DMI_TXN2: U1.G33(DMI1_RXN) XU1.AE1(DMI_TXN[2])
DMI_TXN3: U1.K34(DMI0_RXN) XU1.AF3(DMI_TXN[3])
DMI_TXP0: U1.F30(DMI3_RXP) XU1.AC2(DMI_TXP[0])
DMI_TXP1: U1.J32(DMI2_RXP) XU1.AD3(DMI_TXP[1])
DMI_TXP2: U1.F34(DMI1_RXP) XU1.AE2(DMI_TXP[2])
DMI_TXP3: U1.J35(DMI0_RXP) XU1.AF2(DMI_TXP[3])
DP_CABLE_DETECT: J69.30 SR7976.1
DP_CABLE_DETECT_R: SR40.2 SR7976.2 U1.AR48(GPP_F11/SATA_SLOAD)
DP_PW_EN: C941629.1 Q93025.1(GATE) Q93041.1(GATE) R93100.1 R93101.2
DPB_CTRL_CLK: M1R24.2 Q9432.4(S2) U1.AL13(GPP_I5/DDPB_CTRLCLK)
DPB_CTRL_DATA: M1R23.2 Q9432.1(S1) U1.AR8(GPP_I6/DDPB_CTRLDATA)
DPB_HPD: M1Q7.2(SOURCE) R2353.2 U1.AT6(GPP_I0/DDPB_HPD0/DISP_MISC0) U1.BD8(GPP_G6/SD_CLK)
DPB_HPD_R: M1Q7.3(DRAIN) M2R1.2
DPB_TXN0: M1C118.1 XU1.D21(DDI1_TXN[0])
DPB_TXN1: M1C120.1 XU1.E22(DDI1_TXN[1])
DPB_TXN2: M1C122.1 XU1.A23(DDI1_TXN[2])
DPB_TXN3: M1C124.1 XU1.D23(DDI1_TXN[3])
DPB_TXP0: M1C117.1 XU1.C21(DDI1_TXP[0])
DPB_TXP1: M1C119.1 XU1.D22(DDI1_TXP[1])
DPB_TXP2: M1C121.1 XU1.B23(DDI1_TXP[2])
DPB_TXP3: M1C123.1 XU1.C23(DDI1_TXP[3])
DPC_AUXN: M1C101.2 XU1.B12(DDI2_AUXN)
DPC_AUXN_C: AQ17.1(S1) M1C101.1
DPC_AUXN_I: AQ17.6(D1) AQ18.3(D2) J302.17(AUX_CH(N)) M1R21.2
DPC_AUXP: M1C111.2 XU1.A12(DDI2_AUXP)
DPC_AUXP_C: AQ17.4(S2) M1C111.1
DPC_AUXP_I: AQ17.3(D2) AQ18.1(S1) J302.15(AUX_CH(P)) M1R22.1
DPC_CON_PIN13: FR12.2 J302.13(CONFIG1) M1C113.1 SR7904.1
DPC_CON_PIN13_R: AQ19.5(G2) FR12.1 M1C112.1
DPC_CON_PIN14: J302.14(CONFIG2) R99508.1
DPC_CTRL_CLK: SR7905.2 SR7906.2 U1.AN13(GPP_I7/DDPC_CTRLCLK)
DPC_CTRL_CLK_R: AQ18.6(D1) SR7905.1
DPC_CTRL_DATA: SR7901.2 SR7902.2 U1.AL10(GPP_I8/DDPC_CTRLDATA)
DPC_CTRL_DATA_R: AQ18.4(S2) SR7901.1
DPC_HPD: M1Q8.2(SOURCE) R2354.2 U1.AN10(GPP_I1/DDPC_HPD1/DISP_MISC1) U1.AV13(GPP_G7/SD_WP)
DPC_HPD_CON: J302.18(HOT_PLUG_DETECT) M1Q8.3(DRAIN) M1R20.1
DPC_PIN13_INV: AQ17.2(G1) AQ17.5(G2) AQ19.2(G1) AQ19.3(D2) M1C114.1 SR7907.2
DPC_PIN13_MOS: AQ18.2(G1) AQ18.5(G2) AQ19.6(D1) M1C102.1 SR7903.2
DPC_TXN0: M1C104.2 XU1.A18(DDI2_TXN[0])
DPC_TXN0_C: J302.3(ML_LANE_0(N)/ML_LANE_3(P)) M1C104.1 M1U3.1(TMDS_CH1-) M1U3.10(NC4)
DPC_TXN1: M1C106.2 XU1.E18(DDI2_TXN[1])
DPC_TXN1_C: J302.6(ML_LANE_1(N)/ML_LANE_2(P)) M1C106.1 M1U3.5(TMDS_CH2+) M1U3.6(NC1)
DPC_TXN2: M1C108.2 XU1.D19(DDI2_TXN[2])
DPC_TXN2_C: J302.9(ML_LANE_2(N)/ML_LANE_1(P)) M1C108.1 M1U4.2(TMDS_CH1+) M1U4.9(NC3)
DPC_TXN3: M1C110.2 XU1.E20(DDI2_TXN[3])
DPC_TXN3_C: J302.12(ML_LANE_3(N)/ML_LANE_0(P)) M1C110.1 M1U4.4(TMDS_CH2-) M1U4.7(NC2)
DPC_TXP0: M1C103.2 XU1.B18(DDI2_TXP[0])
DPC_TXP0_C: J302.1(ML_LANE_0(P)/ML_LANE_3(N)) M1C103.1 M1U3.2(TMDS_CH1+) M1U3.9(NC3)
DPC_TXP1: M1C105.2 XU1.D18(DDI2_TXP[1])
DPC_TXP1_C: J302.4(ML_LANE_1(P)/ML_LANE_2(N)) M1C105.1 M1U3.4(TMDS_CH2-) M1U3.7(NC2)
DPC_TXP2: M1C107.2 XU1.C19(DDI2_TXP[2])
DPC_TXP2_C: J302.7(ML_LANE_2(P)/ML_LANE_1(N)) M1C107.1 M1U4.1(TMDS_CH1-) M1U4.10(NC4)
DPC_TXP3: M1C109.2 XU1.D20(DDI2_TXP[3])
DPC_TXP3_C: J302.10(ML_LANE_3(P)ML_LANE_0(N)) M1C109.1 M1U4.5(TMDS_CH2+) M1U4.6(NC1)
DPD_AUXN: J69.15 XU1.C11(DDI3_AUXN)
DPD_AUXP: J69.14 XU1.B11(DDI3_AUXP)
DPD_CTRL_CLK: J69.17 R39.2 U1.AL9(GPP_I9/DDPD_CTRLCLK)
DPD_CTRL_DATA: J69.18 R40.2 U1.AR3(GPP_I10/DDPD_CTRLDATA)
DPD_HPD: J69.22 SR7981.2 U1.AP9(GPP_I2/DPPD_HPD2/DISP_MISC2)
DPD_TXN0: J69.11 XU1.A14(DDI3_TXN[0])
DPD_TXN1: J69.8 XU1.B15(DDI3_TXN[1])
DPD_TXN2: J69.5 XU1.A16(DDI3_TXN[2])
DPD_TXN3: J69.2 XU1.B17(DDI3_TXN[3])
DPD_TXP0: J69.12 XU1.B14(DDI3_TXP[0])
DPD_TXP1: J69.9 XU1.C15(DDI3_TXP[1])
DPD_TXP2: J69.6 XU1.B16(DDI3_TXP[2])
DPD_TXP3: J69.3 XU1.C17(DDI3_TXP[3])
DRAMA_RESET#: HR411.2 SC26.1 SR265.2 SR291.1 U1.BB46(DRAM_RESET#)
DRAMB_RESET#: CB4132.2 D4C5.1 D4C16.1 DIMM1.108(RESET_N) DIMM2.108(RESET_N) HR411.1
DUAL_POWER_DISCH_G: M1C44.2 Q9543.1(GATE) Q9544.3(DRAIN) Q93037.1(GATE) Q93038.1(GATE) R663.2
E16_CLK: E16.7 F3R25.2
E16_CS0#: E16.1 F3R27.2
E16_IO2: E16.9 F3R26.2
E16_IO3: E16.10 F3R21.2
E16_MISO: E16.5 F3R20.2
E16_MOSI: E16.3 F3R24.2
EDP_4_HPD: M1R10.1 U1.AN6(GPP_I4/EDP_HPD/DISP_MISC4)
EDP_DETECT: SR71.2 SR84.1 U1.V47(GPP_K9)
EDP_RCOMP_W5S20O25: HR10.2 XU1.M9(DISP_RCOMP)
EN_OK: C941489.1 Q9534.1(GATE) Q9535.1(GATE) R70298.2
FM_TBT_FORCE_PWR: LT9.1 U1.BE20(GPP_C21/UART2_TXD)
FM_TBT_SCI_EVENT: SR7847.2 U1.AW21(GPP_C22/UART2_RTS#)
FP_CBL_DET: ECR146.1 SR7942.2 U1.BD20(GPP_C20/UART2_RXD)
FP_CBL_DET_SIO: ECR146.2 OR59.1 U104.50((FP_CBL_DET#)GP025)
FRAME#_DEBUG: ECR106.2 P12.10
GP001: OR128.2 OR144.2 U104.3(VSS2)
GP002: OR129.2 U104.5(NC1)
GP003: OR130.2 U104.6(NC2)
GP111: OR124.2 U104.61(NC3)
GP112: OR125.2 U104.62(NC4)
GP113: OR126.2 U104.63(NC5)
GP114: OR127.2 U104.64(NC6)
GPIO_PEG SLOT_RESET: SR7834.1 U1.AT49(GPP_F22/DDPF_CTRLCLK)
GPIO_WIRELESS_DISABLE1#: APD2.2(CATHODE) R3108.2 SR7940.2 U1.BF33(GPP_B1/GSPI1_CS1#/TIME_SYNC1)
GPIO_WIRELESS_DISABLE2#: APD1.2(CATHODE) R3109.2 SR7939.2 U1.BE29(GPP_B0/GSPI0_CS1#)
GPIO_WIRELESS_DISABLE#_R: APD2.1(ANODE) APR136.2 J218.56(W_DISABLE1*) R3108.1
GPP_A8: SR7841.2 SR7938.1 U1.AV32(GPP_A8/CLKRUN#)
GPP_A_21: SR7882.2 SR7883.2 U1.BA33(GPP_A21/ISH_GP3)
GPP_A_22: SR7944.2 SR7947.2 U1.AW32(GPP_A22/ISH_GP4)
GPP_A_23: SR7945.2 SR7946.2 U1.AV34(GPP_A23/ISH_GP5)
GPP_B4: SR674.2 U1.BC33(GPP_B4/CPU_GP3)
GPP_B_15: SR7843.2 U1.BB26(GPP_B15/GSPI0_CS0#)
GPP_B_16: SR7842.2 U1.BF29(GPP_B16/GSPI0_CLK)
GPP_D_7_USB_WAKEOUT_N: SR7922.2 SR7923.1 U1.BE41(GPD7)
GPP_F6: SR7803.2 U1.AR47(GPP_F6/SATA_DEVSLP4)
GPP_F7: ST34.1 U1.AN46(GPP_F7/SATA_DEVSLP5)
GPP_F13: SR41.2 U1.AU47(GPP_F13/SATA_SDATAOUT0)
GPP_F14: SR46.2 U1.AP41(GPP_F14/EXT_PWR_GATE#/PS_ON#)
GPP_F21: SR7848.2 U1.AU48(GPP_F21/EDP_BKLTCTL)
GPP_G0: R2341.2 R2343.1 U1.AW13(GPP_G0/SD_CMD)
GPP_G2: MQ27.1(GATE) R2345.2 R2347.1 U1.BF8(GPP_G2/SD_D1)
GPP_G4: R2349.2 R2351.1 U1.BG8(GPP_G4/SD_D3)
GPP_G5: R2350.2 R2352.1 U1.BE8(GPP_G5/SD_CD#)
GPP_H_3: SR7852.1 U1.AF48(GPP_H3/SRCCLKREQ9#)
GPP_H_4: SR7851.1 U1.AC41(GPP_H4/SRCCLKREQ10#)
GPP_H_5: SR7850.1 U1.AC39(GPP_H5/SRCCLKREQ11#)
GPP_H_6: SR420.1 U1.AE39(GPP_H6/SRCCLKREQ12#)
GPP_H_12: SR277.2 SR298.1 U1.AB47(GPP_H12/SML2ALERT#)
GPP_J_0_CNV_GNSS_PA_BLANKING: R3129.1 U1.AV6(GPP_J0/CNV_PA_BLANKING)
GPP_J_0_CNV_GNSS_PA_BLANKING_R: J218.44(COEX3) R3129.2
GPP_J_8_CNV_MFUART2_RXD: R3131.1 U1.AW2(GPP_J8/CNV_MFUART2_RXD)
GPP_J_8_CNV_MFUART2_RXD_R: J218.48(COEX1) R3131.2
GPP_J_9_CNV_MFUART2_TXD: R3130.1 SR7924.1 SR7925.1 U1.AU9(GPP_J9/CNV_MFUART2_TXD)
GPP_J_9_CNV_MFUART2_TXD_R: J218.46(COEX2) R3130.2
GPP_K5: MQ26.1(GATE) SR7953.2 SR7954.1 SR7966.2 U1.N47(GPP_K5)
GSPI1_MISO: SR7796.2 U1.BD30(GPP_B21/GSPI1_MISO)
GT1_CSP1_A: PC89026.1 PR89045.1 PR89047.2 PU89001.25(CSP1A)
GT2_CSN2_A: PC89029.1 PC89030.2 PR89051.1 PR89052.2 PU89001.24(CSN2A)
GT2_CSP2_A: PC89030.1 PR89052.1 PR89055.2 PU89001.23(CSP2A)
GT_COMPA: PC89024.1 PC89025.1 PU89001.18(COMPA)
GT_COMPA_R: PC89024.2 PR89043.2
GT_CSCOMP: PC89032.2 PC89034.2 PR89059.1 PR89062.2 PRT89002.1 PU89001.19(CSCOMPA)
GT_CSCOMP_R: PR89059.2 PR89060.1 PRT89002.2
GT_CSN1_A: PC89026.2 PJP93002.2 PR89045.2 PR89067.2 PU89001.26(CSN1A)
GT_CSN2_A: PJP93004.2 PR89051.2 PR89069.2
GT_CSP1_A: PJP93001.2 PR89047.1 PR89057.2
GT_CSP2_A: PJP93003.2 PR89055.1 PR89061.2
GT_CSREF_A: PC89035.2 PR89067.1 PR89069.1 PU89001.22(CSREFA)
GT_CSSUM: PC89032.1 PC89034.1 PR89057.1 PR89060.2 PR89061.1 PU89001.21(CSSUMA)
GT_DIFFOUTA: PR89042.1 PR89044.1 PU89001.16(DIFFA)
GT_DIFFOUTA_R: PC89023.2 PR89042.2
GT_FBA: PC89023.1 PC89025.2 PR89043.1 PR89044.2 PR89046.1 PU89001.17(FBA)
GT_ILIM_A: PR89062.1 PU89001.20(ILIMA)
GT_IOUTA: PC89033.1 PR89063.2 PU89001.13(IOUTA)
GT_PWM1_A: PR89041.1 PU89001.30(PWM1A) PU93001.2(PWM)
GT_PWM1_BOOT: PR93003.1 PU93001.1(BST)
GT_PWM1_BOOT_R_C: PC93005.2 PR93003.2
GT_PWM1_EN: PR93005.2 PU93001.3(EN)
GT_PWM1_HG_D: PR93001.1 PU93001.8(DRVH)
GT_PWM1_HG_D_R: PC93006.1 PQ93001.1(G1) PR93001.2 PR93004.1
GT_PWM1_LG_D: PR93007.1 PU93001.5(DRVL)
GT_PWM1_LG_D_R: PC93010.1 PQ93001.8(G2) PR93007.2 PR93008.1
GT_PWM1_SN: PC93009.1 PR93006.2
GT_PWM1_SW_S: PC93005.1 PC93006.2 PC93008.1 PJP93001.1 PL93001.1 PQ93001.9(PHASE(S1/D2)) PQ93001.10(PHASE(S1/D2)_1) PQ93001.11(PHASE(S1/D2)_2) PQ93001.12(PHASE(S1/D2)_3) PQ93001.13(PHASE(S1/D2)_4) PQ93001.14(PHASE(S1/D2)_5) PQ93001.15(PHASE(S1/D2)_6) PQ93001.16(PHASE(S1/D2)_7) PQ93001.17(PHASE(S1/D2)_8) PR93004.2 PR93006.1 PU93001.7(SW)
GT_PWM1_VCC: PC93007.2 PR93002.2 PU93001.4(VCC)
GT_PWM2_A: PR89049.1 PU89001.31(PWM2A) PU93002.2(PWM)
GT_PWM2_BOOT: PR93010.1 PU93002.1(BST)
GT_PWM2_BOOT_R_C: PC93016.2 PR93010.2
GT_PWM2_EN: PR93013.2 PU93002.3(EN)
GT_PWM2_HG_D: PR93011.1 PU93002.8(DRVH)
GT_PWM2_HG_D_R: PC93017.1 PQ93002.1(G1) PR93011.2 PR93012.1
GT_PWM2_LG_D: PR93015.1 PU93002.5(DRVL)
GT_PWM2_LG_D_R: PC93021.1 PQ93002.8(G2) PR93015.2 PR93016.1
GT_PWM2_SN: PC93020.1 PR93014.2
GT_PWM2_SW_S: PC93016.1 PC93017.2 PC93019.1 PJP93003.1 PL93002.1 PQ93002.9(PHASE(S1/D2)) PQ93002.10(PHASE(S1/D2)_1) PQ93002.11(PHASE(S1/D2)_2) PQ93002.12(PHASE(S1/D2)_3) PQ93002.13(PHASE(S1/D2)_4) PQ93002.14(PHASE(S1/D2)_5) PQ93002.15(PHASE(S1/D2)_6) PQ93002.16(PHASE(S1/D2)_7) PQ93002.17(PHASE(S1/D2)_8) PR93012.2 PR93014.1 PU93002.7(SW)
GT_PWM2_VCC: PC93018.1 PR93009.2 PU93002.4(VCC)
GT_ROSC: PR89070.1 PU89001.8(ROSC)
GT_TSENSEA: PC89037.1 PR89072.2 PU89001.11(TSENSEA)
GT_TSENSEA_R: PR89072.1 PR89073.1 PRT89004.1
GT_VSNA: PC89031.2 PR89054.2 PU89001.14(VSNA)
GT_VSPA: PC89027.1 PC89028.1 PR89048.2 PR89050.2 PU89001.15(VSPA)
H_DDR_VTT_CNTL: HQ2.3(COLLECTOR) HR2.2 HR3.1
H_DDR_VTT_CNTL_R: HQ1.1(BASE) HR3.2
H_PRDY#: HR369.2 XDP1.5(OBSFN_A1) XU1.B10(PROC_PRDY#)
H_PREQ#: HR347.2 HR368.2 XDP1.3(OBSFN_A0) XU1.B9(PROC_PREQ#)
H_PROCHOT#: C83.1 ECR104.2 HR29.2 HR33.1 MQ28.3(DRAIN) SR7995.1
H_SKTOCC_N: SR7928.2 U1.AP3(GPP_I11/M2_SKT2_CFG0) XU1.AC38(SKTOCC#)
H_TAPPWRGOOD: AR41.1 R93119.1
H_THMTRIP#: HR413.1 SR259.2 SR266.2
H_THMTRIP#_CPU: HR413.2 XU1.D11(THERMTRIP#)
H_TRIGIN: R2420.2 XU1.D1(PROC_TRIGIN)
H_TRIGOUT: HR25.2 U1.AK2(TRIGGER_IN)
H_TRIGOUT_LMIL: HR25.1 XU1.B3(PROC_TRIGOUT)
HDA_BCLK: AC1.1 SR132.1 SR220.1 U6.6(BCLK)
HDA_BCLK_R: SC14.1 SR132.2 U1.BD11(HDA_BCLK/I2S0_SCLK)
HDA_RST#: AR19.1 AR38.1 SR133.1 SR221.1 U6.11(RESETB)
HDA_RST#_R: SC13.1 SR133.2 U1.BE10(HDA_RST#/I2S1_SCLK)
HDA_SDI0: SC87.1 SR7795.1 U1.BE11(HDA_SDI0/I2S0_RXD)
HDA_SDI0_R: SR7795.2 U6.8(SDATA-IN)
HDA_SDO: SR124.1 U6.5(SDATA-OUT)
HDA_SDO_R: SC16.1 SR124.2 SR7812.1 U1.BF12(HDA_SDO/I2S0_TXD)
HDA_SYNC: SR125.1 U6.10(SYNC)
HDA_SYNC_R: SC15.1 SR125.2 U1.BG13(HDA_SYNC/I2S0_SFRM)
HDD_LED+: C248.1 CR15.1(ANODE) R69695.2
HDD_LED-_EMI-: C249.1 CR15.2(CATHODE) Q9435.3(DRAIN) Q9437.3(DRAIN)
HDMI2_CABLE_DETECT: J69.21 SR7977.2
HDMI2_CABLE_DETECT_R: SR7931.2 SR7977.1 U1.P47(GPP_K6)
HDMI_CTRL_CLK_LS: J125.15 M1R26.1 Q9432.3(D2)
HDMI_CTRL_DATA_LS: J125.16 M1R25.1 Q9432.6(D1)
HDMI_HPD_CON: D4310.1(ANODE) J125.19 M1R14.2 M2R1.1
HDMI_PD: M1Q9.3(DRAIN) RN133.2(4) RN133.4 RN133.6(4) RN133.8(4) RN134.2(4) RN134.4 RN134.6(4) RN134.8(4)
HDMI_TMDS_CLK_N: J125.12 M1C124.2 RN134.7(3)
HDMI_TMDS_CLK_P: J125.10 M1C123.2 RN134.5(3)
HDMI_TMDS_DATA0_N: J125.9 M1C122.2 RN133.1(3)
HDMI_TMDS_DATA0_P: J125.7 M1C121.2 RN133.3
HDMI_TMDS_DATA1_N: J125.6 M1C120.2 RN134.3
HDMI_TMDS_DATA1_P: J125.4 M1C119.2 RN134.1(3)
HDMI_TMDS_DATA2_N: J125.3 M1C118.2 RN133.5(3)
HDMI_TMDS_DATA2_P: J125.1 M1C117.2 RN133.7(3)
HPOUT1_JD: D4308.2(CATHODE) J301.5 R69692.2
HPOUT1_JD_R: AC98.1 R69692.1 R70263.1 U6.13(HP/LINE1_JD(JD1))
HPOUT1_L: AR22.1 HR69.2 R70275.1 U6.32(HPOUT-L(PORT-I-L))
HPOUT1_R: AR23.1 HR70.2 R70274.1 U6.33(HPOUT-R(PORT-I-R))
HPOUT2_L_B: C4301.1 D4301.2(CATHODE) J89.2 L122.2
HPOUT2_R_B: C4302.1 D4302.2(CATHODE) J89.3 L123.2
I2C0_SCL_R: SR7935.2 U1.BC22(GPP_C17/I2C0_SCL)
I2C0_SDA_R: SR7934.2 U1.BF23(GPP_C16/I2C0_SDA)
INTRUDER: P305.3 P305.4 SC25.1 SR257.2 U1.BB44(INTRUDER#)
INTRUDER_DET: P305.1 R3106.1 SR7990.2
INTRUDER_DET_R: SR118.2 SR7990.1 U1.W46(GPP_K14/GSXDIN)
IO_SMI_N: ECR149.2 OR29.2 U104.126((SLP_M#)GP071/IO_SMI#)
ITP_PMODE: HR377.2 SR165.1 U1.AL3(ITP_PMODE)
ITP_PMODE_PCH_XDP: SR165.2 SR758.2 SR823.1 XDP3.46(HOOK6/RESET#)
ITPCLK/HOOK4: SR167.2 XDP3.40(ITPCLK/HOOK4)
J219_P70: J219.70 R3138.2
KB_CLK: J68.20 OR68.1 U104.113(KCLK)
KB_DATA: J68.22 OR69.1 U104.114(KDAT)
KBRST_N: SR16.2 U1.BE39(GPP_A0/RCIN#/ESPI_ALERT1#) U104.118(GP063/KBDRST#)
L23_1: APR46.2 APR47.2 D519.1(ANODE) L129.1
L_AD0: C17.1 ECR73.1 ECR110.1 U1.BB39(GPP_A1/LAD0/ESPI_IO0)
L_AD0_SIO: ECR73.2 U104.8(LAD0)
L_AD1: C18.1 ECR74.1 ECR109.1 U1.AW37(GPP_A2/LAD1/ESPI_IO1)
L_AD1_SIO: ECR74.2 U104.9(LAD1)
L_AD2: C15.1 ECR75.1 ECR108.1 U1.AV37(GPP_A3/LAD2/ESPI_IO2)
L_AD2_SIO: ECR75.2 U104.10(LAD2)
L_AD3: C16.1 ECR76.1 ECR107.1 U1.BA38(GPP_A4/LAD3/ESPI_IO3)
L_AD3_SIO: ECR76.2 U104.11(LAD3)
L_FRAME_N_R: ECR77.1 ECR106.1 U1.BE38(GPP_A5/LFRAME#/ESPI_CS0#)
L_FRAME_N_R_SIO: ECR77.2 U104.12(LFRAME#)
LAD0_DEBUG: ECR110.2 P12.2
LAD1_DEBUG: ECR109.2 P12.4
LAD2_DEBUG: ECR108.2 P12.6
LAD3_DEBUG: ECR107.2 P12.8
LAN1_GND: C3102.2 J8.13(P_GND1)
LAN2_GND: C3101.2 J8.14(P_GND2)
LAN_ACT#: D3106.1(ANODE) J8.10 LC5.1 U114.27(LED0)
LAN_CLKREQ#_R: R4009.2 R4011.2 U114.12(CLKREQB)
LAN_DISABLE_N: ECR156.1 SR251.2 U1.BF41(GPD11/LANPHYPC)
LAN_GATE#: C4012.2 Q4000.1(GATE) R4003.2 R4006.1
LAN_ISOLATEB: R4001.2 R4002.1 U114.20(ISOLATEB)
LAN_LED1: Q2.1(GATE) R1.2 U114.26(LED1/GPO)
LAN_LED1_R: D3104.1(ANODE) J8.11 LC7.1 R1.1
LAN_LED2: Q2.2(SOURCE) R2.2 U114.25(LED2)
LAN_LED2_R: D3103.1(ANODE) J8.12 LC8.1 LR10.2 LR11.1 R2.1
LAN_MDI0_N: CM3104.3 RN128.3(X) U114.2(MDIN0)
LAN_MDI0_N_C: CM3104.4 D3101.1(TX1+IN1) D3101.10(TX1+OUT) LU3.12(TD4-) RN128.4(Y)
LAN_MDI0_P: CM3104.2 RN128.1(X) U114.1(MDIP0)
LAN_MDI0_P_C: CM3104.1 D3101.2(TX1+IN2) D3101.9(TX1-OUT) LU3.11(TD4+) RN128.2(Y)
LAN_MDI0N_T: J8.2(TX_DA-) LU3.13(MX4-)
LAN_MDI0P_T: J8.1(TX_DA+) LU3.14(MX4+)
LAN_MDI1_N: CM3103.3 RN127.3(X) U114.5(MDIN1)
LAN_MDI1_N_C: CM3103.4 D3101.4(TX2+IN) D3101.7(TX2+OUT) LU3.9(TD3-) RN127.4(Y)
LAN_MDI1_P: CM3103.2 RN127.1(X) U114.4(MDIP1)
LAN_MDI1_P_C: CM3103.1 D3101.5(TX2-IN) D3101.6(TX2-OUT) LU3.8(TD3+) RN127.2(Y)
LAN_MDI1N_T: J8.6(RX_DB-) LU3.16(MX3-)
LAN_MDI1P_T: J8.3(RX_DB+) LU3.17(MX3+)
LAN_MDI2_N: CM3102.3 RN126.3(X) U114.7(MDIN2)
LAN_MDI2_N_C: CM3102.4 D3102.1(TX1+IN1) D3102.10(TX1+OUT) LU3.6(TD2-) RN126.4(Y)
LAN_MDI2_P: CM3102.2 RN126.1(X) U114.6(MDIP2)
LAN_MDI2_P_C: CM3102.1 D3102.2(TX1+IN2) D3102.9(TX1-OUT) LU3.5(TD2+) RN126.2(Y)
LAN_MDI2N_T: J8.5(NC/BI_DC-) LU3.19(MX2-)
LAN_MDI2P_T: J8.4(NC/BI_DC+) LU3.20(MX2+)
LAN_MDI3_N: CM3101.3 RN125.3(X) U114.10(MDIN3)
LAN_MDI3_N_C: CM3101.4 D3102.4(TX2+IN) D3102.7(TX2+OUT) LU3.3(TD1-) RN125.4(Y)
LAN_MDI3_P: CM3101.2 RN125.1(X) U114.9(MDIP3)
LAN_MDI3_P_C: CM3101.1 D3102.5(TX2-IN) D3102.6(TX2-OUT) LU3.2(TD1+) RN125.2(Y)
LAN_MDI3N_T: J8.8(NC/BI_DD-) LU3.22(MX1-)
LAN_MDI3P_T: J8.7(NC/BI_DD+) LU3.23(MX1+)
LAN_RSET: R4010.1 U114.31(RSET)
LAN_WAKE#_R: R4004.2 R4007.1 U114.21(LANWAKEB)
LAN_XTAL_IN: C4023.2 R4008.2 U114.28(CKXTAL1)
LAN_XTAL_IN_R: R4008.1 Y4000.3
LAN_XTAL_OUT: C4022.2 U114.29(CKXTAL2) Y4000.1
LANCLK_REQ_N: R4011.1 SR911.2 SR7878.2 SR7896.2 U1.AR32(GPP_B7/SRCCLKREQ2#)
LANLED2: D3105.1(ANODE) J8.9 LC6.1 LR9.2
LANWAKE_R_N: Q4001.3(COLLECTOR) SR254.2 U1.BG44(GPD2/LAN_WAKE#)
LDO1_CAP: AC86.1 R70273.1 U6.27(LDO1-CAP)
LDO2_CAP: AC89.1 U6.39(LDO2-CAP)
LDO3_CAP: AC82.1 U6.7(LDO3-CAP)
LINE1-L: AC100.2 U6.22(LINE1-L(PORT-C-L))
LINE1-L_C: AC100.1 R70275.2
LINE1-R: AC99.2 U6.21(LINE1-R(PORT-C-R))
LINE1-R_C: AC99.1 R70274.2
LINE1-VREFO-L: HR69.1 U6.31(LINE1-VREFO-L)
LINE1-VREFO-R: HR70.1 U6.30(LINE1-VREFO-R)
LINE2-L: AC203.2 U6.24(LINE2-L(PORT-E-L))
LINE2-L_C: AC203.1 AR15.1
LINE2-L_C_R: AR15.2 C4307.1 L122.1 R124.1
LINE2-R: AC202.2 U6.23(LINE2-R(PORT-E-R))
LINE2-R_C: AC202.1 AR14.1
LINE2-R_C_R: AR14.2 C4308.1 L123.1 R123.1
LINE2_JD: D4303.2(CATHODE) J89.4 R70262.2
LINE2_JD_R: AC97.1 R70262.1 R70264.1 U6.14(MIC2/LINE2_JD(JD2))
LINK_1000#_D: LR11.2 Q2.3(DRAIN)
LPC_0_ESPI_CLK_EC: SC72.1 SR19.2 U1.BB36(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
LPC_PME_N: ECR147.2 U104.75(GP041/IO_PME#)
LPC_PME_R_N: ECR147.1 FR10.2 U1.AV21(GPP_C23/UART2_CTS#)
LPCPD_N: SR44.1 U1.BF38(GPP_A14/SUS_STAT#/ESPI_RESET#)
LPSS_GSPI0_MOSI: SR211.2 SR230.1 U1.BE30(GPP_B18/GSPI0_MOSI)
LPSS_GSPI1_MOSI: SR228.2 SR229.1 U1.BA26(GPP_B22/GSPI1_MOSI)
M2_ WAKE: APR119.1 APR120.2 SR549.2 XDP3.15(OBSDATA_A2)
M.2_BT_PCMCLK: J218.8(PCM_CLK/I2S_SCK) R3132.1
M.2_BT_PCMCLK_R: R3132.2 U1.AV18(GPP_D8/I2S2_SCLK)
M.2_BT_PCMFRM_CRF_RST_N: J218.10(PCM_SYNC/I2S_WS) R3133.1 SR411.1 SR7932.1
M.2_BT_PCMFRM_CRF_RST_N_R: R3133.2 U1.BE16(GPP_D5/I2S2_SFRM/CNV_RF_RESET#)
M.2_BT_PCMIN: J218.12(PCM_IN/I2S_SD_IN) R3134.1
M.2_BT_PCMINR: R3134.2 U1.AW18(GPP_D7/I2S2_RXD)
M.2_BT_PCMOUT_CLKREQ0: J218.14(PCM_OUT/I2S_SD_OUT) R3135.1 SR410.2 SR7933.1
M.2_BT_PCMOUT_CLKREQ0_R: R3135.2 U1.BA17(GPP_D6/I2S2_TXD/MODEM_CLKREQ)
M_A_A0: DIMM2.144(A0) XU1.AW15(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
M_A_A1: DIMM2.133(A1) XU1.AU18(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
M_A_A2: DIMM2.132(A2) XU1.AU17(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
M_A_A3: DIMM2.131(A3) XU1.AV19(DDR0_MA[3])
M_A_A4: DIMM2.128(A4) XU1.AT19(DDR0_MA[4])
M_A_A5: DIMM2.126(A5) XU1.AU20(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
M_A_A6: DIMM2.127(A6) XU1.AV20(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
M_A_A7: DIMM2.122(A7) XU1.AU21(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
M_A_A8: DIMM2.125(A8) XU1.AT20(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
M_A_A9: DIMM2.121(A9) XU1.AT22(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
M_A_A10: DIMM2.146(A10/AP) XU1.AY14(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
M_A_A11: DIMM2.120(A11) XU1.AU22(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
M_A_A12: DIMM2.119(A12) XU1.AV22(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
M_A_A13: DIMM2.158(A13) XU1.AV12(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
M_A_A14: DIMM2.151(WE_N/A14) XU1.AV14(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
M_A_A15: DIMM2.156(CAS_N/A15) XU1.AY11(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
M_A_A16: DIMM2.152(RAS_N/A16) XU1.AW13(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
M_A_ACT#: DIMM2.114(ACT_N) XU1.AU24(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
M_A_ALERT#: DIMM2.116(ALERT_N) XU1.AT23(DDR0_ALERT#)
M_A_BA0: DIMM2.150(BA0) XU1.AY13(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
M_A_BA1: DIMM2.145(BA1) XU1.AV15(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
M_A_BG0: DIMM2.115(BG0) XU1.AW23(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
M_A_BG1: DIMM2.113(BG1) XU1.AV23(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
M_A_CKE0: DIMM2.109(CKE0) XU1.AY24(DDR0_CKE[0])
M_A_CKE1: DIMM2.110(CKE1) XU1.AW24(DDR0_CKE[1])
M_A_CLK0: DIMM2.137(CK0_T) XU1.AW18(DDR0_CKP[0])
M_A_CLK0#: DIMM2.139(CK0_C) XU1.AV18(DDR0_CKN[0])
M_A_CLK1: DIMM2.138(CK1_T/NF) XU1.AW17(DDR0_CKP[1])
M_A_CLK1#: DIMM2.140(CK1_C/NF) XU1.AY17(DDR0_CKN[1])
M_A_CS#0: DIMM2.149(CS0_N) XU1.AW12(DDR0_CS#[0])
M_A_CS#1: DIMM2.157(CS1_N) XU1.AU11(DDR0_CS#[1])
M_A_DQ0: DIMM2.3(DQ5) XU1.AE38(DDR0_DQ[0])
M_A_DQ1: DIMM2.4(DQ4) XU1.AE37(DDR0_DQ[1])
M_A_DQ2: DIMM2.17(DQ7) XU1.AG38(DDR0_DQ[2])
M_A_DQ3: DIMM2.21(DQ3) XU1.AG37(DDR0_DQ[3])
M_A_DQ4: DIMM2.8(DQ0) XU1.AE39(DDR0_DQ[4])
M_A_DQ5: DIMM2.7(DQ1) XU1.AE40(DDR0_DQ[5])
M_A_DQ6: DIMM2.20(DQ2) XU1.AG39(DDR0_DQ[6])
M_A_DQ7: DIMM2.16(DQ6) XU1.AG40(DDR0_DQ[7])
M_A_DQ8: DIMM2.29(DQ9) XU1.AJ38(DDR0_DQ[8])
M_A_DQ9: DIMM2.28(DQ8) XU1.AJ37(DDR0_DQ[9])
M_A_DQ10: DIMM2.42(DQ11) XU1.AL38(DDR0_DQ[10])
M_A_DQ11: DIMM2.38(DQ14) XU1.AL37(DDR0_DQ[11])
M_A_DQ12: DIMM2.25(DQ13) XU1.AJ40(DDR0_DQ[12])
M_A_DQ13: DIMM2.24(DQ12) XU1.AJ39(DDR0_DQ[13])
M_A_DQ14: DIMM2.41(DQ10) XU1.AL39(DDR0_DQ[14])
M_A_DQ15: DIMM2.37(DQ15) XU1.AL40(DDR0_DQ[15])
M_A_DQ16: DIMM2.45(DQ21) XU1.AN38(DDR0_DQ[16]/DDR0_DQ[32])
M_A_DQ17: DIMM2.50(DQ16) XU1.AN40(DDR0_DQ[17]/DDR0_DQ[33])
M_A_DQ18: DIMM2.63(DQ19) XU1.AR38(DDR0_DQ[18]/DDR0_DQ[34])
M_A_DQ19: DIMM2.62(DQ18) XU1.AR37(DDR0_DQ[19]/DDR0_DQ[35])
M_A_DQ20: DIMM2.46(DQ20) XU1.AN39(DDR0_DQ[20]/DDR0_DQ[36])
M_A_DQ21: DIMM2.49(DQ17) XU1.AN37(DDR0_DQ[21]/DDR0_DQ[37])
M_A_DQ22: DIMM2.58(DQ22) XU1.AR39(DDR0_DQ[22]/DDR0_DQ[38])
M_A_DQ23: DIMM2.59(DQ23) XU1.AR40(DDR0_DQ[23]/DDR0_DQ[39])
M_A_DQ24: DIMM2.71(DQ25) XU1.AW37(DDR0_DQ[24]/DDR0_DQ[40])
M_A_DQ25: DIMM2.70(DQ24) XU1.AU38(DDR0_DQ[25]/DDR0_DQ[41])
M_A_DQ26: DIMM2.79(DQ30) XU1.AV35(DDR0_DQ[26]/DDR0_DQ[42])
M_A_DQ27: DIMM2.83(DQ26) XU1.AW35(DDR0_DQ[27]/DDR0_DQ[43])
M_A_DQ28: DIMM2.66(DQ28) XU1.AU37(DDR0_DQ[28]/DDR0_DQ[44])
M_A_DQ29: DIMM2.67(DQ29) XU1.AV37(DDR0_DQ[29]/DDR0_DQ[45])
M_A_DQ30: DIMM2.84(DQ27) XU1.AT35(DDR0_DQ[30]/DDR0_DQ[46])
M_A_DQ31: DIMM2.80(DQ31) XU1.AU35(DDR0_DQ[31]/DDR0_DQ[47])
M_A_DQ32: DIMM2.173(DQ33) XU1.AY8(DDR0_DQ[32]/DDR1_DQ[0])
M_A_DQ33: DIMM2.174(DQ32) XU1.AW8(DDR0_DQ[33]/DDR1_DQ[1])
M_A_DQ34: DIMM2.186(DQ35) XU1.AV6(DDR0_DQ[34]/DDR1_DQ[2])
M_A_DQ35: DIMM2.187(DQ34) XU1.AU6(DDR0_DQ[35]/DDR1_DQ[3])
M_A_DQ36: DIMM2.170(DQ36) XU1.AU8(DDR0_DQ[36]/DDR1_DQ[4])
M_A_DQ37: DIMM2.169(DQ37) XU1.AV8(DDR0_DQ[37]/DDR1_DQ[5])
M_A_DQ38: DIMM2.182(DQ39) XU1.AW6(DDR0_DQ[38]/DDR1_DQ[6])
M_A_DQ39: DIMM2.183(DQ38) XU1.AY6(DDR0_DQ[39]/DDR1_DQ[7])
M_A_DQ40: DIMM2.190(DQ45) XU1.AY4(DDR0_DQ[40]/DDR1_DQ[8])
M_A_DQ41: DIMM2.194(DQ41) XU1.AV4(DDR0_DQ[41]/DDR1_DQ[9])
M_A_DQ42: DIMM2.208(DQ43) XU1.AT1(DDR0_DQ[42]/DDR1_DQ[10])
M_A_DQ43: DIMM2.207(DQ42) XU1.AT2(DDR0_DQ[43]/DDR1_DQ[11])
M_A_DQ44: DIMM2.191(DQ44) XU1.AV3(DDR0_DQ[44]/DDR1_DQ[12])
M_A_DQ45: DIMM2.195(DQ40) XU1.AW4(DDR0_DQ[45]/DDR1_DQ[13])
M_A_DQ46: DIMM2.204(DQ47) XU1.AT4(DDR0_DQ[46]/DDR1_DQ[14])
M_A_DQ47: DIMM2.203(DQ46) XU1.AT3(DDR0_DQ[47]/DDR1_DQ[15])
M_A_DQ48: DIMM2.215(DQ49) XU1.AP2(DDR0_DQ[48]/DDR1_DQ[32])
M_A_DQ49: DIMM2.229(DQ51) XU1.AM4(DDR0_DQ[49]/DDR1_DQ[33])
M_A_DQ50: DIMM2.212(DQ53) XU1.AP3(DDR0_DQ[50]/DDR1_DQ[34])
M_A_DQ51: DIMM2.228(DQ50) XU1.AM3(DDR0_DQ[51]/DDR1_DQ[35])
M_A_DQ52: DIMM2.216(DQ48) XU1.AP4(DDR0_DQ[52]/DDR1_DQ[36])
M_A_DQ53: DIMM2.225(DQ55) XU1.AM2(DDR0_DQ[53]/DDR1_DQ[37])
M_A_DQ54: DIMM2.211(DQ52) XU1.AP1(DDR0_DQ[54]/DDR1_DQ[38])
M_A_DQ55: DIMM2.224(DQ54) XU1.AM1(DDR0_DQ[55]/DDR1_DQ[39])
M_A_DQ56: DIMM2.233(DQ61) XU1.AK3(DDR0_DQ[56]/DDR1_DQ[40])
M_A_DQ57: DIMM2.249(DQ58) XU1.AH1(DDR0_DQ[57]/DDR1_DQ[41])
M_A_DQ58: DIMM2.236(DQ57) XU1.AK4(DDR0_DQ[58]/DDR1_DQ[42])
M_A_DQ59: DIMM2.245(DQ62) XU1.AH2(DDR0_DQ[59]/DDR1_DQ[43])
M_A_DQ60: DIMM2.250(DQ59) XU1.AH4(DDR0_DQ[60]/DDR1_DQ[44])
M_A_DQ61: DIMM2.232(DQ60) XU1.AK2(DDR0_DQ[61]/DDR1_DQ[45])
M_A_DQ62: DIMM2.246(DQ63) XU1.AH3(DDR0_DQ[62]/DDR1_DQ[46])
M_A_DQ63: DIMM2.237(DQ56) XU1.AK1(DDR0_DQ[63]/DDR1_DQ[47])
M_A_DQS0: DIMM2.13(DQS0_T) XU1.AF38(DDR0_DQSP[0])
M_A_DQS0#: DIMM2.11(DQS0_C) XU1.AF39(DDR0_DQSN[0])
M_A_DQS1: DIMM2.34(DQS1_T) XU1.AK38(DDR0_DQSP[1])
M_A_DQS1#: DIMM2.32(DQS1_C) XU1.AK39(DDR0_DQSN[1])
M_A_DQS2: DIMM2.55(DQS2_T) XU1.AP38(DDR0_DQSP[2]/DDR0_DQSP[4])
M_A_DQS2#: DIMM2.53(DQS2_C) XU1.AP39(DDR0_DQSN[2]/DDR0_DQSN[4])
M_A_DQS3: DIMM2.76(DQS3_T) XU1.AV36(DDR0_DQSP[3]/DDR0_DQSP[5])
M_A_DQS3#: DIMM2.74(DQS3_C) XU1.AU36(DDR0_DQSN[3]/DDR0_DQSN[5])
M_A_DQS4: DIMM2.179(DQS4_T) XU1.AV7(DDR0_DQSP[4]/DDR1_DQSP[0])
M_A_DQS4#: DIMM2.177(DQS4_C) XU1.AW7(DDR0_DQSN[4]/DDR1_DQSN[0])
M_A_DQS5: DIMM2.200(DQS5_T) XU1.AU2(DDR0_DQSP[5]/DDR1_DQSP[1])
M_A_DQS5#: DIMM2.198(DQS5_C) XU1.AU3(DDR0_DQSN[5]/DDR1_DQSN[1])
M_A_DQS6: DIMM2.221(DQS6_T) XU1.AN2(DDR0_DQSP[6]/DDR1_DQSP[4])
M_A_DQS6#: DIMM2.219(DQS6_C) XU1.AN3(DDR0_DQSN[6]/DDR1_DQSN[4])
M_A_DQS7: DIMM2.242(DQS7_T) XU1.AJ2(DDR0_DQSP[7]/DDR1_DQSP[5])
M_A_DQS7#: DIMM2.240(DQS7_C) XU1.AJ3(DDR0_DQSN[7]/DDR1_DQSN[5])
M_A_ODT0: DIMM2.155(ODT0) XU1.AW11(DDR0_ODT[0])
M_A_ODT1: DIMM2.161(ODT1) XU1.AU14(DDR0_ODT[1])
M_A_PAR: DIMM2.143(PARITY) XU1.AY15(DDR0_PAR)
M_B_A0: DIMM1.144(A0) XU1.AL19(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
M_B_A1: DIMM1.133(A1) XU1.AL22(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
M_B_A2: DIMM1.132(A2) XU1.AM22(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
M_B_A3: DIMM1.131(A3) XU1.AM23(DDR1_MA[3])
M_B_A4: DIMM1.128(A4) XU1.AP23(DDR1_MA[4])
M_B_A5: DIMM1.126(A5) XU1.AL23(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
M_B_A6: DIMM1.127(A6) XU1.AW26(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
M_B_A7: DIMM1.122(A7) XU1.AY26(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
M_B_A8: DIMM1.125(A8) XU1.AU26(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
M_B_A9: DIMM1.121(A9) XU1.AW27(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
M_B_A10: DIMM1.146(A10/AP) XU1.AP18(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
M_B_A11: DIMM1.120(A11) XU1.AU27(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
M_B_A12: DIMM1.119(A12) XU1.AV27(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
M_B_A13: DIMM1.158(A13) XU1.AR15(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
M_B_A14: DIMM1.151(WE_N/A14) XU1.AL17(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
M_B_A15: DIMM1.156(CAS_N/A15) XU1.AP16(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
M_B_A16: DIMM1.152(RAS_N/A16) XU1.AN18(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
M_B_ACT#: DIMM1.114(ACT_N) XU1.AU28(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
M_B_ALERT#: DIMM1.116(ALERT_N) XU1.AY25(DDR1_ALERT#)
M_B_BA0: DIMM1.150(BA0) XU1.AL18(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
M_B_BA1: DIMM1.145(BA1) XU1.AM18(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
M_B_BG0: DIMM1.115(BG0) XU1.AW28(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
M_B_BG1: DIMM1.113(BG1) XU1.AY28(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
M_B_CKE0: DIMM1.109(CKE0) XU1.AY29(DDR1_CKE[0])
M_B_CKE1: DIMM1.110(CKE1) XU1.AV29(DDR1_CKE[1])
M_B_CLK0: DIMM1.137(CK0_T) XU1.AM20(DDR1_CKP[0])
M_B_CLK0#: DIMM1.139(CK0_C) XU1.AM21(DDR1_CKN[0])
M_B_CLK1: DIMM1.138(CK1_T/NF) XU1.AP22(DDR1_CKP[1])
M_B_CLK1#: DIMM1.140(CK1_C/NF) XU1.AP21(DDR1_CKN[1])
M_B_CS#0: DIMM1.149(CS0_N) XU1.AP17(DDR1_CS#[0])
M_B_CS#1: DIMM1.157(CS1_N) XU1.AN15(DDR1_CS#[1])
M_B_DQ0: DIMM1.8(DQ0) XU1.AD34(DDR1_DQ[0]/DDR0_DQ[16])
M_B_DQ1: DIMM1.4(DQ4) XU1.AD35(DDR1_DQ[1]/DDR0_DQ[17])
M_B_DQ2: DIMM1.3(DQ5) XU1.AG35(DDR1_DQ[2]/DDR0_DQ[18])
M_B_DQ3: DIMM1.7(DQ1) XU1.AH35(DDR1_DQ[3]/DDR0_DQ[19])
M_B_DQ4: DIMM1.20(DQ2) XU1.AE35(DDR1_DQ[4]/DDR0_DQ[20])
M_B_DQ5: DIMM1.16(DQ6) XU1.AE34(DDR1_DQ[5]/DDR0_DQ[21])
M_B_DQ6: DIMM1.21(DQ3) XU1.AG34(DDR1_DQ[6]/DDR0_DQ[22])
M_B_DQ7: DIMM1.17(DQ7) XU1.AH34(DDR1_DQ[7]/DDR0_DQ[23])
M_B_DQ8: DIMM1.28(DQ8) XU1.AK35(DDR1_DQ[8]/DDR0_DQ[24])
M_B_DQ9: DIMM1.29(DQ9) XU1.AL35(DDR1_DQ[9]/DDR0_DQ[25])
M_B_DQ10: DIMM1.37(DQ15) XU1.AK32(DDR1_DQ[10]/DDR0_DQ[26])
M_B_DQ11: DIMM1.42(DQ11) XU1.AL32(DDR1_DQ[11]/DDR0_DQ[27])
M_B_DQ12: DIMM1.24(DQ12) XU1.AK34(DDR1_DQ[12]/DDR0_DQ[28])
M_B_DQ13: DIMM1.25(DQ13) XU1.AL34(DDR1_DQ[13]/DDR0_DQ[29])
M_B_DQ14: DIMM1.38(DQ14) XU1.AK31(DDR1_DQ[14]/DDR0_DQ[30])
M_B_DQ15: DIMM1.41(DQ10) XU1.AL31(DDR1_DQ[15]/DDR0_DQ[31])
M_B_DQ16: DIMM1.46(DQ20) XU1.AP35(DDR1_DQ[16]/DDR0_DQ[48])
M_B_DQ17: DIMM1.45(DQ21) XU1.AN35(DDR1_DQ[17]/DDR0_DQ[49])
M_B_DQ18: DIMM1.62(DQ18) XU1.AN32(DDR1_DQ[18]/DDR0_DQ[50])
M_B_DQ19: DIMM1.58(DQ22) XU1.AP32(DDR1_DQ[19]/DDR0_DQ[51])
M_B_DQ20: DIMM1.50(DQ16) XU1.AN34(DDR1_DQ[20]/DDR0_DQ[52])
M_B_DQ21: DIMM1.49(DQ17) XU1.AP34(DDR1_DQ[21]/DDR0_DQ[53])
M_B_DQ22: DIMM1.63(DQ19) XU1.AN31(DDR1_DQ[22]/DDR0_DQ[54])
M_B_DQ23: DIMM1.59(DQ23) XU1.AP31(DDR1_DQ[23]/DDR0_DQ[55])
M_B_DQ24: DIMM1.67(DQ29) XU1.AL29(DDR1_DQ[24]/DDR0_DQ[56])
M_B_DQ25: DIMM1.66(DQ28) XU1.AM29(DDR1_DQ[25]/DDR0_DQ[57])
M_B_DQ26: DIMM1.71(DQ25) XU1.AP29(DDR1_DQ[26]/DDR0_DQ[58])
M_B_DQ27: DIMM1.79(DQ30) XU1.AR29(DDR1_DQ[27]/DDR0_DQ[59])
M_B_DQ28: DIMM1.80(DQ31) XU1.AM28(DDR1_DQ[28]/DDR0_DQ[60])
M_B_DQ29: DIMM1.70(DQ24) XU1.AL28(DDR1_DQ[29]/DDR0_DQ[61])
M_B_DQ30: DIMM1.83(DQ26) XU1.AR28(DDR1_DQ[30]/DDR0_DQ[62])
M_B_DQ31: DIMM1.84(DQ27) XU1.AP28(DDR1_DQ[31]/DDR0_DQ[63])
M_B_DQ32: DIMM1.169(DQ37) XU1.AR12(DDR1_DQ[32]/DDR1_DQ[16])
M_B_DQ33: DIMM1.173(DQ33) XU1.AP12(DDR1_DQ[33]/DDR1_DQ[17])
M_B_DQ34: DIMM1.183(DQ38) XU1.AM13(DDR1_DQ[34]/DDR1_DQ[18])
M_B_DQ35: DIMM1.187(DQ34) XU1.AL13(DDR1_DQ[35]/DDR1_DQ[19])
M_B_DQ36: DIMM1.170(DQ36) XU1.AR13(DDR1_DQ[36]/DDR1_DQ[20])
M_B_DQ37: DIMM1.174(DQ32) XU1.AP13(DDR1_DQ[37]/DDR1_DQ[21])
M_B_DQ38: DIMM1.182(DQ39) XU1.AM12(DDR1_DQ[38]/DDR1_DQ[22])
M_B_DQ39: DIMM1.186(DQ35) XU1.AL12(DDR1_DQ[39]/DDR1_DQ[23])
M_B_DQ40: DIMM1.190(DQ45) XU1.AP10(DDR1_DQ[40]/DDR1_DQ[24])
M_B_DQ41: DIMM1.191(DQ44) XU1.AR10(DDR1_DQ[41]/DDR1_DQ[25])
M_B_DQ42: DIMM1.204(DQ47) XU1.AR7(DDR1_DQ[42]/DDR1_DQ[26])
M_B_DQ43: DIMM1.203(DQ46) XU1.AP7(DDR1_DQ[43]/DDR1_DQ[27])
M_B_DQ44: DIMM1.194(DQ41) XU1.AR9(DDR1_DQ[44]/DDR1_DQ[28])
M_B_DQ45: DIMM1.195(DQ40) XU1.AP9(DDR1_DQ[45]/DDR1_DQ[29])
M_B_DQ46: DIMM1.208(DQ43) XU1.AR6(DDR1_DQ[46]/DDR1_DQ[30])
M_B_DQ47: DIMM1.207(DQ42) XU1.AP6(DDR1_DQ[47]/DDR1_DQ[31])
M_B_DQ48: DIMM1.215(DQ49) XU1.AM10(DDR1_DQ[48])
M_B_DQ49: DIMM1.225(DQ55) XU1.AL10(DDR1_DQ[49])
M_B_DQ50: DIMM1.212(DQ53) XU1.AM7(DDR1_DQ[50])
M_B_DQ51: DIMM1.229(DQ51) XU1.AL7(DDR1_DQ[51])
M_B_DQ52: DIMM1.211(DQ52) XU1.AM9(DDR1_DQ[52])
M_B_DQ53: DIMM1.224(DQ54) XU1.AL9(DDR1_DQ[53])
M_B_DQ54: DIMM1.216(DQ48) XU1.AM6(DDR1_DQ[54])
M_B_DQ55: DIMM1.228(DQ50) XU1.AL6(DDR1_DQ[55])
M_B_DQ56: DIMM1.232(DQ60) XU1.AJ6(DDR1_DQ[56])
M_B_DQ57: DIMM1.233(DQ61) XU1.AJ7(DDR1_DQ[57])
M_B_DQ58: DIMM1.250(DQ59) XU1.AE6(DDR1_DQ[58])
M_B_DQ59: DIMM1.246(DQ63) XU1.AF7(DDR1_DQ[59])
M_B_DQ60: DIMM1.236(DQ57) XU1.AH7(DDR1_DQ[60])
M_B_DQ61: DIMM1.237(DQ56) XU1.AH6(DDR1_DQ[61])
M_B_DQ62: DIMM1.245(DQ62) XU1.AE7(DDR1_DQ[62])
M_B_DQ63: DIMM1.249(DQ58) XU1.AF6(DDR1_DQ[63])
M_B_DQS0: DIMM1.13(DQS0_T) XU1.AF35(DDR1_DQSP[0]/DDR0_DQSP[2])
