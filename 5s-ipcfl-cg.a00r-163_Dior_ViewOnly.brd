# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ37: length 55.9
  TOP w0.102: v1(117.1,98.72) 117.16,98.72 XU1.AP13
  TOP w0.127: DIMM1.174 112.63,50.04 v1(112.29,50.38)
  IN1 w0.102: 115.54,91.72 115.65,91.83 115.65,93.03 115.63,93.05 115.63,97.71 116.19,98.27 116.65,98.27 v1(117.1,98.72)
  IN1 w0.127: v1(112.29,50.38) 111.89,50.79 111.89,52.97 113.33,54.42 113.33,55.98 112.81,56.5 112.81,57.49 113.2,57.88 113.54,57.88 114.05,58.39 114.05,59.37 113.6,59.82 113.6,61.97 114.1,62.47 114.1,68.06 113.31,68.85 113.31,71.74 112.83,72.23 112.83,87.45 115.54,90.16 115.54,91.72
  BOTTOM w0.127: v1(112.29,50.38) 112.75,50.38 v2(112.98,50.15)
M_B_DQ38: length 57.7
  TOP w0.102: v1(116.25,100.61) 116.31,100.61 XU1.AM12
  TOP w0.127: v1(111.12,50.79) 110.63,50.3 DIMM1.182
  IN1 w0.102: v1(116.25,100.61) 115.86,100.61 114.78,99.53 114.78,95.91 114.17,95.31 114.17,91.89 113.82,91.53
  IN1 w0.127: v1(111.12,50.79) 110.75,51.17 110.75,57.45 110.81,57.51 110.81,58.8 110.79,58.82 110.79,60.92 111.93,62.05 111.93,62.72 111.69,62.96 111.69,65.89 110.66,66.92 110.66,67.91 110.74,67.99 110.74,71.31 110.16,71.89 110.16,78.9 111.15,79.89 111.15,88.14 113.82,90.81 113.82,91.53
  BOTTOM w0.127: v1(111.12,50.79) 110.44,51.48 v2(110.44,51.6)
M_B_DQ39: length 58.4
  TOP w0.102: XU1.AL12 116.27,101.49 v1(116.25,101.49)
  TOP w0.127: DIMM1.186 v1(109.63,50.35)
  IN1 w0.102: v1(116.25,101.49) 115.95,101.49 114.37,99.91 114.37,96.08 113.76,95.46 113.76,92.23 113.1,91.57
  IN1 w0.127: 113.1,91.57 113.1,91.45 110.39,88.73 110.39,84.61 109.4,83.62 109.4,70.32 109.88,69.84 109.88,66.13 109.97,66.04 109.97,61.16 109.14,60.34 109.14,58.16 110.37,56.94 110.37,50.62 110.1,50.35 v1(109.63,50.35)
  BOTTOM w0.127: v2(110.14,49.84) v1(109.63,50.35)
M_B_DQ40: length 60.3
  TOP w0.102: XU1.AP10 v1(113.16,100.58)
  TOP w0.127: DIMM1.190 v1(108.63,50.34)
  IN1 w0.102: 112.89,94.07 113.15,94.32 113.15,95.76 113.9,96.52 113.9,99.83 v1(113.16,100.58)
  IN1 w0.127: 112.89,94.07 112.89,92.53 108.41,88.05 108.41,71.93 107.9,71.41 107.9,70.04 108.38,69.56 108.38,66.31 109.05,65.64 109.05,61.58 108.05,60.58 108.05,57.96 108.61,57.4 108.61,55.95 108.86,55.69 108.86,53.94 108.74,53.81 108.22,53.81 108.08,53.67 108.08,53.32 108.22,53.18 108.94,53.18 109.08,53.04 109.08,52.68 108.94,52.54 108.22,52.54 108.08,52.4 108.08,52.05 108.22,51.91 108.94,51.91 109.08,51.77 109.08,50.78 v1(108.63,50.34)
  BOTTOM w0.127: v2(108.36,49.66) 108.63,49.93 v1(108.63,50.34)
M_B_DQ41: length 59.5
  TOP w0.102: XU1.AR10 113.13,98.72 v1(113.13,98.66)
  TOP w0.127: DIMM1.191 v1(108.38,55.23)
  IN1 w0.102: v1(113.13,98.66) 113.7,98.09 113.7,96.73 112.94,95.97 112.94,94.6 112.66,94.32
  IN1 w0.127: v1(108.38,55.23) 108.08,55.54 108.08,57.39 107.14,58.33 107.14,60.37 107.85,61.08 107.85,69.55 107.49,69.91 107.49,72.41 107.06,72.84 107.06,73.27 107.2,73.41 107.89,73.41 108.03,73.55 108.03,73.91 107.89,74.05 107.2,74.05 107.06,74.19 107.06,74.54 107.2,74.68 107.89,74.68 108.03,74.82 108.03,75.18 107.89,75.32 107.2,75.32 107.06,75.46 107.06,75.81 107.2,75.95 107.89,75.95 108.03,76.09 108.03,76.45 107.89,76.59 107.2,76.59 107.06,76.73 107.06,77.08 107.2,77.22 107.89,77.22 108.03,77.36 108.03,77.72 107.89,77.86 107.2,77.86 107.06,78 107.06,78.35 107.2,78.49 107.89,78.49 108.03,78.63 108.03,78.99 107.89,79.13 107.2,79.13 107.06,79.27 107.06,79.62 107.2,79.76 107.89,79.76 108.03,79.9 108.03,88.28 112.66,92.91 112.66,94.32
  BOTTOM w0.127: v1(108.38,55.23) v2(108.92,54.7)
M_B_DQ42: length 57.5
  TOP w0.102: XU1.AR7 110.32,98.79 v1(110.32,98.72)
  TOP w0.127: DIMM1.204 105.13,50.75 v1(104.96,50.93)
  IN1 w0.102: 108.96,94.02 109.89,94.95 109.89,97.97 110.32,98.4 v1(110.32,98.72)
  IN1 w0.127: v1(104.96,50.93) 104.96,52 105.1,52.14 105.27,52.14 105.41,52.28 105.41,52.64 105.27,52.78 104.26,52.78 104.07,52.97 104.07,53.46 104.22,53.61 104.87,53.61 105.82,54.55 105.82,56.73 104.6,57.95 104.6,66.47 103.94,67.13 103.94,71.5 104.75,72.3 104.75,90.01 108.76,94.02 108.96,94.02
  BOTTOM w0.127: v2(105.21,51.93) 104.96,51.69 v1(104.96,50.93)
M_B_DQ43: length 58.3
  TOP w0.102: v1(110.4,99.57) 110.4,99.63 XU1.AP7
  TOP w0.127: DIMM1.203 v1(105.38,56.02)
  IN1 w0.102: 108.93,95.99 108.93,97.83 109.3,98.21 109.52,98.21 109.89,98.58 109.89,99.07 v1(110.4,99.57)
  IN1 w0.127: 108.93,95.99 108.93,95.89 108.69,95.65 108.69,94.4 106.21,91.93 105.86,91.93 104.37,90.44 104.37,81.43 104.23,81.29 103.8,81.29 103.66,81.15 103.66,80.8 103.8,80.66 104.23,80.66 104.37,80.52 104.37,80.16 104.23,80.02 103.8,80.02 103.66,79.88 103.66,79.53 103.8,79.39 104.23,79.39 104.37,79.25 104.37,78.89 104.23,78.75 103.8,78.75 103.66,78.61 103.66,78.26 103.8,78.12 104.23,78.12 104.37,77.98 104.37,77.62 104.23,77.48 103.8,77.48 103.66,77.34 103.66,76.99 103.8,76.85 104.23,76.85 104.37,76.71 104.37,76.35 104.23,76.21 103.8,76.21 103.66,76.07 103.66,75.72 103.8,75.58 104.23,75.58 104.37,75.44 104.37,75.08 104.23,74.94 103.8,74.94 103.66,74.8 103.66,74.45 103.8,74.31 104.23,74.31 104.37,74.17 104.37,73.81 104.23,73.67 103.8,73.67 103.66,73.53 103.66,73.18 103.8,73.04 104.23,73.04 104.37,72.9 104.37,72.46 103.56,71.66 103.56,68.82 102.94,68.2 102.94,67.19 103.68,66.45 103.68,61.86 104.19,61.35 104.19,57.6 105.38,56.41 v1(105.38,56.02)
  BOTTOM w0.127: v2(105.38,56.75) v1(105.38,56.02)
M_B_DQ44: length 58.6
  TOP w0.102: XU1.AR9 112.22,98.72 v1(112.29,98.72)
  TOP w0.127: DIMM1.194 v1(107.63,47.79)
  IN1 w0.102: 112.36,94.5 112.71,94.85 112.71,96.03 113.5,96.81 113.5,97.98 113.25,98.22 112.79,98.22 v1(112.29,98.72)
  IN1 w0.127: 112.36,94.5 112.36,93.15 107.65,88.44 107.65,80.79 106.56,79.71 106.56,66.21 107.47,65.31 107.47,61.66 106.75,60.95 106.75,58.16 107.64,57.28 107.64,54.14 107.35,53.85 107.35,48.08 v1(107.63,47.79)
  BOTTOM w0.127: v2(106.92,47.79) v1(107.63,47.79)
M_B_DQ45: length 60
  TOP w0.102: v1(112.22,99.57) 112.22,99.64 XU1.AP9
  TOP w0.127: DIMM1.195 107.38,56.07 v1(107.21,55.9)
  IN1 w0.102: 111.82,94.8 111.82,99.17 v1(112.22,99.57)
  IN1 w0.127: v1(107.21,55.9) 107.21,57.17 106.37,58.01 106.37,62.22 106.48,62.32 106.48,63.24 106.18,63.53 106.18,79.86 107.27,80.95 107.27,81.39 107.13,81.53 106.21,81.53 106.07,81.66 106.07,82.02 106.21,82.16 107.13,82.16 107.27,82.3 107.27,82.66 107.13,82.8 106.21,82.8 106.07,82.93 106.07,83.29 106.21,83.43 107.13,83.43 107.27,83.57 107.27,83.93 107.13,84.07 106.21,84.07 106.07,84.2 106.07,84.56 106.21,84.7 107.13,84.7 107.27,84.84 107.27,85.2 107.13,85.34 106.21,85.34 106.07,85.47 106.07,85.83 106.21,85.97 107.13,85.97 107.27,86.11 107.27,86.47 107.13,86.61 106.21,86.61 106.07,86.74 106.07,87.1 106.21,87.24 107.13,87.24 107.27,87.38 107.27,88.6 111.82,93.16 111.82,94.8
  BOTTOM w0.127: v2(107.21,56.66) v1(107.21,55.9)
M_B_DQ46: length 56.3
  TOP w0.102: XU1.AR6 109.02,99.18 v1(109.46,98.74)
  TOP w0.127: DIMM1.208 v1(104.13,50.34)
  IN1 w0.102: 108.42,95.79 108.73,96.1 108.73,97.95 109.46,98.69 v1(109.46,98.74)
  IN1 w0.127: v1(104.13,50.34) 103.69,50.78 103.69,53.62 104.81,54.74 104.81,56.44 103.81,57.44 103.81,61.19 103.3,61.7 103.3,66.29 102.56,67.03 102.56,68.36 103.18,68.98 103.18,81.22 103.99,82.02 103.99,90.92 105.76,92.7 106.53,92.7 107.21,93.39 107.21,94.33 107.49,94.6 108.08,94.6 108.42,94.95 108.42,95.79
  BOTTOM w0.127: v2(104.13,49.57) v1(104.13,50.34)
M_B_DQ47: length 57.9
  TOP w0.102: v1(109.48,99.57) 109.48,99.63 XU1.AP6
  TOP w0.127: DIMM1.207 104.38,55.93 v1(104.38,55.92)
  IN1 w0.102: 106.96,94.57 107.19,94.8 107.19,95.29 107.42,95.52 107.97,95.52 108.14,95.69 108.14,96.12 108.52,96.5 108.52,98.05 109.01,98.54 109.01,99.09 v1(109.48,99.57)
  IN1 w0.127: v1(104.38,55.92) 104.38,56.24 102.82,57.8 102.82,66.23 101.94,67.11 101.94,71.66 102.17,71.88 102.6,71.88 102.8,72.08 102.8,82.14 102.94,82.28 103.47,82.28 103.61,82.42 103.61,82.78 103.47,82.92 102.94,82.92 102.8,83.06 102.8,83.41 102.94,83.55 103.47,83.55 103.61,83.69 103.61,84.05 103.47,84.19 102.94,84.19 102.8,84.33 102.8,84.68 102.94,84.82 103.47,84.82 103.61,84.96 103.61,85.32 103.47,85.46 102.94,85.46 102.8,85.6 102.8,85.95 102.94,86.09 103.47,86.09 103.61,86.23 103.61,86.59 103.47,86.73 102.94,86.73 102.8,86.87 102.8,87.22 102.94,87.36 103.47,87.36 103.61,87.5 103.61,87.86 103.47,88 102.94,88 102.8,88.14 102.8,88.47 103.61,89.27 103.61,91.5 106.68,94.57 106.96,94.57
  BOTTOM w0.127: v2(104.09,56.67) 104.38,56.38 v1(104.38,55.92)
M_B_DQ48: length 69.8
  TOP w0.102: v1(113.1,101.45) 113.1,101.5 XU1.AM10
  TOP w0.127: v1(102.25,58.58) 102.38,58.44 DIMM1.215
  IN1 w0.102: 108.09,98.71 108.09,98.82 109.25,99.99 112.2,99.99 112.67,100.46 112.67,101.02 v1(113.1,101.45)
  IN1 w0.127: 108.09,98.71 108.09,96.71 107.81,96.43 107.49,96.43 107.18,96.12 107.18,95.8 106.89,95.51 105.58,95.51 105.26,95.19 105.26,93.97 103.07,91.79 103.07,89.49 102.27,88.69 102.27,86.86 102.13,86.72 101.59,86.72 101.45,86.58 101.45,86.22 101.59,86.08 102.13,86.08 102.27,85.94 102.27,85.59 102.13,85.45 101.59,85.45 101.45,85.31 101.45,84.95 101.59,84.81 102.13,84.81 102.27,84.67 102.27,84.32 102.13,84.18 101.59,84.18 101.45,84.04 101.45,83.68 101.59,83.54 102.13,83.54 102.27,83.4 102.27,83.05 102.13,82.91 101.59,82.91 101.45,82.77 101.45,82.41 101.59,82.27 102.13,82.27 102.27,82.13 102.27,81.78 102.13,81.64 101.59,81.64 101.45,81.5 101.45,81.14 101.59,81 102.13,81 102.27,80.86 102.27,80.51 102.13,80.37 101.59,80.37 101.45,80.23 101.45,79.87 101.59,79.73 102.13,79.73 102.27,79.59 102.27,79.24 102.13,79.1 101.59,79.1 101.45,78.96 101.45,78.6 101.59,78.46 102.13,78.46 102.27,78.32 102.27,77.97 102.13,77.83 101.59,77.83 101.45,77.69 101.45,77.33 101.59,77.19 102.13,77.19 102.27,77.05 102.27,76.7 102.13,76.56 101.59,76.56 101.45,76.42 101.45,76.06 101.59,75.92 102.13,75.92 102.27,75.78 102.27,75.43 102.13,75.29 101.59,75.29 101.45,75.15 101.45,74.79 101.59,74.65 102.13,74.65 102.27,74.51 102.27,74.16 102.13,74.02 101.59,74.02 101.45,73.88 101.45,73.52 101.59,73.38 102.13,73.38 102.27,73.24 102.27,72.74 101.41,71.88 101.41,69.24 100.29,68.12 100.29,67.04 100.79,66.54 101.76,66.54 102.28,66.01 102.28,63.79 101.9,63.41 101.9,59.91 102.28,59.53 102.28,58.61 v1(102.25,58.58)
  BOTTOM w0.127: v1(102.25,58.58) v2(102.25,57.83)
M_B_DQ49: length 71.4
  TOP w0.102: XU1.AL10 v1(113.14,103.29)
  TOP w0.127: DIMM1.225 99.88,55.27 v1(99.92,55.23)
  IN1 w0.102: 105.49,100.12 106.93,100.12 109.25,102.45 110.51,102.45 110.8,102.74 111.86,102.74 111.96,102.84 112.68,102.84 113.01,103.17
  IN1 w0.127: 105.49,100.12 103.81,100.12 101.88,98.2 101.88,95.26 98.97,92.36 98.97,79.85 98.83,79.71 98.08,79.71 97.94,79.57 97.94,79.21 98.08,79.07 98.83,79.07 98.97,78.93 98.97,78.58 98.83,78.44 96.66,78.44 96.52,78.3 96.52,77.94 96.66,77.8 98.83,77.8 98.97,77.66 98.97,77.35 98.68,77.05 96.85,77.05 96.44,76.65 96.44,66.57 97.43,65.58 97.43,61.41 98.39,60.45 98.39,58.07 100.25,56.21 100.25,55.57 v1(99.92,55.23) ; v1(113.14,103.29) 113.01,103.17
  BOTTOM w0.127: v1(99.92,55.23) v2(100.65,54.51)
M_B_DQ50: length 68.4
  TOP w0.102: v1(110.36,101.46) 110.36,101.5 XU1.AM7
  TOP w0.127: DIMM1.212 v1(103.13,47.81)
  IN1 w0.102: 105.45,97.37 106.86,97.37 107.38,97.89 107.38,98.82 108.98,100.42 108.98,100.7 109.31,101.04 109.93,101.04 v1(110.36,101.46)
  IN1 w0.127: 105.45,97.37 105.15,97.37 104.27,96.48 104.27,95.28 100.65,91.66 100.65,69.56 100.14,69.05 99.19,69.05 98.96,68.82 98.96,67.1 99.46,66.59 99.46,62.02 100.61,60.87 100.61,58.66 102.6,56.67 102.6,54.97 102.74,54.83 103.46,54.83 103.63,54.67 103.63,54.31 103.52,54.2 102.74,54.2 102.6,54.06 102.6,53.7 102.74,53.56 103.01,53.56 103.15,53.42 103.15,53.07 103.01,52.93 102.74,52.93 102.6,52.79 102.6,52.43 102.74,52.29 103.01,52.29 103.15,52.15 103.15,51.8 103.01,51.66 102.74,51.66 102.6,51.52 102.6,50.88 103.71,49.77 103.71,48.38 v1(103.13,47.81)
  BOTTOM w0.127: v2(103.85,47.81) v1(103.13,47.81)
M_B_DQ51: length 69.8
  TOP w0.102: XU1.AL7 110.33,103.23 v1(110.33,103.29)
  TOP w0.127: DIMM1.229 v1(98.88,56.01)
  IN1 w0.102: v1(110.33,103.29) 109.9,102.85 108.98,102.85 107.94,101.81 104.66,101.81 104.48,101.64
  IN1 w0.127: 104.48,101.64 104.43,101.58 104.43,101.29 104.09,100.95 103.65,100.95 103.37,100.67 103.14,100.67 101.12,98.64 101.12,95.58 98.21,92.67 98.21,91.57 98.07,91.43 97.72,91.43 97.59,91.29 97.59,90.93 97.72,90.79 98.07,90.79 98.21,90.65 98.21,90.3 98.07,90.16 97.72,90.16 97.59,90.02 97.59,89.66 97.72,89.52 98.07,89.52 98.21,89.38 98.21,89.03 98.07,88.89 97.72,88.89 97.59,88.75 97.59,88.39 97.72,88.25 98.07,88.25 98.21,88.11 98.21,87.76 98.07,87.62 97.72,87.62 97.59,87.48 97.59,87.12 97.72,86.98 98.07,86.98 98.21,86.84 98.21,86.49 98.07,86.35 97.72,86.35 97.59,86.21 97.59,85.85 97.72,85.71 98.07,85.71 98.21,85.57 98.21,85.22 98.07,85.08 97.72,85.08 97.59,84.94 97.59,84.58 97.72,84.44 98.07,84.44 98.21,84.3 98.21,83.95 98.07,83.81 97.72,83.81 97.59,83.67 97.59,83.31 97.72,83.17 98.07,83.17 98.21,83.03 98.21,82.68 98.07,82.54 97.72,82.54 97.59,82.4 97.59,82.04 97.72,81.9 98.07,81.9 98.21,81.76 98.21,81.07 95.68,78.54 95.68,65.83 95.95,65.57 96.36,65.57 96.67,65.26 96.67,64.76 96.53,64.62 95.82,64.62 95.68,64.48 95.68,64.12 95.82,63.98 96.53,63.98 96.67,63.85 96.67,61.08 97.56,60.19 97.56,59.63 97.1,59.18 97.1,58.24 98.88,56.45 v1(98.88,56.01)
  BOTTOM w0.127: v1(98.88,56.01) v2(99.41,56.53)
M_B_DQ52: length 69.6
  TOP w0.102: v1(112.19,101.45) 112.19,101.5 XU1.AM9
  TOP w0.127: DIMM1.211 103.38,56.02 v1(103.39,56.02)
  IN1 w0.102: 107.66,97.6 107.66,98.68 109.17,100.19 111.47,100.19 111.72,100.44 111.72,100.98 v1(112.19,101.45)
  IN1 w0.127: 107.66,97.6 107.15,97.09 107.15,96.73 106.82,96.4 105.65,96.4 105.33,96.08 105.33,95.81 101.03,91.5 101.03,90.63 101.17,90.49 102.58,90.49 102.69,90.38 102.69,90.02 102.53,89.86 101.17,89.86 101.03,89.72 101.03,89.36 101.17,89.22 101.71,89.22 101.85,89.08 101.85,88.73 101.71,88.59 101.17,88.59 101.03,88.45 101.03,88.09 101.17,87.95 101.71,87.95 101.85,87.81 101.85,87.46 101.71,87.32 101.17,87.32 101.03,87.18 101.03,69.4 99.91,68.27 99.91,66.88 100.35,66.43 100.35,66 100.49,65.86 101.76,65.86 101.9,65.72 101.9,65.36 101.76,65.22 100.49,65.22 100.35,65.08 100.35,64.73 100.49,64.59 101.76,64.59 101.9,64.45 101.9,64.09 101.76,63.95 100.49,63.95 100.35,63.81 100.35,63.23 100.49,63.09 101.28,63.09 101.42,62.95 101.42,62.6 101.28,62.46 100.49,62.46 100.35,62.32 100.35,61.67 100.99,61.03 100.99,58.82 102.98,56.83 102.98,56.43 v1(103.39,56.02)
  BOTTOM w0.127: v2(102.64,56.02) v1(103.39,56.02)
M_B_DQ53: length 70.7
  TOP w0.102: v1(112.2,103.27) XU1.AL9
  TOP w0.127: DIMM1.224 v1(100.13,50.34)
  IN1 w0.102: 104.76,100.92 104.81,100.98 107.41,100.98 109.08,102.65 110.4,102.65 110.69,102.94 111.5,102.94 111.83,103.27 v1(112.2,103.27)
  IN1 w0.127: v1(100.13,50.34) 100.57,50.77 100.57,51.4 100.7,51.54 101.2,51.54 101.34,51.68 101.34,52.04 101.2,52.18 100.7,52.18 100.57,52.32 100.57,52.67 100.7,52.81 101.2,52.81 101.34,52.95 101.34,53.31 101.2,53.45 100.7,53.45 100.57,53.59 100.57,54.03 100.43,54.17 99.52,54.17 99.32,54.37 99.32,56.6 98,57.91 98,60.28 97.05,61.23 97.05,65.42 96.06,66.41 96.06,78.38 98.59,80.91 98.59,92.51 101.5,95.42 101.5,98.35 103.69,100.55 104.39,100.55 104.76,100.92
  BOTTOM w0.127: v2(100.77,50.68) 100.47,50.68 v1(100.13,50.34)
M_B_DQ54: length 67.6
  TOP w0.102: v1(109.49,101.51) 109.44,101.51 XU1.AM6
  TOP w0.127: DIMM1.216 v1(102.13,50.34)
  IN1 w0.102: 104.65,98.12 104.76,98.23 106.91,98.23 107.18,98.5 107.18,98.92 107.61,99.35 107.61,99.62 v1(109.49,101.51)
  IN1 w0.127: v1(102.13,50.34) 101.68,50.79 101.68,51.15 102.22,51.69 102.22,53.95 102.08,54.09 101.76,54.09 101.62,54.23 101.62,54.59 101.76,54.73 102.08,54.73 102.22,54.87 102.22,56.52 100.23,58.51 100.23,60.59 99.08,61.74 99.08,66.43 98.58,66.94 98.58,68.49 98.35,68.72 97.94,68.72 97.74,68.92 97.74,69.28 97.95,69.49 99.73,69.49 99.87,69.63 99.87,69.99 99.73,70.13 98.31,70.13 98.14,70.29 98.14,71.54 98.32,71.72 99.97,71.72 100.27,72.01 100.27,91.82 103.78,95.34 103.78,96.64 104.53,97.39 104.53,98 104.65,98.12
  BOTTOM w0.127: v2(102.13,49.55) v1(102.13,50.34)
M_B_DQ55: length 69.1
  TOP w0.102: v1(109.47,103.29) 109.21,103.03 109.21,103.03 XU1.AL6
  TOP w0.127: DIMM1.228 v1(99.13,47.79)
  IN1 w0.102: v1(109.47,103.29) 109.11,103.29 107.84,102.02 104.41,102.02
  IN1 w0.127: 104.41,102.02 103.44,102.02 102.83,101.41 102.83,101 100.73,98.9 100.73,95.74 97.2,92.21 97.2,80.6 95.3,78.7 95.3,64.5 95.04,64.24 95.04,62.36 96.06,61.34 96.06,58.62 98.37,56.31 98.37,54.77 99.55,53.59 99.55,51.11 99.03,50.59 99.03,50.1 99.13,50 v1(99.13,47.79)
  BOTTOM w0.127: v1(99.13,47.79) v2(99.9,47.79)
M_B_DQ56: length 77.1
  TOP w0.102: XU1.AJ6 v1(108.55,104.2)
  TOP w0.127: DIMM1.232 v1(98.13,50.34)
  IN1 w0.102: v1(108.55,104.2) 108.11,103.76 104.76,103.76
  IN1 w0.127: 104.76,103.76 104.38,103.38 104.38,103.23 103.93,102.78 103.32,102.78 99.82,99.28 99.82,96.12 95.48,91.77 95.48,81.83 95.65,81.66 96.15,81.66 96.29,81.52 96.29,81.16 96.15,81.02 94.49,81.02 94.35,80.88 94.35,80.53 94.49,80.39 95.06,80.39 95.2,80.25 95.2,79.89 95.06,79.75 94.49,79.75 94.35,79.61 94.35,68.74 93.06,67.46 93.06,61.74 93.22,61.58 93.52,61.58 93.89,61.96 94.11,61.96 94.36,61.71 94.36,61.53 93.84,61.01 93.84,60.81 94.09,60.56 94.29,60.56 94.61,60.88 94.81,60.88 95.06,60.63 95.06,60.43 94.74,60.11 94.74,59.91 95.07,59.58 95.07,58.32 97.38,56 97.38,54.38 97.52,54.24 98.13,54.24 98.27,54.1 98.27,53.74 98.13,53.6 97.52,53.6 97.38,53.46 97.38,52.57 97.68,52.27 97.88,52.27 98.51,52.89 98.71,52.89 98.96,52.64 98.96,52.44 98.33,51.82 98.33,51.62 98.53,51.42 98.53,50.98 98.45,50.9 98.45,50.65 v1(98.13,50.34)
  BOTTOM w0.127: v2(97.42,50.34) v1(98.13,50.34)
M_B_DQ57: length 78.1
  TOP w0.102: v1(110.39,105.12) 110.16,104.9 110.16,104.89 XU1.AJ7
  TOP w0.127: v1(97.84,55.06) 97.88,55.1 DIMM1.233
  IN1 w0.102: v1(110.39,105.12) 109.97,104.7 109.97,104.11 109.62,103.76 108.85,103.76 107.94,102.86 104.72,102.86
  IN1 w0.127: v1(97.84,55.06) 97.84,56.09 95.45,58.47 95.45,61.19 94.03,62.62 94.03,64.45 94.17,64.59 94.6,64.59 94.74,64.73 94.74,65.08 94.6,65.22 93.84,65.22 93.72,65.34 93.72,65.69 93.89,65.86 94.6,65.86 94.74,66 94.74,66.35 94.6,66.49 94.17,66.49 94.03,66.63 94.03,67.88 94.73,68.59 94.73,78.88 96.67,80.82 96.67,82.09 96.53,82.23 96,82.23 95.86,82.37 95.86,82.72 96,82.86 96.53,82.86 96.67,83 96.67,83.36 96.53,83.5 96,83.5 95.86,83.64 95.86,83.99 96,84.13 96.53,84.13 96.67,84.27 96.67,84.63 96.53,84.77 96,84.77 95.86,84.91 95.86,85.26 96,85.4 96.53,85.4 96.67,85.54 96.67,85.9 96.53,86.04 96,86.04 95.86,86.18 95.86,86.53 96,86.67 96.53,86.67 96.67,86.81 96.67,87.17 96.53,87.31 96,87.31 95.86,87.45 95.86,87.8 96,87.94 96.53,87.94 96.67,88.08 96.67,88.44 96.53,88.58 96,88.58 95.86,88.72 95.86,89.07 96,89.21 96.53,89.21 96.67,89.35 96.67,89.71 96.53,89.85 96,89.85 95.86,89.99 95.86,90.34 96,90.48 96.53,90.48 96.67,90.62 96.67,90.98 96.53,91.12 96,91.12 95.86,91.26 95.86,91.61 96,91.75 96.53,91.75 96.67,91.89 96.67,92.43 100.2,95.96 100.2,99.12 103.53,102.45 104.31,102.45 104.72,102.86
  BOTTOM w0.127: v2(97.84,54.24) v1(97.84,55.06)
M_B_DQ58: length 79.4
  TOP w0.102: v1(108.51,107.86) 108.56,107.86 XU1.AE6
  TOP w0.127: v1(93.78,50.41) 93.63,50.27 DIMM1.250
  IN1 w0.127: v1(108.51,107.86) 108.11,107.45 105.5,107.45 104.89,108.06 103.2,108.06 99.22,104.08 99.22,103.3 91.53,95.61 91.53,77.17 90.68,76.32 90.68,69.06 90.24,68.63 90.24,67.37 88.86,65.98 88.86,64.42 89.89,63.38 89.89,55.7 92.18,53.41 92.65,53.41 94,54.76 94.2,54.76 94.45,54.51 94.45,54.31 93.27,53.13 93.27,52.32 94.23,51.35 94.23,50.87 v1(93.78,50.41)
  BOTTOM w0.127: v1(93.78,50.41) 94.26,50.89 v2(94.26,51.73)
M_B_DQ59: length 79.8
  TOP w0.102: v1(110.39,107.86) 110.39,107.86 XU1.AF7
  TOP w0.127: v1(94.63,47.82) 94.63,47.83 DIMM1.246
  IN1 w0.127: v1(110.39,107.86) 109.7,108.55 103.1,108.55 98.84,104.29 98.84,103.46 90.73,95.35 90.73,77.33 89.43,76.03 89.43,73.5 89.68,73.25 89.68,67.35 88.47,66.14 88.47,64.26 89.51,63.23 89.51,55.54 92.4,52.64 92.4,50.05 v1(94.63,47.82)
  BOTTOM w0.127: v2(95.25,48.17) 94.9,47.82 v1(94.63,47.82)
M_B_DQ60: length 78.7
  TOP w0.102: XU1.AH7 109.94,105.62 v1(110.35,106.03)
  TOP w0.127: DIMM1.236 v1(97.13,47.82)
  IN1 w0.102: v1(110.35,106.03) 109.9,105.58 109.9,104.98 109.55,104.63 104.78,104.63 104.48,104.34 104.48,104.05 104.2,103.77 103.76,103.77 103.69,103.85
  IN1 w0.127: 103.69,103.85 103.06,103.85 102.06,102.84 102.06,102.06 99.44,99.44 99.44,96.27 95.1,91.93 95.1,82.17 93.97,81.04 93.97,72.8 93.23,72.06 93.23,68.16 92.68,67.62 92.68,61.36 93.95,60.09 93.95,58.89 97,55.85 97,53.47 96.86,53.33 96.24,53.33 96.11,53.21 96.11,52.83 96.24,52.7 96.86,52.7 97,52.56 97,52.24 97.66,51.58 97.66,50.01 97.8,49.88 98.41,49.88 98.55,49.74 98.55,49.38 98.41,49.24 97.8,49.24 97.66,49.1 97.66,48.76 97.84,48.58 98.4,48.58 98.55,48.43 98.55,48 98.38,47.82 v1(97.13,47.82)
  BOTTOM w0.127: v1(97.13,47.82) v2(97.85,47.82)
M_B_DQ61: length 77.6
  TOP w0.102: XU1.AH6 v1(109.46,105.14)
  TOP w0.127: v1(96.49,55.74) 96.88,56.13 DIMM1.237
  IN1 w0.102: v1(109.46,105.14) 109.06,105.54 104.73,105.54 104.49,105.3
  IN1 w0.127: v1(96.49,55.74) 95.99,56.25 93.57,58.67 93.57,59.93 92.3,61.2 92.3,67.78 92.85,68.32 92.85,72.22 93.59,72.96 93.59,81.2 94.72,82.33 94.72,82.71 94.58,82.85 93.79,82.85 93.65,82.99 93.65,83.34 93.79,83.48 94.58,83.48 94.72,83.62 94.72,83.98 94.58,84.12 93.79,84.12 93.65,84.26 93.65,84.61 93.79,84.75 94.58,84.75 94.72,84.89 94.72,85.25 94.58,85.39 93.79,85.39 93.65,85.53 93.65,85.88 93.79,86.02 94.58,86.02 94.72,86.16 94.72,86.52 94.58,86.66 93.79,86.66 93.65,86.8 93.65,87.15 93.79,87.29 94.58,87.29 94.72,87.43 94.72,87.79 94.58,87.93 93.79,87.93 93.65,88.07 93.65,88.42 93.79,88.56 94.58,88.56 94.72,88.7 94.72,89.06 94.58,89.2 93.79,89.2 93.65,89.34 93.65,89.69 93.79,89.83 94.58,89.83 94.72,89.97 94.72,90.33 94.58,90.47 93.79,90.47 93.65,90.61 93.65,90.96 93.79,91.1 94.58,91.1 94.72,91.24 94.72,92.09 99.06,96.43 99.06,99.81 101.54,102.3 101.54,102.86 103.39,104.71 103.98,104.71 104.38,105.11 104.38,105.19 104.49,105.3
  BOTTOM w0.127: v1(96.49,55.74) v2(97.01,56.26)
M_B_DQ62: length 80.9
  TOP w0.102: v1(109.5,107.86) 109.5,107.89 XU1.AE7
  TOP w0.127: DIMM1.245 94.88,56.34 94.66,56.12 v1(94.66,55.74)
  IN1 w0.102: 108.92,106.74 108.92,107.28 v1(109.5,107.86)
  IN1 w0.127: v1(94.66,55.74) 91.01,59.4 91.01,68.31 91.55,68.86 91.55,72.75 92.29,73.49 92.29,91.5 93.18,92.39 93.18,92.59 92.44,93.33 92.44,93.52 92.69,93.78 92.89,93.78 93.63,93.03 93.83,93.03 94.08,93.29 94.08,93.48 93.75,93.82 93.34,94.23 93.34,94.42 93.59,94.67 93.79,94.67 94.53,93.93 94.73,93.93 94.98,94.18 94.98,94.38 94.24,95.12 94.24,95.32 94.49,95.57 94.69,95.57 95.43,94.83 95.63,94.83 95.88,95.08 95.88,95.28 95.14,96.02 95.14,96.22 95.39,96.47 95.58,96.47 96.33,95.73 96.52,95.73 96.78,95.98 96.78,96.18 96.03,96.92 96.03,97.12 96.29,97.37 96.48,97.37 97.22,96.63 97.42,96.63 97.76,96.97 97.76,100.55 100.23,103.01 100.23,104.01 102.99,106.77 104.36,106.77 104.44,106.86 106.68,106.86 107.28,106.26 108.45,106.26 108.92,106.74
  BOTTOM w0.127: v2(93.34,54.85) 94.23,55.74 v1(94.66,55.74)
M_B_DQ63: length 79.2
  TOP w0.102: XU1.AF6 108.57,106.96 v1(108.5,106.96)
  TOP w0.127: DIMM1.249 93.88,56.33 93.67,56.12 v1(93.67,55.8)
  IN1 w0.127: v1(93.67,55.8) 93.67,55.9 90.63,58.94 90.63,61.23 90.35,61.51 90.35,62.25 90.63,62.52 90.63,63.19 89.24,64.57 89.24,65.82 90.63,67.21 90.63,68.47 91.17,69.01 91.17,72.91 91.91,73.65 91.91,95.26 92.37,95.71 92.56,95.71 93.24,95.03 93.44,95.03 93.69,95.28 93.69,95.48 93.01,96.16 93.01,96.36 93.26,96.61 93.46,96.61 94.14,95.93 94.34,95.93 94.59,96.18 94.59,96.38 93.91,97.06 93.91,97.26 94.16,97.51 94.36,97.51 95.04,96.83 95.24,96.83 95.49,97.08 95.49,97.28 94.81,97.96 94.81,98.15 95.06,98.4 95.26,98.4 95.94,97.73 96.13,97.73 96.39,97.98 96.39,98.18 95.71,98.85 95.71,99.05 95.96,99.3 96.16,99.3 96.84,98.62 97.03,98.62 97.28,98.88 97.28,99.07 96.61,99.75 96.61,99.95 99.6,102.94 99.6,103.92 102.7,107.03 104.29,107.03 104.35,107.08 106.83,107.08 107.43,106.49 108.03,106.49 v1(108.5,106.96)
  BOTTOM w0.127: v2(94.39,56.44) 94.31,56.44 v1(93.67,55.8)
M_B_DQS0: length 75.5
  TOP w0.127: DIMM1.13 154.88,55.93 v1(154.8,55.84) ; XU1.AF35 137.32,106.08 v1(137.32,106.01)
  IN1 w0.102: v1(137.32,106.01) 137.32,106.29 137.42,106.39 141.3,106.39 141.48,106.21 143.07,106.21 143.64,106.79 143.92,106.79 143.93,106.77
  IN1 w0.127: v1(154.8,55.84) 155.89,56.94 156.9,56.94 158.89,58.93 158.89,63.13 157.61,64.42 157.55,64.47 157.55,65.92 158.7,67.06 158.7,69.69 157.96,70.42 157.96,72.72 156.92,73.77 156.92,83.47 156.78,83.61 156.25,83.61 155.98,83.88 155.98,84.42 156.25,84.7 156.78,84.7 156.92,84.84 156.92,85.19 156.78,85.33 156.25,85.33 155.98,85.61 155.98,86.15 156.25,86.42 156.78,86.42 156.92,86.56 156.92,86.92 156.78,87.06 156.25,87.06 155.98,87.33 155.98,87.88 156.25,88.15 156.78,88.15 156.92,88.29 156.92,88.65 156.78,88.79 156.25,88.79 155.98,89.06 155.98,89.61 156.25,89.88 156.78,89.88 156.92,90.02 156.92,94.17 144.31,106.77 143.93,106.77
M_B_DQS0#: length 75.6
  TOP w0.127: DIMM1.11 155.38,56.02 v1(155.56,55.84) ; v1(137.26,106.91) 137.24,106.91 XU1.AF34
  IN1 w0.102: v1(137.26,106.91) 137.58,106.59 141.39,106.59 141.56,106.42 142.99,106.42 143.57,107 143.93,107
  IN1 w0.127: 143.93,107 144.41,107 157.15,94.26 157.15,89.92 156.87,89.65 156.35,89.65 156.21,89.51 156.21,89.16 156.35,89.02 156.87,89.02 157.15,88.74 157.15,88.2 156.87,87.92 156.35,87.92 156.21,87.78 156.21,87.43 156.35,87.29 156.87,87.29 157.15,87.01 157.15,86.47 156.87,86.2 156.35,86.2 156.21,86.06 156.21,85.7 156.35,85.56 156.87,85.56 157.15,85.29 157.15,84.74 156.87,84.47 156.35,84.47 156.21,84.33 156.21,83.97 156.35,83.83 156.87,83.83 157.15,83.56 157.15,73.86 158.19,72.82 158.19,70.52 158.93,69.78 158.93,66.97 157.78,65.83 157.78,64.57 159.12,63.23 159.12,58.83 156.99,56.71 155.99,56.71 155.56,56.28 v1(155.56,55.84)
M_B_DQS1: length 71.8
  TOP w0.127: DIMM1.34 149.63,49.88 149.83,50.07 149.83,50.32 v1(149.49,50.66) ; XU1.AL33 135.91,102.34 135.8,102.45 v1(135.45,102.45)
  IN1 w0.102: v1(135.45,102.45) 135.71,102.45 135.82,102.35 135.82,102.12 136.4,101.53 137.73,101.53 138.39,100.87 138.7,100.87 138.91,100.67 139.94,100.67 140.61,100 141.46,100 141.81,100.35 142.78,100.35 145.7,97.43 145.7,97.08
  IN1 w0.127: v1(149.49,50.66) 149.49,50.99 149.59,51.09 149.81,51.09 149.93,51.22 149.93,51.86 149.79,52 148.21,52 147.94,52.27 147.94,52.81 148.21,53.09 150.06,53.09 150.19,53.21 150.19,53.57 150.46,53.84 151.22,53.84 151.36,53.98 151.36,54.34 151.22,54.48 150.46,54.48 150.19,54.75 150.19,56.42 151.25,57.49 151.25,59.42 151.76,59.93 151.76,60.38 152.22,60.83 152.22,65.95 152.3,66.03 152.3,68.42 151.76,68.95 151.76,69.56 151.36,69.96 151.36,73 149.76,74.6 149.76,83.35 149.18,83.93 149.18,89.11 145.7,92.6 145.7,97.08
M_B_DQS1#: length 71.8
  TOP w0.127: XU1.AK33 135.9,102.84 v1(135.45,103.28) ; DIMM1.32 150.13,50.55 v1(150.25,50.66)
  IN1 w0.102: v1(135.45,103.28) 136.02,102.71 136.02,102.2 136.48,101.74 137.82,101.74 138.48,101.08 138.79,101.08 138.99,100.87 140.02,100.87 140.7,100.2 141.37,100.2 141.72,100.55 142.86,100.55 145.9,97.51 145.9,97.18 145.91,97.17 145.91,97.11 145.92,97.09 145.92,97.08
  IN1 w0.127: v1(150.25,50.66) 150.25,51.06 150.16,51.15 150.16,51.95 149.89,52.22 148.3,52.22 148.16,52.36 148.16,52.72 148.3,52.86 150.16,52.86 150.42,53.12 150.42,53.47 150.56,53.61 151.31,53.61 151.59,53.89 151.59,54.43 151.31,54.71 150.56,54.71 150.42,54.85 150.42,56.33 151.48,57.39 151.48,59.33 151.99,59.84 151.99,60.28 152.45,60.74 152.45,65.86 152.52,65.93 152.52,68.51 151.99,69.05 151.99,69.65 151.59,70.06 151.59,73.09 149.99,74.69 149.99,83.45 149.41,84.02 149.41,89.2 145.92,92.69 145.92,97.08
M_B_DQS2: length 57.5
  TOP w0.127: v1(144.07,55.69) 144.25,55.87 144.25,56.12 144.38,56.26 DIMM1.55 ; XU1.AP33 136.19,99.18 136.3,99.07 v1(136.3,98.72)
  IN1 w0.102: 140.51,92.27 140.51,92.54 139.57,93.48 138.91,93.48 136.49,95.9 136.49,97.39 136.45,97.42 136.45,98.16 136.73,98.44 136.73,98.99 136.54,99.18 136.37,99.18 136.3,99.1 v1(136.3,98.72)
  IN1 w0.127: v1(144.07,55.69) 144.27,55.9 144.27,56.62 145.11,57.46 145.11,61.48 145.9,62.27 145.9,68.06 144.55,69.4 144.55,70.49 144.88,70.82 144.88,71.39 144.55,71.72 144.55,72.27 144.39,72.44 144.01,72.44 143.69,72.76 143.69,73.26 143.96,73.53 145.07,73.53 145.21,73.67 145.21,74.03 145.07,74.17 143.96,74.17 143.69,74.44 143.69,74.99 143.96,75.26 145.07,75.26 145.21,75.4 145.21,75.76 145.07,75.89 143.96,75.89 143.69,76.17 143.69,87.34 140.51,90.52 140.51,92.27
M_B_DQS2#: length 57.6
  TOP w0.127: v1(136.39,99.61) XU1.AN33 ; v1(144.7,55.69) 144.48,55.91 144.48,56.04 144.63,56.18 144.79,56.18 144.88,56.28 DIMM1.53
  IN1 w0.102: v1(136.39,99.61) 136.93,99.07 136.93,98.35 136.65,98.07 136.65,97.51 136.69,97.47 136.69,95.99 138.99,93.69 139.65,93.69 140.71,92.62 140.71,92.37 140.73,92.36 140.73,92.29 140.74,92.28 140.74,92.27
  IN1 w0.127: v1(144.7,55.69) 144.5,55.9 144.5,56.53 145.34,57.37 145.34,61.39 146.12,62.17 146.12,68.15 144.78,69.49 144.78,70.4 145.11,70.73 145.11,71.48 144.78,71.81 144.78,72.37 144.48,72.67 144.1,72.67 143.91,72.86 143.91,73.16 144.05,73.3 145.17,73.3 145.44,73.58 145.44,74.12 145.17,74.4 144.05,74.4 143.91,74.54 143.91,74.89 144.05,75.03 145.17,75.03 145.44,75.3 145.44,75.85 145.17,76.12 144.05,76.12 143.91,76.26 143.91,87.44 140.74,90.61 140.74,92.27
M_B_DQS3: length 57.4
  TOP w0.127: XU1.AN28 130.94,99.7 v1(130.94,99.63) ; v1(138.96,50.59) 139.13,50.41 DIMM1.76
  IN1 w0.102: v1(130.94,99.63) 131.44,99.13 131.94,99.13 132.15,98.92 132.15,98.35 132.63,97.87 132.63,96.96 134.25,95.34 134.25,93.76 135.33,92.68 135.33,91.3 135.33,91.3 135.33,91.29
  IN1 w0.127: 135.33,91.29 135.33,91.16 136.11,90.38 136.11,87.77 138.29,85.59 138.29,77.92 137.8,77.43 137.8,72.34 138.4,71.74 138.4,69.26 139.3,68.36 139.3,61.95 139.61,61.64 139.61,55.99 138.58,54.96 138.58,54.17 138.89,53.86 139.14,53.86 139.37,53.63 139.37,53.3 139.22,53.15 138.86,53.15 138.53,52.82 138.53,52.18 139.2,51.51 139.2,51.16 139.14,51.09 139.14,50.77 v1(138.96,50.59)
M_B_DQS3#: length 57.4
  TOP w0.127: XU1.AN29 131.83,100.09 131.75,100.02 v1(131.75,99.61) ; DIMM1.74 139.63,50.02 139.44,50.21 139.44,50.32 v1(139.72,50.59)
  IN1 w0.102: v1(131.75,99.61) 132.35,99.01 132.35,98.44 132.83,97.96 132.83,97.04 134.45,95.43 134.45,93.84 135.53,92.76 135.53,91.38 135.56,91.35
  IN1 w0.127: v1(139.72,50.59) 139.54,50.59 139.37,50.76 139.37,51 139.43,51.06 139.43,51.61 138.76,52.28 138.76,52.73 138.95,52.92 139.31,52.92 139.6,53.2 139.6,53.73 139.23,54.09 138.98,54.09 138.81,54.26 138.81,54.87 139.84,55.89 139.84,61.73 139.53,62.04 139.53,68.46 138.63,69.35 138.63,71.83 138.03,72.43 138.03,77.34 138.52,77.82 138.52,85.69 136.34,87.87 136.34,90.47 135.56,91.25 135.56,91.35
M_B_DQS4: length 54.8
  TOP w0.127: DIMM1.179 111.38,55.98 v1(111.23,55.83) ; v1(117.14,100.53) 116.71,100.1 XU1.AN12
  IN1 w0.102: 114.39,92.09 114.39,92.13 114.38,92.14 114.38,95.23 115,95.85 115,98.32 115.62,98.94 115.62,99.92 115.89,100.19 116.8,100.19 v1(117.14,100.53)
  IN1 w0.127: 114.39,92.09 114.39,90.64 111.68,87.92 111.68,79.18 111.49,78.99 111,78.99 110.69,78.68 110.69,75.66 110.97,75.38 111.54,75.38 111.68,75.24 111.68,74.89 111.54,74.75 110.97,74.75 110.69,74.47 110.69,73.93 110.97,73.66 111.54,73.66 111.68,73.52 111.68,73.16 111.54,73.02 110.97,73.02 110.69,72.75 110.69,72.2 110.97,71.93 111.35,71.93 111.68,71.6 111.68,68.57 112.39,67.85 112.39,62.98 112.46,62.92 112.46,61.83 111.67,61.04 111.67,57.03 111.5,56.87 111.5,56.1 v1(111.23,55.83)
M_B_DQS4#: length 54.8
  TOP w0.127: DIMM1.177 111.88,55.92 v1(112,55.81) ; v1(117.24,99.64) 117.24,99.71 XU1.AN13
  IN1 w0.102: 114.62,92.09 114.62,92.17 114.59,92.21 114.59,95.14 115.2,95.76 115.2,98.23 115.82,98.85 115.82,99.84 115.97,99.99 117.19,99.99 117.24,99.94 v1(117.24,99.64)
  IN1 w0.127: v1(112,55.81) 111.73,56.07 111.73,56.78 111.9,56.94 111.9,60.94 112.69,61.73 112.69,63.01 112.62,63.08 112.62,67.95 111.91,68.66 111.91,71.7 111.45,72.16 111.06,72.16 110.92,72.3 110.92,72.65 111.06,72.79 111.64,72.79 111.91,73.07 111.91,73.61 111.64,73.88 111.06,73.88 110.92,74.02 110.92,74.38 111.06,74.52 111.64,74.52 111.91,74.79 111.91,75.34 111.64,75.61 111.06,75.61 110.92,75.75 110.92,78.58 111.1,78.76 111.59,78.76 111.91,79.08 111.91,87.83 114.62,90.54 114.62,92.09
M_B_DQS5: length 57.8
  TOP w0.127: v1(111.31,99.57) 111.31,99.63 XU1.AP8 ; v1(105.95,50.55) 106.13,50.36 DIMM1.200
  IN1 w0.102: 110.18,93.61 110.18,93.9 110.75,94.46 110.75,99 v1(111.31,99.57)
  IN1 w0.127: v1(105.95,50.55) 105.95,53.6 106.35,54 106.35,56.95 105.54,57.76 105.54,60 105.54,61.23 105.13,61.64 105.13,66.69 104.72,67.11 104.72,69.48 105.28,70.04 105.28,87.86 105.56,88.14 106.34,88.14 106.48,88.28 106.48,88.63 106.34,88.77 105.56,88.77 105.28,89.04 105.28,89.75 105.8,90.26 107.57,90.26 110.18,92.87 110.18,93.61
M_B_DQS5#: length 57.8
  TOP w0.127: v1(111.37,98.72) 110.98,98.72 110.85,98.84 XU1.AR8 ; v1(106.71,50.55) 106.51,50.35 106.51,50.17 106.63,50.05 DIMM1.198
  IN1 w0.102: v1(111.37,98.72) 111.28,98.8 111.05,98.8 110.95,98.7 110.95,94.38 110.41,93.84 110.41,93.61
  IN1 w0.127: v1(106.71,50.55) 106.71,50.91 106.58,51.04 106.27,51.04 106.18,51.14 106.18,53.5 106.58,53.9 106.58,57.05 105.77,57.86 105.77,60.1 105.77,61.33 105.36,61.74 105.36,66.79 104.95,67.2 104.95,69.38 105.51,69.95 105.51,87.77 105.65,87.91 106.43,87.91 106.7,88.18 106.7,88.73 106.43,89 105.65,89 105.51,89.14 105.51,89.65 105.89,90.03 107.67,90.03 110.41,92.78 110.41,93.61
M_B_DQS6: length 68.4
  TOP w0.127: v1(100.81,55.87) 100.88,55.94 DIMM1.221 ; v1(111.31,102.32) 111.31,102.38 XU1.AL8
  IN1 w0.102: v1(111.31,102.32) 111.12,102.13 109.23,102.13 107.18,100.07 107.18,99.53 106.92,99.27 103.57,99.27 103.09,98.8 102.97,98.68 102.96,98.68 102.92,98.64 102.9,98.64 102.88,98.63
  IN1 w0.127: v1(100.81,55.87) 100.81,56.82 99.46,58.17 99.46,60.14 98.32,61.28 98.32,66.11 97.41,67.03 97.41,68.1 96.98,68.53 96.98,72.43 97.43,72.89 99.32,72.89 99.5,73.07 99.5,73.56 99.37,73.7 97.5,73.7 97.23,73.97 97.23,74.52 97.5,74.79 99.37,74.79 99.5,74.93 99.5,75.29 99.37,75.43 97.5,75.43 97.23,75.7 97.23,76.25 97.5,76.52 99.37,76.52 99.5,76.66 99.5,92.13 102.46,95.09 102.46,98.2 102.88,98.63
M_B_DQS6#: length 68.4
  TOP w0.127: DIMM1.219 101.38,55.95 v1(101.47,55.86) ; v1(111.3,101.43) 111.3,101.5 110.88,101.92 XU1.AM8
  IN1 w0.102: 103.05,98.47 103.65,99.07 107,99.07 107.38,99.45 107.38,99.99 109.32,101.92 110.81,101.92 v1(111.3,101.43)
  IN1 w0.127: v1(101.47,55.86) 101.04,56.29 101.04,56.91 99.69,58.26 99.69,60.23 98.55,61.37 98.55,66.21 97.63,67.12 97.63,68.2 97.21,68.63 97.21,72.34 97.53,72.66 99.41,72.66 99.73,72.98 99.73,73.66 99.46,73.93 97.6,73.93 97.46,74.07 97.46,74.43 97.6,74.56 99.46,74.56 99.73,74.84 99.73,75.38 99.46,75.66 97.6,75.66 97.46,75.8 97.46,76.15 97.6,76.29 99.46,76.29 99.73,76.57 99.73,92.04 102.69,95 102.69,98.11 103.05,98.47
M_B_DQS7: length 77.4
  TOP w0.127: v1(109.45,106.05) 109.49,106.05 XU1.AG7 ; v1(95.51,50.47) 95.63,50.35 DIMM1.242
  IN1 w0.102: 102.78,105.46 102.8,105.48 102.8,105.48 103.65,106.33 104.51,106.33 104.62,106.44 106.38,106.44 107.07,105.75 108.53,105.75 109.07,106.29 109.22,106.29 v1(109.45,106.05)
  IN1 w0.127: v1(95.51,50.47) 95.51,49.24 95.79,48.96 96.7,48.96 97.08,49.34 97.08,51.41 96.47,52.02 95.65,52.02 95.45,52.21 95.45,52.48 95.18,52.75 94.75,52.75 94.61,52.89 94.61,53.24 94.75,53.38 95.18,53.38 95.45,53.66 95.45,56.03 92.96,58.53 92.96,59.18 91.77,60.37 91.77,68 92.31,68.54 92.31,72.44 93.05,73.18 93.05,91.18 98.53,96.65 98.53,100.03 100.99,102.5 100.99,103.67 101.95,104.63 102.78,105.46
M_B_DQS7#: length 77.4
  TOP w0.127: XU1.AG6 109.49,106.96 v1(109.49,106.99) ; DIMM1.240 96.13,50.31 v1(96.28,50.46)
  IN1 w0.102: 102.62,105.62 102.63,105.63 102.64,105.63 102.69,105.68 102.71,105.68 103.56,106.54 104.43,106.54 104.53,106.64 106.47,106.64 107.15,105.95 108.45,105.95 v1(109.49,106.99)
  IN1 w0.127: v1(96.28,50.46) 95.74,49.91 95.74,49.33 95.88,49.19 96.6,49.19 96.85,49.44 96.85,51.32 96.38,51.79 95.55,51.79 95.22,52.12 95.22,52.38 95.08,52.52 94.66,52.52 94.38,52.79 94.38,53.34 94.66,53.61 95.08,53.61 95.22,53.75 95.22,55.94 92.73,58.43 92.73,59.09 91.54,60.28 91.54,68.09 92.08,68.64 92.08,72.53 92.83,73.27 92.83,91.28 98.3,96.75 98.3,100.13 100.76,102.59 100.76,103.77 101.72,104.73 102.62,105.62
M_B_ODT0: length 59.3
  TOP w0.198: v1(118.11,55.21) 117.38,55.93 DIMM1.155 ; XU1.AM16 119.92,100.56 v1(119.92,100.49)
  IN1 w0.102: v1(119.92,100.49) 119.92,99.54 119.97,99.49 119.97,92.35 119.78,92.16 119.78,91.72
  IN1 w0.211: 119.78,91.72 119.78,88.3 119.38,87.9 118.96,87.9 117.68,86.62 117.68,76.83 117.9,76.6 119.58,76.6 119.84,76.34 119.84,75.78 119.6,75.55 117.97,75.55 117.68,75.25 117.68,74.59 117.93,74.34 118.94,74.34 119.17,74.11 119.17,73.52 118.94,73.28 118.02,73.28 117.68,72.94 117.68,72.17 118.18,71.67 118.18,70.85 117.68,70.35 117.68,69.74 118.42,69 119.22,69 119.53,68.69 119.53,67.85 118.92,67.25 118.92,65.54 118.51,65.12 118.51,60.8 119.13,60.17 119.13,56.92 118.11,55.89 v1(118.11,55.21)
  BOTTOM w0.198: v2(118.11,56.07) v1(118.11,55.21)
M_B_ODT1: length 59.5
  TOP w0.198: XU1.AL16 119.95,101.51 v1(119.92,101.51) ; DIMM1.161 115.88,56.39 115.62,56.12 115.62,55.18 v1(116.15,54.65)
  IN1 w0.102: v1(119.92,101.51) 119.31,101.51 118.55,100.74 118.55,100.42 118.19,100.06 117.92,100.06 117.66,99.81 117.66,99.13 117.52,98.99 117.52,97.99 117.53,97.98 117.53,93.98 117.18,93.64 117.18,92.04 117.23,92 117.23,91.59 117.19,91.56
  IN1 w0.211: 117.19,91.56 116.88,91.24 116.88,89.44 114.16,86.73 114.16,77.27 114.78,76.65 114.78,69.47 115.43,68.82 115.43,55.37 114.41,54.35 114.41,53.29 114.66,53.04 115.41,53.04 115.67,53.3 115.67,54.17 v1(116.15,54.65)
  BOTTOM w0.198: v2(116.75,54.16) 116.26,54.65 v1(116.15,54.65)
M_B_PAR: length 56.1
  TOP w0.198: XU1.AL20 124.02,101.92 v1(123.54,101.44) ; DIMM1.143 122.38,56.21 v1(122.59,56.01)
  IN1 w0.102: 123.1,91.72 123.1,92.38 123.61,92.89 123.61,97.15 123.46,97.3 123.46,101.35 v1(123.54,101.44)
  IN1 w0.211: 123.1,91.72 123.1,84.88 122.75,84.54 121.57,84.54 121.33,84.31 121.33,83.73 121.58,83.49 122.8,83.49 123.1,83.19 123.1,82.73 122.8,82.43 121.56,82.43 121.2,82.08 121.2,80.55 121.98,79.77 122.8,79.77 123.1,79.48 123.1,74.49 122.38,73.77 122.38,73.17 123.06,72.48 123.06,72.18 122.38,71.49 122.38,70.37 123.09,69.66 123.09,68.87 123.54,68.41 123.54,66.04 122.86,65.36 122.86,63.44 122.87,63.44 122.87,62.79 123.11,62.54 123.11,60.03 122.59,59.51 v1(122.59,56.01)
  BOTTOM w0.198: v2(123.25,56.27) 122.98,56.01 v1(122.59,56.01)
MB_REG_PG: length 19.8
  BOTTOM w0.102: v2(11.78,119.45) 11.78,118.73 12.99,117.53 O2Q3.6 12.27,117.11 12.17,117 12.17,116.22 12,116.06 O2Q2.6 10.51,116.06 10.39,115.94 10.39,115.61 10.54,115.46 12.14,115.46 12.42,115.18 13.13,115.18 13.28,115.03 13.28,114.36 13.46,114.18 14.03,114.18 14.17,114.04 14.17,113.42 OR134.1 14.65,112.56 14.55,112.46 14.55,111.89 14.25,111.59 13.89,111.59 13.77,111.47 13.24,111.47 12.91,111.15 12.91,110.8 13.02,110.7 13.02,110.07 13.35,109.74 14.07,109.74 14.71,109.1 U104.109
MCT0: length 4.6
  TOP w0.254: R22.1 13.08,158.08 13.54,158.54 v2(13.54,159.17)
  TOP w0.508: LU3.15 12.21,157.47 12.17,157.52 R22.1
MCT1: length 5.8
  TOP w0.254: R21.1 9.45,158.08 8.99,158.54 v2(8.99,159.91)
  TOP w0.508: R21.1 9.21,156.9 LU3.18
MCT2: length 4.7
  TOP w0.254: v2(7.52,159.17) 7.52,158.33 7.26,158.08 R20.1
  TOP w0.508: LU3.21 6.21,157.03 6.2,157.05 R20.1
MCT3: length 7.6
  TOP w0.254: v2(3.66,161.2) 3.66,160.44 3.25,160.03 3.25,158.41 3.58,158.08 R19.1
  TOP w0.508: LU3.24 3.21,156.95 3.5,157.24 4.16,157.24 4.42,157.5 R19.1
ME_CNTL: length 47.9
  TOP w0.089: 37.64,89.63 37.87,89.39 39.26,89.39 U1.BF32
  TOP w0.102: v1(23.06,64.2) 23.05,64.21 23.05,68.01 23.49,68.45 23.49,69.71 21.32,71.88 19.9,71.88 19.17,72.61 19.17,74.34 19.34,74.5 19.92,74.5 20.39,74.97 20.39,75.92 22.63,78.15 22.63,84.16 24.6,86.13 24.6,86.72 25.5,87.62 28.99,87.62 29.47,88.09 30.46,88.09 30.61,88.24 32.53,88.24 32.76,88.47 35.88,88.47 37.04,89.63 v1(37.34,89.63) 37.64,89.63
  BOTTOM w0.102: v2(20.78,64.82) SR135.1 22.44,64.82 v1(23.06,64.2) ; SR673.2 37.34,89.41 v1(37.34,89.63)
ME_DISABLE#_R: length 5.6
  BOTTOM w0.102: Q1.1 v2(21.62,66.98) 21.23,66.59 21.23,66.14 SR135.2
MEM_REG_PG: length 12.9
  BOTTOM w0.102: v2(16.51,118.35) 16.65,118.21 16.65,116.36 16.09,115.81 O2Q3.3 15.1,115.81 14.9,115.61 14.9,115.13 15.29,114.74 15.29,114.37 15.47,114.19 15.92,114.19 16.03,114.08 16.03,113.37 OR136.1 15.52,112.95 14.83,112.26 14.83,109.82 15.51,109.14 U104.111
MIC2-VREFO: length 21.6
  TOP w0.203: v1(17.54,17.58) 17.54,18.39 17.29,18.63 U6.29
  IN1 w0.254: v1(34.64,16.35) 33.91,16.35 33.32,15.76 24.14,15.76 23.51,15.13 20.38,15.13 20.1,15.41 19.83,15.41 19.06,16.18 18.23,16.18 17.54,16.88 v1(17.54,17.58)
  BOTTOM w0.254: v1(34.64,16.35) 34.47,16.35 v2(33.88,16.93)
  vias: v1(35.28,16.35)
MIC_CAP: length 6.7
  TOP w0.229: U6.19 13.95,21.64
  TOP w0.254: 13.95,21.64 12.54,21.64 AC85.1 11.26,21.28 v1(11.17,21.28)
  BOTTOM w0.254: v1(11.17,21.28) 11.27,21.28 12.7,22.7 v2(12.7,22.88)
MQ28_1: length 18.9
  BOTTOM w0.102: MQ28.1 75.48,146.88 75.87,147.27 77.86,147.27 78.15,147.56 79.9,147.56 80.08,147.74 84.28,147.74 84.31,147.77 85.41,147.77 v2(85.72,147.46) 85.95,147.23 85.95,144.36 86.24,144.08 MQ27.3 85.37,143.63 84.85,143.11 SR7994.1
MS_CLK: length 98.7
  TOP w0.127: J68.14 78.26,147.15 79.53,145.89 79.53,144.62 79.22,144.32 79.22,143.78 79.6,143.39 79.6,143.13 79.48,143.01 79.48,142.99 79.4,142.92 79.4,142.64 v1(79.88,142.17)
  IN2 w0.127: v1(79.88,142.17) 77.43,142.17 76.84,142.76 75.52,142.76 75.27,143 71.99,143 68.32,139.33 66.82,139.33 65.6,138.12 58.85,138.12 57.86,139.11 55.21,139.11 54.4,138.29 53.16,138.29 52.45,139 48.12,139 45.6,136.49 42.8,136.49 41.21,134.9 39.96,134.9 36.49,131.43 35.79,131.43 34.97,130.62 34.97,129.51 35.6,128.88 35.6,127.81 34.27,126.48 29.26,126.48 28.9,126.12 28.9,123.82 27.47,122.39 25.75,122.39 25.06,121.7 25.06,121.22 23.52,119.68 23.52,118.08 22.92,117.48 20.67,115.23 20.26,115.23 17.63,112.59 17.63,110.26 18.02,109.87 18.02,109.51 17.76,109.26 17.4,109.26 17.07,109.59 17.07,109.78 v1(16.52,110.33)
  BOTTOM w0.127: OR70.1 16.6,112.02 16.6,111.95 16.34,111.7 16.34,110.51 v1(16.52,110.33) 16.93,109.92 16.93,109.35 17.11,109.17 U104.115 ; v1(79.88,142.17) 79.53,141.82 v2(79.22,141.82)
MS_DATA: length 94.7
  TOP w0.127: v1(79.88,142.8) 79.88,143.47 79.48,143.88 79.48,144.21 79.78,144.52 79.78,145.99 78.77,147 78.77,147.69 78.31,148.15 J68.16
  IN2 w0.127: v1(17.58,109.69) 17.37,109.9 17.37,112.7 20.16,115.48 20.56,115.48 22.67,117.59 23.26,118.19 23.26,119.78 24.8,121.32 24.8,121.8 25.65,122.65 27.37,122.65 28.65,123.93 28.65,126.23 29.16,126.74 34.1,126.74 34.55,127.18 34.55,127.85 34.49,127.91 34.49,130.49 35.68,131.69 36.39,131.69 39.85,135.16 41.1,135.16 43.94,137.99 46.73,137.99 48,139.26 52.58,139.26 53.26,138.57 54.32,138.57 55.11,139.36 57.99,139.36 58.98,138.37 65.5,138.37 66.72,139.59 68.22,139.59 71.89,143.26 75.38,143.26 75.63,143.01 76.95,143.01 77.48,142.48 79.56,142.48 v1(79.88,142.8)
  BOTTOM w0.127: OR71.1 17.12,110.89 17.12,110.45 v2(17.23,110.34) 17.58,109.98 v1(17.58,109.69) 17.51,109.62 U104.116
Net_524: length 0.3
  TOP w0.203: 61.59,92.45 61.59,92.2
Net_1955: length 0.3
  TOP w0.203: 105.36,122.04 105.36,121.71
Net_1956: length 0.3
  TOP w0.203: 104.45,122.95 104.45,123.28
Net_1957: length 0.3
  TOP w0.203: 105.36,123.87 105.36,123.54
Net_1958: length 0.3
  TOP w0.203: 104.45,124.78 104.45,124.45
Net_1959: length 0.3
  TOP w0.203: 105.36,125.37 105.36,125.7
Net_1960: length 0.3
  TOP w0.203: 104.45,126.61 104.45,126.28
Net_1961: length 0.4
  TOP w0.203: 105.36,127.52 105.77,127.52
Net_1963: length 0.4
  TOP w0.203: 107.19,129.35 107.19,128.95
Net_1964: length 0.3
  TOP w0.203: 105.36,116.55 105.36,116.88
Net_1965: length 0.3
  TOP w0.203: 105.36,117.47 105.36,117.8
Net_1966: length 0.3
  TOP w0.203: 105.36,118.38 105.36,118.71
Net_1967: length 0.3
  TOP w0.203: 104.45,119.29 104.45,118.96
Net_1968: length 0.3
  TOP w0.203: 105.36,119.88 105.36,120.21
Net_1969: length 0.3
  TOP w0.203: 104.45,121.45 104.45,121.12
Net_1970: length 0.4
  TOP w0.203: 108.11,130.27 108.11,129.86
Net_1972: length 0.3
  TOP w0.203: 105.36,122.95 105.36,122.62
Net_1974: length 0.3
  TOP w0.203: 105.36,124.78 105.36,124.45
Net_1976: length 0.3
  TOP w0.203: 105.36,126.61 105.36,126.28
Net_1979: length 0.4
  TOP w0.203: 108.11,129.35 108.11,128.99
Net_1981: length 0.3
  TOP w0.203: 104.45,117.47 104.71,117.26
Net_1983: length 0.3
  TOP w0.203: 105.36,119.29 105.62,119.09
Net_1985: length 0.3
  TOP w0.203: 105.36,121.12 105.36,120.79
Net_1986: length 0.4
  TOP w0.203: 109.02,130.27 108.65,130.27
Net_2002: length 0.3
  TOP w0.203: 110.85,129.35 111.18,129.35
Net_2018: length 0.4
  TOP w0.203: 109.94,129.35 109.94,128.99
O2Q2_PIN2: length 5.3
  BOTTOM w0.102: v2(5.17,115.85) 5.43,115.59 6.67,115.59 RO1.2 7.51,115.52 7.51,115.66 RO2.1 7.78,116.71 O2Q2.2
O2Q2_PIN5: length 6.2
  BOTTOM w0.102: v2(10.18,118.61) 10.74,118.61 11.78,117.57 11.78,116.86 11.64,116.71 O2Q2.5 10.33,116.71 10.03,116.41 O2R12.2
O2Q4_C1: length 5.5
  BOTTOM w0.102: M1R16.2 35.29,111.95 v2(35.29,111.74) 35.24,111.68 AC6.1 35.93,110.92 36.04,110.81 O2Q4.5 36.87,110.81 37.44,110.81 37.54,110.91 37.54,111.36 37.44,111.46 O2Q4.6
O2Q5_PIN3: length 4.6
  BOTTOM w0.102: O2Q5.3 42.14,136.25 ECR160.1 39.42,135.59 v2(39.05,135.96)
O2Q5_PIN56: length 8.4
  BOTTOM w0.254: O2Q5.5 44.93,135.6 44.8,135.47 44.8,135.07 44.92,134.95 O2Q5.6 45.59,134.28 45.2,133.89 AC209.1 R99535.2 41.9,134.99 v2(40.56,134.99)
O_TR_CPU+: length 33.5
  TOP w0.127: SSD_Q1.2 26.47,84.21 26.06,84.62 25.4,84.62 24.83,84.05 24.83,83.7 O2C6.1 24.35,82.88 24.48,82.75 24.48,82.39 24.05,81.96 v1(24.05,81.93) ; SSD_Q2.3 13,89.7 13.95,88.75 SSD_Q2.1 14.52,88.75 14.83,89.07 15.08,89.07 15.53,88.62 15.77,88.62 O2C8.1 16.34,88.59 17.22,88.59 18.28,89.65 18.74,89.65 v1(18.95,89.45)
  BOTTOM w0.127: U104.41 19.11,91.94 O2C7.1 19.95,90.65 19.95,89.94 19.63,89.61 19.11,89.61 v1(18.95,89.45) 19.15,89.45 19.66,88.94 21.08,88.94 21.45,88.57 22.94,88.57 24.37,87.14 24.37,83.67 24.99,83.05 24.99,82.44 24.61,82.06 24.17,82.06 v1(24.05,81.93) ; SSD_Q1.3 26.47,81.73 26.64,81.9 26.64,82.57 26.47,82.74 SSD_Q1.2
O_TR_CPU-: length 28.7
  TOP w0.127: SSD_Q1.1 25.58,85.26 25.55,85.26 O2C6.2 23.91,83.63 23.91,82.7 v1(24.05,82.57) ; v1(18.95,90.12) 18.74,89.91 18.18,89.91 17.11,88.84 16.39,88.84 O2C8.2 15.81,88.89 15.62,88.89 15.19,89.32 14.78,89.32 14.48,89.62 SSD_Q2.2
  BOTTOM w0.127: U104.42 18.71,91.79 18.84,91.66 19.03,91.66 19.49,91.2 19.49,91.02 O2C7.2 19.7,90.51 19.7,90.05 19.52,89.87 19.19,89.87 v1(18.95,90.12) 18.52,89.68 18.52,89.27 18.77,89.01 19.13,89.01 19.45,88.69 20.97,88.69 21.35,88.31 22.83,88.31 24.12,87.03 24.12,83.57 24.74,82.95 24.74,82.54 24.51,82.31 24.31,82.31 v1(24.05,82.57)
O_TR_MB+: length 250.8
  TOP w0.127: AMB_Q1.2 AMB_Q1.3 155.53,14 155.24,14.29 154.44,14.29 O2C2.1 153.86,14.29 153.29,14.29 151.54,12.54 149.78,12.54 v1(149.58,12.33) ; v1(32.89,22.62) 33.04,22.77 33.04,27.46 35.2,29.62 35.2,39.24 34.75,39.7 34.75,42.34 32.92,44.17 32.92,45.2 32.94,45.22 v1(32.94,45.5)
  IN1 w0.127: v1(6.75,74.97) 7.19,74.54 7.19,73.81 8.97,72.02 8.97,69.76 10.21,68.52 10.58,68.52 11.65,67.44 11.65,66.56 11.65,66.35 11.52,66.22 11.52,65.48 11.52,65.36 10.84,64.68 10.84,55.52 12.89,53.47 16.03,53.47 17.04,52.45 17.04,50.89 17.94,49.99 19.3,49.99 22.06,47.23 25.38,47.23 26.31,46.29 31.79,46.29 32.58,45.5 v1(32.94,45.5)
  IN2 w0.127: v1(143.25,22.6) 141.73,24.12 138.75,24.12 137.38,25.49 135.18,25.49 133.26,23.57 130.93,23.57 129.99,22.64 124.71,22.64 121.36,19.3 107.05,19.3 106.62,18.86 96.47,18.86 95.88,18.28 93.5,18.28 90.75,15.53 87.1,15.53 83.49,19.14 83.49,19.65 82.65,20.49 74.32,20.49 71.78,17.95 65.1,17.95 64.9,17.74 59.06,17.74 57.39,19.41 49.89,19.41 48.28,17.8 42.15,17.8 41.91,17.57 40.67,17.57 38.89,19.34 36.17,19.34 v1(32.89,22.62)
  BOTTOM w0.127: U104.43 18.31,90.97 O2C1.1 17.98,90.13 17.98,89.42 17.46,88.9 9.79,88.9 5.79,84.9 5.79,77.33 v2(6.04,77.08) 5.79,76.82 5.79,75.48 6.3,74.97 v1(6.75,74.97) ; v1(143.25,22.6) 143.25,21.75 143.91,21.1 145.3,21.1 145.97,20.43 145.97,13.57 147.01,12.54 149.38,12.54 v1(149.58,12.33)
O_TR_MB-: length 251.8
  TOP w0.127: v1(33.35,45.02) 33.17,44.84 33.17,44.28 35,42.45 35,39.8 35.46,39.35 35.46,29.51 35.36,29.41 33.3,27.35 33.3,22.93 v1(33.6,22.62) ; AMB_Q1.1 155.51,18.39 155.51,14.81 155.24,14.54 154.44,14.54 O2C2.2 153.86,14.54 153.19,14.54 151.43,12.79 149.76,12.79 v1(149.57,12.98)
  IN1 w0.127: v1(33.35,45.02) 32.71,45.02 31.68,46.04 26.17,46.04 25.23,46.97 21.96,46.97 19.2,49.74 17.84,49.74 16.79,50.79 16.79,52.35 15.92,53.22 12.79,53.22 10.59,55.41 10.59,64.79 11.27,65.47 11.27,66.33 11.4,66.45 11.4,67.34 10.47,68.27 10.11,68.27 8.72,69.65 8.72,71.91 6.93,73.7 6.93,74.16 v1(6.75,74.34)
  IN2 w0.127: v1(143.28,23.33) 142.88,23.33 141.83,24.37 138.86,24.37 137.49,25.75 135.07,25.75 133.15,23.83 130.82,23.83 129.89,22.9 124.6,22.9 121.26,19.55 106.95,19.55 106.51,19.12 96.36,19.12 95.78,18.53 93.39,18.53 90.65,15.79 87.2,15.79 83.74,19.25 83.74,19.76 82.76,20.74 74.22,20.74 71.68,18.2 65,18.2 64.79,18 59.16,18 57.49,19.66 49.78,19.66 48.18,18.06 42.04,18.06 41.81,17.82 40.77,17.82 38.99,19.6 36.28,19.6 33.6,22.27 v1(33.6,22.62)
  BOTTOM w0.127: U104.44 17.91,91.78 18.06,91.64 18.06,91.05 O2C1.2 17.73,89.53 17.36,89.16 9.69,89.16 5.54,85.01 5.54,75.38 6.2,74.72 6.37,74.72 v1(6.75,74.34) ; v1(143.28,23.33) 143.76,22.85 v2(143.76,21.96) 143.76,21.6 144.01,21.35 145.41,21.35 146.23,20.53 146.23,13.68 147.12,12.79 149.38,12.79 v1(149.57,12.98)
OC0#_R: length 85.8
  IN1 w0.102: v1(49.71,71.24) 50.62,71.24 53.58,74.19 53.58,74.4 54.38,75.2 54.38,79.34 54.76,79.72 54.76,80.1 52.81,82.06 52.81,85.69 v1(52.91,85.79) ; v1(54.1,51.98) 53.59,51.98 52.79,51.19 45.62,51.19 45.2,51.6 41.79,51.6 41.53,51.87 39.05,51.87 38.16,52.76 35.21,52.76 34.59,53.38 32.92,53.38 32.33,53.97 31.93,53.97 30.96,54.94 29.02,54.94 28.44,54.36 27.42,54.36 27.25,54.54 25.77,54.54 25.5,54.8 21.48,54.8 v1(20.34,55.94)
  IN2 w0.102: v1(54.1,51.98) 54.29,52.17 54.29,52.59 55.51,53.81 55.51,54.58 55.92,54.99 55.92,55.68 55.32,56.28 54.88,56.28 54.62,56.53 54.62,57.33 55.07,57.77 55.5,57.77 55.98,58.25 55.98,59.22 54.24,60.96 54.24,65.54 52.04,67.74 52.04,68.91 v1(49.71,71.24)
  BOTTOM w0.102: v2(21.26,56.99) 21.26,56.85 v1(20.34,55.94) 19.65,55.24 XDP3.10 ; v1(52.91,85.79) 52.5,86.2 52.5,86.68 52.77,86.95 SR7858.2
