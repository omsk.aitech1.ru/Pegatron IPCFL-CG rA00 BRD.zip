# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MX_SOCKET_16P_50_LOTE
  rect 0.508x1.499 smd: 1(-4.445,-4.8) 2(-3.175,-4.8) 3(-1.905,-4.8) 4(-0.635,-4.8) 5(0.635,-4.8) 6(1.905,-4.8) 7(3.175,-4.8) 8(4.445,-4.8) 9(4.445,4.8) 10(3.175,4.8) 11(1.905,4.8) 12(0.635,4.8) 13(-0.635,4.8) 14(-1.905,4.8) 15(-3.175,4.8) 16(-4.445,4.8)
MX_SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.857) 6(0.635,2.857) 7(-0.635,2.857) 8(-1.905,2.857)
MX_SOIC_8P_50_201X236PNIK4V
  rect 0.635x1.549 smd: 1(-1.905,-2.833) 2(-0.635,-2.833) 3(0.635,-2.833) 4(1.905,-2.833) 5(1.905,2.833) 6(0.635,2.833) 7(-0.635,2.833) 8(-1.905,2.833)
  rect 3.607x2.692 smd: 9(0,0)
  round 0.61 hole 0.305: 10(-1.499,1.041) 11(1.499,1.041) 12(-1.499,-1.041) 13(1.499,-1.041)
MX_SOIC_8P_50_S213_NS_NP
  rect 0.61x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
MX_SOT23
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
MX_SOT23_2D4_122X55_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_2D4_122X71
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
MX_SOT23_S5_2D4_H51
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
MX_SOT23_S5_H57
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
MX_SOT23_S6
  rect 0.483x1.067 smd: 1(-0.95,-1.45) 2(0,-1.45) 3(0.95,-1.45) 4(0.95,1.45) 5(0,1.45) 6(-0.95,1.45)
MX_SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
MX_SOT323_S5
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(-0.65,1.19)
MX_SOT363_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
MX_SW_4P_2HOLD_RA_DIPT
  round 1.041 hole 1.041 unplated: (0,1.5) (0,-1.5)
  rect 1.092x0.991 smd: 1(-2.65,-1.95) 2(-2.65,1) 3(2.65,-1.95) 4(2.65,1)
MX_SW_4P_181X126
  rect 1.041x0.66 smd: 1(-2.075,1.075) 2(2.075,1.075) 3(-2.075,-1.075) 4(2.075,-1.075)
MX_TPC26T_S4_68
  round 0.66 smd: 1(0,0)
MX_TRANS_24P_39_595X394_DEL
  rect 0.584x1.956 smd: 1(-5.5,-4.632) 2(-4.5,-4.632) 3(-3.5,-4.632) 4(-2.5,-4.632) 5(-1.5,-4.632) 6(-0.5,-4.632) 7(0.5,-4.632) 8(1.5,-4.632) 9(2.5,-4.632) 10(3.5,-4.632) 11(4.5,-4.632) 12(5.5,-4.632) 13(5.5,4.632) 14(4.5,4.632) 15(3.5,4.632) 16(2.5,4.632) 17(1.5,4.632) 18(0.5,4.632) 19(-0.5,4.632) 20(-1.5,4.632) 21(-2.5,4.632) 22(-3.5,4.632) 23(-4.5,4.632) 24(-5.5,4.632)
MX_USB_2X4P_4HD_AMCOTE_LF5
  rect 1.321x1.321 hole 0.914: 1(-3.5,2.71)
  round 1.321 hole 0.914: 2(-1,2.71) 3(1,2.71) 4(3.5,2.71) 5(-3.5,5.33) 6(-1,5.33) 7(1,5.33) 8(3.5,5.33)
  round 2.718 hole 2.311: 9(-6.57,0) 10(6.57,0) 11(-6.57,5.68) 12(6.57,5.68)
MX_USB_2X9P_4HD_RA_F71_LF5
  rect 1.118x1.118 hole 0.711: 1(-3.5,2)
  round 1.118 hole 0.711: 2(-1,2) 3(1,2) 4(3.5,2) 5(4,3.5) 6(2,3.5) 7(0,3.5) 8(-2,3.5) 9(-4,3.5) 10(-3.5,5.2) 11(-1,5.2) 12(1,5.2) 13(3.5,5.2) 14(4,6.7) 15(2,6.7) 16(0,6.7) 17(-2,6.7) 18(-4,6.7)
  round 2.718 hole 2.311: 19(-6.57,0) 20(6.57,0) 21(-6.57,5.68) 22(6.57,5.68)
MX_USB_9P_2HOLD_RA_JCTC_LF5
  round 1.118 hole 0.711: 1(-3.5,2) 2(-1,2) 3(1,2) 4(3.5,2) 5(4,3.5) 6(2,3.5) 7(0,3.5) 8(-2,3.5) 9(-4,3.5)
  round 2.718 hole 2.311: 10(6.57,0) 11(-6.57,0)
MX_WAF_HD_1X4P_79_H_F71_LF5
  round 1.245 hole 1.245 unplated: (-3,1.8)
  rect 1.372x1.372 hole 0.965: 1(3,0)
  round 1.372 hole 0.965: 2(1,0) 3(-1,0) 4(-3,0)
MX_WAFER_HD_4P_79_H_F71_LF5
  round 1.245 hole 1.245 unplated: (-3,1.8)
  rect 1.372x1.372 hole 0.965: 1(3,0)
  round 1.372 hole 0.965: 2(1,0) 3(-1,0) 4(-3,0)
MX_WTOB_24P_39_2HD_ACES
  rect 0.61x1.6 smd: 1(-5.5,-3.2) 2(-5.5,2.4) 3(-4.5,-3.2) 4(-4.5,2.4) 5(-3.5,-3.2) 6(-3.5,2.4) 7(-2.5,-3.2) 8(-2.5,2.4) 9(-1.5,-3.2) 10(-1.5,2.4) 11(-0.5,-3.2) 12(-0.5,2.4) 13(0.5,-3.2) 14(0.5,2.4) 15(1.5,-3.2) 16(1.5,2.4) 17(2.5,-3.2) 18(2.5,2.4) 19(3.5,-3.2) 20(3.5,2.4) 21(4.5,-3.2) 22(4.5,2.4) 23(5.5,-3.2) 24(5.5,2.4)
  rect 0.838x1.803 smd: 25(-6.825,0) 26(6.825,0)
MX_WTOB_30P_20_6HD_STARCONN
  round 0.864 hole 0.864 unplated: (-8,0) (8,0)
  rect 0.254x1.143 smd: 1(7.25,2.125) 2(6.75,2.125) 3(6.25,2.125) 4(5.75,2.125) 5(5.25,2.125) 6(4.75,2.125) 7(4.25,2.125) 8(3.75,2.125) 9(3.25,2.125) 10(2.75,2.125) 11(2.25,2.125) 12(1.75,2.125) 13(1.25,2.125) 14(0.75,2.125) 15(0.25,2.125) 16(-0.25,2.125) 17(-0.75,2.125) 18(-1.25,2.125) 19(-1.75,2.125) 20(-2.25,2.125) 21(-2.75,2.125) 22(-3.25,2.125) 23(-3.75,2.125) 24(-4.25,2.125) 25(-4.75,2.125) 26(-5.25,2.125) 27(-5.75,2.125) 28(-6.25,2.125) 29(-6.75,2.125) 30(-7.25,2.125)
  rect 1.499x2.997 smd: 31(9.75,0) 32(-9.75,0)
  rect 2.794x1.499 smd: 33(5.7,-2.05) 34(-5.7,-2.05)
MX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
MX_XTAL_4P_126X98_HOSON_H35
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
MX_XTAL_4P_272X55
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)
SHORTPIN
  custom 0.184x0.184 smd: 1(-0.521,0) 2(0.521,0)
T_PHONE_JACK_6P_4H_SING_LF5
  round 1.143 hole 1.143 unplated: (0,3) (0,-3)
  oval 0.914x1.575 hole 0.508x1.168: 1(3.8,6.1)
  oval 0.864x1.524 hole 0.457x1.118: 2(-3.7,-1.5) 3(3.7,-3.8) 4(-2.7,-3.6) 5(-2.2,6.1) 6(-3.8,6.1) 7(-4.6,1.5) 8(4.6,0.5)
T_TACT_SW_4P_2H_RA_LF5
  round 1.346 hole 0.94: 5(-1.6,0) 6(1.6,0)
  oval 0.914x1.118 hole 0.711: A(-0.575,2.2) B(0.575,2.2) L1(1.725,2.2) L2(-1.725,2.2)
TX_2R4P0201_35X28
  rect 0.305x0.279 smd: 1(-0.3,-0.288) 2(-0.3,0.288) 3(0.3,-0.288) 4(0.3,0.288)
TX_2R4P0201_35X28_SHORT
  rect 0.305x0.279 smd: 1(-0.3,-0.288) 2(-0.3,0.288) 3(0.3,-0.288) 4(0.3,0.288)
TX_C0201
  rect 0.305x0.33 smd: 1(-0.254,0) 2(0.254,0)
TX_C0201_T009_H14
  rect 0.305x0.406 smd: 1(-0.254,0) 2(0.254,0)
TX_C0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_C0402_H24
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_C0603
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_C0603_T015_H37
  rect 0.587x0.965 smd: 1(-0.684,0) 2(0.684,0)
TX_C0805_T02_H55
  rect 0.726x1.473 smd: 1(-0.856,0) 2(0.856,0)
TX_C0805_T02_H57
  rect 0.726x1.473 smd: 1(-0.856,0) 2(0.856,0)
TX_CHOKE_4P_35X28_PAN
  rect 0.305x0.305 smd: 1(-0.25,-0.3) 2(-0.25,0.3) 3(0.25,0.3) 4(0.25,-0.3)
TX_DFN_8P_201X240_2P_10V_CO
  rect 0.762x0.864 smd: 1(-1.905,-2.865) 2(-0.635,-2.865) 3(0.635,-2.865) 4(1.905,-2.865) 5(1.905,2.865) 6(0.635,2.865) 7(-0.635,2.865)
  rect 0.813x1.93 smd: 8(-1.885,2.34)
  custom 0.663x0.663 smd: 9(0,0.665)
  rect 4.191x1.067 smd: 10(0,-1.55)
  round 0.61 hole 0.305: 11(1.708,1.675) 12(1.708,-0.357) 13(0.565,1.675) 14(0.565,-0.357) 15(-0.578,1.675) 16(-0.578,-0.357) 17(-1.721,0.532) 18(-1.721,-0.357) 19(1.778,-1.575) 20(-1.778,-1.575)
TX_POLYSWITCH_2P_87X59_H49
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
TX_QFN_22P_20_S161_2PAD
  rect 0.254x0.457 smd: 1(-1.25,-1.825) 2(-0.75,-1.825) 3(-0.25,-1.825) 4(0.25,-1.825) 5(0.75,-1.825) 6(1.25,-1.825) 12(1.25,1.825) 13(0.75,1.825) 14(0.25,1.825) 15(-0.25,1.825) 16(-0.75,1.825) 17(-1.25,1.825)
  custom 0.31x0.31 smd: 7(0.34,-0.877)
  custom 0.224x0.224 smd: 10(0.34,0.872)
  rect 0.457x0.254 smd: 18(-1.825,1.25) 19(-1.825,0.75) 20(-1.825,0.25) 21(-1.825,-0.25) 22(-1.825,-1.25)
TX_R0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0603_SHORT
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_SOD323_79X55_H45
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
TX_SOIC_6P_26_87X53_COLY
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
TX_SOIC_16P_50_413X299_WIN
  rect 0.61x1.905 smd: 1(-4.445,-4.807) 2(-3.175,-4.807) 3(-1.905,-4.807) 4(-0.635,-4.807) 5(0.635,-4.807) 6(1.905,-4.807) 7(3.175,-4.807) 8(4.445,-4.807) 9(4.445,4.807) 10(3.175,4.807) 11(1.905,4.807) 12(0.635,4.807) 13(-0.635,4.807) 14(-1.905,4.807) 15(-3.175,4.807) 16(-4.445,4.807)
TX_SOT23_2D4_122X55_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_2D4_122X55_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_2D4_T01_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_S5_2D4_T02X01_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
unnamed#2
  round 4.064 hole 4.064 unplated: (0,0)
unnamed#3
  custom 0.286x0.286 smd: 1(0,0)

## Nets
+1V_LAN: C4000.1 C4001.1 C4002.1 C4003.1 C4007.1 C4008.1 C4009.1 C4010.1 C4013.1 C4014.1 C4015.1 L4000.2 U114.3(AVDD10_1) U114.8(AVDD10_2) U114.22(DVDD10) U114.30(AVDD10_3)
+1V_ST_DISCH_A: Q93038.3(DRAIN) R93122.2
+5V: AC92.1 AC94.1 C178.1 C941623.1 CB171.1 HT56.1 HT57.1 HT58.1 HT59.1 HT60.1 J68.19 J69.27 J69.28 L82.1 L117.1 M1Q8.1(GATE) M1R19.1 O2Q2.4 P70.2 PC22.1 PC941612.1 PD4.1(ANODE1) PD4.2(ANODE2) PR27.1 PR90002.1 PR90009.1 PR93002.1 PR93009.1 PR93046.1 PR93051.1 PR93054.1 PR93061.1 PR93068.1 PU3.9(VDDP) PU8402.13(VOUT1_1) PU8402.14(VOUT1_2) Q9433.1(GATE) Q93025.2(SOURCE) R7202.1 R69684.1 R69695.1 R93107.1 SR7903.1 SR7907.1 SR7994.2 VD11.3(ANODE)
+5V3VA_IN: PC45.1 PC46.1 PC47.1 PC48.1 PC63.1 PC64.1 PL7.1 PL8.1 PL9.1 PL10.1 PQ7.2(D1_1) PQ7.3(D1_2) PQ7.4(D1_3) PQ7.10(D1_4) PQ8.2(D1_1) PQ8.3(D1_2) PQ8.4(D1_3) PQ8.10(D1_4) PR52.1
+5V_3V_VIN_C: PC50.1 PR52.2 PU4.12(VIN)
+5V_DISCH_A: Q9541.3(DRAIN) R69684.2
+5V_DUAL: C941490.1 C941491.1 J68.15 J68.17 M1C97.1 OR68.2 OR69.2 OR70.2 OR71.2 R70301.2 TUC27.1 UU65.1(OUT)
+5V_DUAL_OC: ST26.1 UU65.3(OC#)
+5V_HDD: C45.1 C306.1 L82.2 P110.P7(5V_POWER_PRECHARGE) P110.P8(5V_POWER_1) P110.P9(5V_POWER_2)
+5V_HDMI: F1.1 Q93025.3(DRAIN)
+5V_LDOOUT: PC53.1 PR50.2 PU4.13(LDO5)
+5VA: APR47.1 D3302.5(VP) D3602.5(VP) D3702.5(VP) OR143.2 OR151.1 PC941582.1 PC941605.1 PC941614.1 PR50.1 PR66.1 PR74.1 PU10.4(BIAS) PU8401.4(BIAS) PU8402.4(BIAS) R70294.1 R93115.2 SR700.2 SR701.1 SR702.1
+5VEN: ECR155.2 M1C99.2 PU8402.3(EN1)
+5VSB: APR46.1 C8301.1 C8302.1 C8303.1 C8304.1 C8305.1 C8306.1 C8307.1 C8308.1 HT51.1 HT52.1 HT53.1 HT54.1 HT55.1 M1C79.1 M1C82.1 M1C88.1 M1C96.1 M1C116.1 PC55.1 PC56.1 PC58.1 PCE5.1 PCE6.1 PJP6.1 PL11.2 PR25.1 PR59.2 PR99.1 PR117.1 PR124.1 PR1017.1 PR7608.1 PR8404.1 PR8410.1 PR89015.1 PR93097.1 PR93160.1 PR93161.1 R55.1 R59.1 UU19.5(IN) UU22.5(IN) UU64.5(IN) UU65.5(IN) UU66.5(IN)
+5VSB&+3P3VA_PG: PR58.2 PU4.7(PGOOD)
+5VSB_BST: PR53.1 PU4.17(BOOT1)
+5VSB_BST_RC: PC51.1 PR53.2
+5VSB_CS: PR60.2 PU4.1(CS1)
+5VSB_EN: PR64.2 PR70.2 PU4.20(EN1)
+5VSB_FB: PC61.2 PR61.2 PR62.1 PU4.2(FB1)
+5VSB_FB_RC: PC61.1 PC62.1 PJP6.2 PR61.1
+5VSB_HG: PR49.1 PU4.16(UGATE1)
+5VSB_HG_R: PC52.1 PQ7.1(G1) PR49.2 PR54.2
+5VSB_LG: PR55.1 PU4.15(LGATE1)
+5VSB_LG_R_D: PC57.1 PQ7.8(G2) PR55.2 PR57.1
+5VSB_PHASE: PC51.2 PC52.2 PL11.1 PQ7.9(S1/D2) PR54.1 PR56.1 PU4.18(PHASE1)
+5VSB_SN_C: PC59.1 PR56.2
+5VSB_VO1: PC60.1 PR59.1 PU4.14(BYP1)
+19V_VIN: D6301.1(ANODE) HT41.1 HT42.1 HT43.1 HT44.1 HT45.1 J1.5(V+_1) J1.6(V+_2) PL1.1 PL2.1 PL3.1 PL4.1
+19V_VIN_R_O2Q4: O2Q4.2 R93116.1 R93117.2
+19VA: PD1.2(CATHODE) PJP1.1 PQ1.5(DRAIN) PR1.1
+19VA_IN: PC1.1 PL1.2 PL2.2 PL3.2 PL4.2 PQ1.1(SOURCE1) PQ1.2(SOURCE2) PQ1.3(SOURCE3) PR2.1 PR3.1 PR4.1 PR5.1 PR9.1
+19VA_IN_ID: J1.9(ID) PC941620.1 PR8.1
+19VA_IN_PR61366_R: PJP1.2 PR11.2
+19VA_IN_R_C: PC4.1 PR2.2 PR3.2 PR4.2 PR5.2
+19VA_PR61365_R: PJP2.2 PR12.2
+19VA_R_SEN: PC5.1 PC941497.1 PR11.1 PU30.4(IN+)
+19VA_SB_SEN: PC5.2 PC941666.1 PR12.1 PU30.5(IN-)
+V3P3A_V1P8A_PCH_SPI: HR61.2 U1.AN44(VCCSPI)
+V3P3A_V1P8A_VCCPAZIO: C200.1 HR67.2 HR425.1
+V3P3A_V1P8A_VCCPGPPA: HR74.2 U1.AN32(VCCPGPPA)
+V3P3A_V1P8A_VCCPGPPD: HR72.2 U1.AN24(VCCPGPPD)
+VCCA_XTAL_1P05: HC11.2 HC12.2 HR423.1 U1.P2(VCCA_XTAL_1P05_1) U1.P3(VCCA_XTAL_1P05_2)
+VCCAMPHYPLL_1P05: HC19.2 HC20.2 HC21.2 HR422.1 U1.C49(VCCAMPHYPLL_1P05_1) U1.D49(VCCAMPHYPLL_1P05_2) U1.E49(VCCAMPHYPLL_1P05_3)
+VCCDPHY_1P24V: C86.1 HR73.1 U1.AJ22(VCCDPHY_1P24_1) U1.AJ23(VCCDPHY_1P24_2) U1.AK22(VCCDPHY_1P24_3) U1.AK23(VCCDPHY_1P24_4) U1.BG5(VCCDPHY_1P24_5)
+VCCDSW_1P05V: HC15.2 U1.BG45(VCCDSW_1P05_1) U1.BG46(VCCDSW_1P05_2)
+VCCGT: PC97024.1 PC97025.1 PC97026.1 PC97027.1 PC97028.1 PC97029.1 PC97030.1 PC97031.1 PC97032.1 PC97033.1 PC97034.1 PC97035.1 PC97036.1 PC97037.1 PC97038.1 PC97039.1 PC97040.1 PC97041.1 PC97042.1 PC97043.1 PCE97033.1 PCE97034.1 PCE97035.1 PCE97038.1 PJP89003.2 PJP93002.1 PJP93004.1 PL93001.2 PL93002.2 XU1.AA34(VCCGT_1) XU1.AA35(VCCGT_2) XU1.AA36(VCCGT_3) XU1.AA37(VCCGT_4) XU1.AA38(VCCGT_5) XU1.AB33(VCCGT_6) XU1.AB34(VCCGT_7) XU1.G36(VCCGT_8) XU1.G37(VCCGT_9) XU1.G38(VCCGT_10) XU1.G39(VCCGT_11) XU1.G40(VCCGT_12) XU1.H36(VCCGT_13) XU1.H38(VCCGT_14) XU1.H40(VCCGT_15) XU1.J36(VCCGT_16) XU1.J37(VCCGT_17) XU1.J38(VCCGT_18) XU1.J39(VCCGT_19) XU1.J40(VCCGT_20) XU1.K36(VCCGT_21) XU1.K38(VCCGT_22) XU1.K40(VCCGT_23) XU1.L34(VCCGT_24) XU1.L35(VCCGT_25) XU1.L36(VCCGT_26) XU1.L37(VCCGT_27) XU1.L38(VCCGT_28) XU1.L39(VCCGT_29) XU1.L40(VCCGT_30) XU1.M33(VCCGT_31) XU1.M34(VCCGT_32) XU1.M36(VCCGT_33) XU1.M38(VCCGT_34) XU1.M40(VCCGT_35) XU1.N34(VCCGT_36) XU1.N35(VCCGT_37) XU1.N36(VCCGT_38) XU1.N37(VCCGT_39) XU1.N38(VCCGT_40) XU1.N39(VCCGT_41) XU1.N40(VCCGT_42) XU1.P33(VCCGT_43) XU1.P34(VCCGT_44) XU1.P36(VCCGT_45) XU1.P38(VCCGT_46) XU1.P40(VCCGT_47) XU1.R34(VCCGT_48) XU1.R35(VCCGT_49) XU1.R36(VCCGT_50) XU1.R37(VCCGT_51) XU1.R38(VCCGT_52) XU1.R39(VCCGT_53) XU1.R40(VCCGT_54) XU1.T33(VCCGT_55) XU1.T34(VCCGT_56) XU1.T36(VCCGT_57) XU1.T38(VCCGT_58) XU1.T40(VCCGT_59) XU1.U34(VCCGT_60) XU1.U35(VCCGT_61) XU1.U36(VCCGT_62) XU1.U37(VCCGT_63) XU1.U38(VCCGT_64) XU1.U39(VCCGT_65) XU1.U40(VCCGT_66) XU1.V33(VCCGT_67) XU1.V34(VCCGT_68) XU1.V36(VCCGT_69) XU1.V38(VCCGT_70) XU1.V40(VCCGT_71) XU1.W34(VCCGT_72) XU1.W35(VCCGT_73) XU1.W36(VCCGT_74) XU1.W37(VCCGT_75) XU1.W38(VCCGT_76) XU1.Y33(VCCGT_77) XU1.Y34(VCCGT_78) XU1.Y36(VCCGT_79) XU1.Y38(VCCGT_80)
+VCCIO_EN: PC24.1 PR29.2 PU3.14(LEN) R3.1 R99518.2
+VCCIO_EN_DISCH_A: Q7.3(DRAIN) R3.2
+VCCIO_FB: PC35.1 PR35.2 PR37.2 PR39.1
+VCCIO_FB_R: PJP6801.1 PR35.1
+VCCIO_LDRV_A: PC28.2 PC35.2 PR39.2 PR42.1 PU3.6(LFB)
+VCCIO_LDRV_C: PC28.1 PQ5.4(G) PR32.1 PU3.7(LDRV)
+VCCIO_LDVR: PC30.1 PR32.2
+VCCPDSW_3P3V: R99515.2 SCB125.1 SCB127.1 U1.BE48(VCCDSW_3P3_1) U1.BE49(VCCDSW_3P3_2)
+VCCPHVLDO_1P8V: C941644.1 HR66.2 SR338.1 U1.AF19(VCCPHVLDO_1P8_1) U1.AF20(VCCPHVLDO_1P8_2)
+VCCPLL_OC_W20MIL: HR63.2 HR64.2 XU1.AJ9(VCCPLL_OC)
+VCCPRIM_1P05: C8313.1 C8314.1 C8315.1 HC13.2 HC14.2 HC16.2 HC17.2 HC18.2 HC23.2 HC24.2 HC25.2 HC26.2 HC27.2 HC28.2 HC29.2 R60757.2 R60758.2 R60759.2 R60760.2 R60761.2 U1.AA22(VCCPRIM_1P05_1) U1.AA23(VCCPRIM_1P05_2) U1.AB20(VCCPRIM_1P05_3) U1.AB22(VCCPRIM_1P05_4) U1.AB23(VCCPRIM_1P05_5) U1.AB27(VCCPRIM_1P05_6) U1.AB28(VCCPRIM_1P05_7) U1.AB30(VCCPRIM_1P05_8) U1.AD20(VCCPRIM_1P05_9) U1.AD23(VCCPRIM_1P05_10) U1.AD27(VCCPRIM_1P05_11) U1.AD28(VCCPRIM_1P05_12) U1.AD30(VCCPRIM_1P05_13) U1.AD31(VCCPRIM_1P05_14) U1.AE17(VCCPRIM_1P05_15) U1.AF23(VCCPRIM_1P05_16) U1.AF27(VCCPRIM_1P05_17) U1.AF30(VCCPRIM_1P05_18) U1.AF31(VCCPRIM_1P05_19) U1.AG31(VCCPRIM_1P05_20) U1.B1(VCCAPLL_1P05_1) U1.B2(VCCAPLL_1P05_2) U1.B3(VCCAPLL_1P05_3) U1.C1(VCCAPLL_1P05_4) U1.C2(VCCAPLL_1P05_5) U1.D1(VCCPRIM_1P05_21) U1.E1(VCCPRIM_1P05_22) U1.U26(VCCPRIM_1P05_23) U1.U29(VCCPRIM_1P05_24) U1.V19(VCCA_BCLK_1P05) U1.V25(VCCPRIM_1P05_25) U1.V27(VCCPRIM_1P05_26) U1.V28(VCCPRIM_1P05_27) U1.V30(VCCPRIM_1P05_28) U1.V31(VCCPRIM_1P05_29) U1.W19(VCCA_SRC_1P05_1) U1.W20(VCCA_SRC_1P05_2) U1.W22(VCCDUSB_1P05_1) U1.W23(VCCDUSB_1P05_2) U1.W31(VCCPRIM_MPHY_1P05)
+VCCPRIM_1P8_3P3: HR59.2 SCB122.2 SCB123.2 SCB124.2 U1.AC35(VCCPGPPHK_1) U1.AC36(VCCPGPPHK_2) U1.AE35(VCCPGPPEF_1) U1.AE36(VCCPGPPEF_2) U1.AN26(VCCPGPPBC_1) U1.AP26(VCCPGPPBC_2)
+VCCPRIM_1P8V: C941643.1 HR66.1 HR72.1 HR424.2 SR7919.2 SR7921.2 SR7924.2 SR7996.1 SR7997.1 U1.AG19(VCCPRIM_1P8_1) U1.AG20(VCCPRIM_1P8_2) U1.AN15(VCCPRIM_1P8_3) U1.AR15(VCCPRIM_1P8_4) U1.BB11(VCCPRIM_1P8_5)
+VCCSA: PC27.1 PC38.1 PC39.1 PC40.1 PC41.1 PC42.1 PC43.1 PC44.1 PCE3.1 PCE4.1 PJP4.1 PL93010.2 R651.1 XU1.AA6(VCCSA_1) XU1.AA7(VCCSA_2) XU1.AB6(VCCSA_3) XU1.AB7(VCCSA_4) XU1.AB8(VCCSA_5) XU1.AC7(VCCSA_6) XU1.AC8(VCCSA_7) XU1.N7(VCCSA_8) XU1.P7(VCCSA_9) XU1.R7(VCCSA_10) XU1.T7(VCCSA_11) XU1.U7(VCCSA_12) XU1.V7(VCCSA_13) XU1.W7(VCCSA_14) XU1.Y6(VCCSA_15) XU1.Y7(VCCSA_16) XU1.Y8(VCCSA_17)
+VCCSA_BOOT: PR28.1 PU3.13(BOOT)
+VCCSA_BOOT_25: PC23.2 PD4.3(CATHODE) PR28.2
+VCCSA_FB_A: PC37.2 PR44.1 PR47.1 PU3.3(FB)
+VCCSA_HG_D: PR30.1 PU3.12(UGATE)
+VCCSA_HG_R_D: PC26.1 PQ93040.1(G1) PR30.2 PR31.2
+VCCSA_ILIM_A: PR34.1 PU3.10(OC)
+VCCSA_ILIM_R_A: PJP3.2 PR34.2
+VCCSA_IN_PQ: JP1.1 PR26.1
+VCCSA_LG_D: PR36.1 PU3.8(LGATE)
+VCCSA_LG_R_D: PC34.1 PQ93040.8(G2) PR36.2 PR38.2
+VCCSA_PHASE_D: PC23.1 PC26.2 PC29.1 PJP3.1 PL93010.1 PQ93040.9(S1/D2) PR31.1 PR33.1 PU3.11(PHASE)
+VCCSA_SN: PC32.1 PR33.2
+VCCSA_TON: PR26.2 PU3.16(TON)
+VCCSA_VDD: PC17.1 PR25.2 PU3.2(VDD)
+VCCSA_VIN: JP1.2 PC19.1 PC20.1 PQ93040.2(D1_1) PQ93040.3(D1_2) PQ93040.4(D1_3) PQ93040.10(D1_4) PR6801.1
+VCCSA_VOUT_A: PR41.1 PU3.1(VOUT)
+VCCSA_VOUT_R_A: PJP4.2 PR43.2
+VCCST: HC4.1 HC5.1 HR14.1 HR15.1 HR29.1 HR30.1 HR58.2 HR91.1 HR347.1 O2CB10.1 OR3.1 PC106.1 PC89001.1 PQ21.4 PQ21.7 PR89001.1 PR89002.2 PR89013.1 PR93063.1 R6502.1 R70295.1 R93122.1 SR259.1 SR763.1 SR765.1 SR766.1 SR769.1 U104.29(PECIVREF) XU1.V4(VCCPLL) XU1.V5(VCCST_1) XU1.V6(VCCST_2)
AVDD1: AC12.1 AC13.1 L129.2 U6.26(AVDD1)
AVDD2: AC90.1 L16.2 U6.40(AVDD2)
DVDD: AC3.1 AC4.1 AC5.1 AC52.1 L120.2 R181.2 SR280.1 U6.1(DVDD) U6.9(DVDD-IO)
GND: AC1.2 AC3.2 AC4.2 AC5.2 AC6.2 AC20.2 AC24.2 AC25.2 AC47.2 AC52.2 AC53.2 AC70.2 AC82.2 AC88.2 AC92.2 AC93.2 AC94.2 AC95.2 AC96.2 AC204.1 AC207.2 AC208.2 AC209.2 APR122.2 APR134.1 APR135.1 AQ19.1(S1) AQ19.4(S2) AQ20.1(S1) AQ20.4(S2) C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C15.2 C16.2 C17.2 C18.2 C45.2 C49.2 C81.2 C82.2 C83.2 C85.2 C86.2 C94.2 C97.2 C98.2 C178.2 C200.2 C201.2 C202.2 C204.2 C205.2 C206.2 C207.2 C248.2 C249.2 C306.2 C316.2 C2715.2 C2726.2 C3101.1 C3102.1 C3907.2 C4000.2 C4001.2 C4002.2 C4003.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4011.2 C4013.2 C4014.2 C4015.2 C4016.2 C4017.2 C4022.1 C4023.1 C4024.2 C7201.2 C7202.2 C7203.2 C7204.2 C7205.2 C7206.2 C7207.2 C7208.1 C7209.2 C7210.2 C8301.2 C8302.2 C8303.2 C8304.2 C8305.2 C8306.2 C8307.2 C8308.2 C8309.2 C8310.2 C8311.2 C8312.2 C8313.2 C8314.2 C8315.2 C8316.2 C9478.2 C941488.2 C941489.2 C941490.2 C941491.2 C941492.2 C941623.2 C941625.2 C941629.2 C941631.2 C941632.2 C941633.2 C941634.2 C941635.2 C941636.2 C941643.2 C941644.2 C941645.2 C941646.2 C941647.2 C941648.2 C941649.2 CB171.2 CB4132.1 CB4133.1 CB4134.1 CB4135.1 CB4152.2 CR4.2(CATHODE) CR5.2(CATHODE) CR6.2(CATHODE) CR22.2(CATHODE) CR23.2(CATHODE) D4C1.2 D4C2.2 D4C3.2 D4C4.2 D4C5.2 D4C6.2 D4C7.2 D4C8.2 D4C9.2 D4C10.2 D4C11.2 D4C12.2 D4C13.2 D4C14.2 D4C15.2 D4C16.2 D4C17.2 D4C18.2 D4C19.2 D4C20.2 D4C21.2 D4C22.2 D4C23.1 D4C24.1 D4C25.2 D4C26.2 D4C27.2 D4C28.2 D4C29.2 D4C31.2 D4C32.2 D4C33.2 D4C34.2 D4CB1.2 D4CB2.2 D4CB3.2 D4CB4.2 D4CB5.2 D4CB6.2 D4CB7.2 D4CB8.2 D4CB9.2 D4CB10.2 D4CB11.2 D4CB12.2 D4CB13.2 D4CB14.2 D4CB15.2 D4CB16.2 D4CB17.2 D4CB18.2 D4CB19.2 D4CB20.2 D4CB21.2 D4CB22.2 D4CB23.2 D4CB24.2 D4CE1.2 D4CE2.2 D4R9.2 D4R10.2 D4R11.2 D4R12.2 D4R20.2 D4R21.2 D4R22.2 D4R23.2 D519.2(CATHODE) D521.1(ANODE1) D3103.2(CATHODE) D3104.2(CATHODE) D3105.2(CATHODE) D3106.2(CATHODE) D3301.3(GND1) D3301.8(GND2) D3302.2(VN) D3601.3(GND1) D3601.8(GND2) D3602.2(VN) D3603.3(GND1) D3603.8(GND2) D3702.2(VN) D4003.3(GND1) D4003.8(GND2) D4310.2(CATHODE) D5501.1(ANODE) D5502.1(ANODE) D5503.1(ANODE) D6301.2(CATHODE) DIMM1.1(VSS1) DIMM1.2(VSS2) DIMM1.5(VSS3) DIMM1.6(VSS4) DIMM1.9(VSS5) DIMM1.10(VSS6) DIMM1.14(VSS7) DIMM1.15(VSS8) DIMM1.18(VSS9) DIMM1.19(VSS10) DIMM1.22(VSS11) DIMM1.23(VSS12) DIMM1.26(VSS13) DIMM1.27(VSS14) DIMM1.30(VSS15) DIMM1.31(VSS16) DIMM1.35(VSS17) DIMM1.36(VSS18) DIMM1.39(VSS19) DIMM1.40(VSS20) DIMM1.43(VSS21) DIMM1.44(VSS22) DIMM1.47(VSS23) DIMM1.48(VSS24) DIMM1.51(VSS25) DIMM1.52(VSS26) DIMM1.56(VSS27) DIMM1.57(VSS28) DIMM1.60(VSS29) DIMM1.61(VSS30) DIMM1.64(VSS31) DIMM1.65(VSS32) DIMM1.68(VSS33) DIMM1.69(VSS34) DIMM1.72(VSS35) DIMM1.73(VSS36) DIMM1.77(VSS37) DIMM1.78(VSS38) DIMM1.81(VSS39) DIMM1.82(VSS40) DIMM1.85(VSS41) DIMM1.86(VSS42) DIMM1.89(VSS43) DIMM1.90(VSS44) DIMM1.93(VSS45) DIMM1.94(VSS46) DIMM1.98(VSS47) DIMM1.99(VSS48) DIMM1.102(VSS49) DIMM1.103(VSS50) DIMM1.106(VSS51) DIMM1.107(VSS52) DIMM1.167(VSS53) DIMM1.168(VSS54) DIMM1.171(VSS55) DIMM1.172(VSS56) DIMM1.175(VSS57) DIMM1.176(VSS58) DIMM1.180(VSS59) DIMM1.181(VSS60) DIMM1.184(VSS61) DIMM1.185(VSS62) DIMM1.188(VSS63) DIMM1.189(VSS64) DIMM1.192(VSS65) DIMM1.193(VSS66) DIMM1.196(VSS67) DIMM1.197(VSS68) DIMM1.201(VSS69) DIMM1.202(VSS70) DIMM1.205(VSS71) DIMM1.206(VSS72) DIMM1.209(VSS73) DIMM1.210(VSS74) DIMM1.213(VSS75) DIMM1.214(VSS76) DIMM1.217(VSS77) DIMM1.218(VSS78) DIMM1.222(VSS79) DIMM1.223(VSS80) DIMM1.226(VSS81) DIMM1.227(VSS82) DIMM1.230(VSS83) DIMM1.231(VSS84) DIMM1.234(VSS85) DIMM1.235(VSS86) DIMM1.238(VSS87) DIMM1.239(VSS88) DIMM1.243(VSS89) DIMM1.244(VSS90) DIMM1.247(VSS91) DIMM1.248(VSS92) DIMM1.251(VSS93) DIMM1.252(VSS94) DIMM1.263(SIDE1) DIMM1.264(SIDE2) DIMM2.1(VSS1) DIMM2.2(VSS2) DIMM2.5(VSS3) DIMM2.6(VSS4) DIMM2.9(VSS5) DIMM2.10(VSS6) DIMM2.14(VSS7) DIMM2.15(VSS8) DIMM2.18(VSS9) DIMM2.19(VSS10) DIMM2.22(VSS11) DIMM2.23(VSS12) DIMM2.26(VSS13) DIMM2.27(VSS14) DIMM2.30(VSS15) DIMM2.31(VSS16) DIMM2.35(VSS17) DIMM2.36(VSS18) DIMM2.39(VSS19) DIMM2.40(VSS20) DIMM2.43(VSS21) DIMM2.44(VSS22) DIMM2.47(VSS23) DIMM2.48(VSS24) DIMM2.51(VSS25) DIMM2.52(VSS26) DIMM2.56(VSS27) DIMM2.57(VSS28) DIMM2.60(VSS29) DIMM2.61(VSS30) DIMM2.64(VSS31) DIMM2.65(VSS32) DIMM2.68(VSS33) DIMM2.69(VSS34) DIMM2.72(VSS35) DIMM2.73(VSS36) DIMM2.77(VSS37) DIMM2.78(VSS38) DIMM2.81(VSS39) DIMM2.82(VSS40) DIMM2.85(VSS41) DIMM2.86(VSS42) DIMM2.89(VSS43) DIMM2.90(VSS44) DIMM2.93(VSS45) DIMM2.94(VSS46) DIMM2.98(VSS47) DIMM2.99(VSS48) DIMM2.102(VSS49) DIMM2.103(VSS50) DIMM2.106(VSS51) DIMM2.107(VSS52) DIMM2.167(VSS53) DIMM2.168(VSS54) DIMM2.171(VSS55) DIMM2.172(VSS56) DIMM2.175(VSS57) DIMM2.176(VSS58) DIMM2.180(VSS59) DIMM2.181(VSS60) DIMM2.184(VSS61) DIMM2.185(VSS62) DIMM2.188(VSS63) DIMM2.189(VSS64) DIMM2.192(VSS65) DIMM2.193(VSS66) DIMM2.196(VSS67) DIMM2.197(VSS68) DIMM2.201(VSS69) DIMM2.202(VSS70) DIMM2.205(VSS71) DIMM2.206(VSS72) DIMM2.209(VSS73) DIMM2.210(VSS74) DIMM2.213(VSS75) DIMM2.214(VSS76) DIMM2.217(VSS77) DIMM2.218(VSS78) DIMM2.222(VSS79) DIMM2.223(VSS80) DIMM2.226(VSS81) DIMM2.227(VSS82) DIMM2.230(VSS83) DIMM2.231(VSS84) DIMM2.234(VSS85) DIMM2.235(VSS86) DIMM2.238(VSS87) DIMM2.239(VSS88) DIMM2.243(VSS89) DIMM2.244(VSS90) DIMM2.247(VSS91) DIMM2.248(VSS92) DIMM2.251(VSS93) DIMM2.252(VSS94) DIMM2.263(SIDE1) DIMM2.264(SIDE2) E16.8 E61.10 ECR129.2 ECR130.2 ECR131.2 ECR132.2 FCB1.2 FCB2.2 H1.2(GND1) H1.3(GND2) H1.4(GND3) H1.5(GND4) H1.6(GND5) H1.7(GND6) H1.8(GND7) H1.9(GND8) H2.2(GND1) H2.3(GND2) H2.4(GND3) H2.5(GND4) H2.6(GND5) H2.7(GND6) H2.8(GND7) H2.9(GND8) H3.2(GND1) H3.3(GND2) H3.4(GND3) H3.5(GND4) H3.6(GND5) H3.7(GND6) H3.8(GND7) H3.9(GND8) H4.2(GND1) H4.3(GND2) H4.4(GND3) H4.5(GND4) H4.6(GND5) H4.7(GND6) H4.8(GND7) H4.9(GND8) H5.2(GND1) H5.3(GND2) H5.4(GND3) H5.5(GND4) H5.6(GND5) H5.7(GND6) H5.8(GND7) H5.9(GND8) H6.2(GND1) H6.3(GND2) H6.4(GND3) H6.5(GND4) H6.6(GND5) H6.7(GND6) H6.8(GND7) H6.9(GND8) H7.2(GND1) H7.3(GND2) H7.4(GND3) H7.5(GND4) H7.6(GND5) H7.7(GND6) H7.8(GND7) H7.9(GND8) H8.2(GND1) H8.3(GND2) H8.4(GND3) H8.5(GND4) H8.6(GND5) H8.7(GND6) H8.8(GND7) H8.9(GND8) H9.3(GND1) H9.4(GND2) H9.5(GND3) H9.6(GND4) H9.7(GND5) H9.8(GND6) H9.9(GND7) H9.10(GND8) H10.3(GND1) H10.4(GND2) H10.5(GND3) H10.6(GND4) H10.7(GND5) H10.8(GND6) H10.9(GND7) H11.2(GND1) H11.3(GND2) H11.4(GND3) H11.5(GND4) H11.6(GND5) H11.7(GND6) H11.8(GND7) H11.9(GND8) H13.1 H14.1 HC3.2 HC4.2 HC5.2 HC6.2 HC7.2 HC11.1 HC12.1 HC13.1 HC14.1 HC15.1 HC16.1 HC17.1 HC18.1 HC19.1 HC20.1 HC21.1 HC23.1 HC24.1 HC25.1 HC26.1 HC27.1 HC28.1 HC29.1 HC30.2 HC31.2 HCB3.1 HCB4.2 HCB5.1 HCB6.1 HEATSINK.1 HEATSINK.2 HQ1.2(EMITTER) HQ2.2(EMITTER) HR7.2 HR8.2 HR36.2 HR37.2 HR38.2 HR39.2 HR40.2 HR41.2 HR42.2 HR43.2 HR44.2 HR45.2 HR46.2 HR47.2 HR48.2 HR49.2 HR54.2 HR55.2 HR57.2 HR64.1 HR81.2 HR82.2 HR83.2 HR84.2 HR85.2 HR346.1 HR383.2 HT76.1 HT77.1 HT78.1 HT79.1 HT80.1 HT81.1 HT82.1 HT83.1 J1.1 J1.2 J1.3 J1.4 J1.7(V-_1) J1.8(V-_2) J12.4(GND_1) J12.7(GND_2) J12.13(GND_3) J12.16(GND_4) J12.19(P_GND1) J12.20(P_GND2) J12.21(P_GND3) J12.22(P_GND4) J13.4 J13.8 J13.9(P_GND1) J13.10(P_GND2) J13.11(P_GND3) J13.12(P_GND4) J68.1 J68.2 J68.7 J68.12 J68.13 J68.18 J68.25(GND1) J68.26(GND2) J69.1 J69.4 J69.7 J69.10 J69.13 J69.16 J69.19 J69.31(SIDE1) J69.32(SIDE2) J69.33(SIDE3) J69.34(SIDE4) J125.2 J125.5 J125.8 J125.11 J125.17 J125.20(P_GND1) J125.21(P_GND2) J125.22(P_GND3) J125.23(P_GND4) J133.4(GND) J133.7(GND_DRAIN) J133.10(P_GND1) J133.11(P_GND2) J200.4(GND) J200.7(GND_DRAIN) J200.10(P_GND1) J200.11(P_GND2) J218.7(GND_7) J218.13(SDIO_DATA0) J218.18(GND_18) J218.33(GND_33) J218.39(GND_39) J218.45(GND_45) J218.57(GND_57) J218.63(GND_63) J218.69(GND_69) J218.75(GND_75) J218.76(SIDE1) J218.77(SIDE2) J219.3 J219.9 J219.15 J219.21 J219.27 J219.33 J219.39 J219.45 J219.51 J219.57 J219.71 J219.73 J219.75 J219.76(SIDE1) J219.77(SIDE2) J302.2(GND_1) J302.5(GND_2) J302.8(GND) J302.11(GND_3) J302.16(GND_4) J302.19(RETURN) J302.21(P_GND_1) J302.22(P_GND_2) J302.23(P_GND_3) J302.24(P_GND_4) J303.7 JMP1.4 JP2801.1 JP2801.2 LC3.2 LC4.2 LC5.2 LC6.2 LC7.2 LC8.2 LC9.2 M1C43.1 M1C44.1 M1C49.1 M1C50.1 M1C51.1 M1C52.1 M1C66.2 M1C67.2 M1C73.2 M1C79.2 M1C80.2 M1C82.2 M1C83.2 M1C88.2 M1C89.2 M1C96.2 M1C97.2 M1C99.1 M1C100.2 M1C102.2 M1C112.2 M1C113.2 M1C114.2 M1C115.2 M1C116.2 M1Q9.2(SOURCE) M1R10.2 M1R14.1 M1R15.1 M1R19.2 M1R20.2 M1R22.2 M1U3.3(GND1) M1U3.8(GND2) M1U4.3(GND1) M1U4.8(GND2) MC5401.1 MC5402.1 MC8301.1 MC8302.1 MC8303.1 MC8304.1 MC8305.1 MQ27.2(SOURCE) MR5401.1 MR5402.1 MR5403.1 O2CB1.2 O2CB2.2 O2CB3.2 O2CB4.2 O2CB5.2 O2CB6.2 O2CB7.2 O2CB8.2 O2CB10.2 O2CB11.2 O2CB15.2 O2CB16.2 O2CB17.2 O2CB19.2 O2CB20.2 O2CB21.2 O2Q4.1 O2Q4.4 O2Q5.1 O2Q5.4 O2R9.2 O2R10.1 O2R14.2 O2R24.1 OR34.1 OR59.2 OR118.2 OR144.1 OR152.1 OR154.2 P6.4 P12.9 P12.11 P70.3 P110.1(P_GND1) P110.2(P_GND2) P110.3(P_GND3) P110.4(P_GND4) P110.P4(GROUND_4) P110.P5(GROUND_5) P110.P6(GROUND_6) P110.P10(DEVICE_PRESENT) P110.S1(GROUND_1) P110.S4(GROUND_2) P110.S7(GROUND_3) P305.2 P466.8 P466.10 P466.12 P466.14 PC4.2 PC17.2 PC19.2 PC20.2 PC21.2 PC22.2 PC24.2 PC25.2 PC27.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC36.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.2 PC49.2 PC50.2 PC53.2 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC60.2 PC62.2 PC63.2 PC64.2 PC67.2 PC68.2 PC69.2 PC70.2 PC71.2 PC72.2 PC73.2 PC75.2 PC76.2 PC78.2 PC79.2 PC81.2 PC92.2 PC93.2 PC94.2 PC95.2 PC97.2 PC99.2 PC102.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC115.2 PC116.2 PC117.2 PC119.2 PC120.2 PC121.2 PC122.2 PC124.2 PC125.2 PC126.2 PC127.2 PC128.2 PC129.2 PC134.2 PC135.2 PC760.2 PC761.2 PC802.2 PC803.2 PC804.2 PC808.2 PC812.2 PC813.2 PC814.2 PC815.2 PC816.2 PC998.2 PC999.2 PC6301.1 PC6302.2 PC6303.2 PC6304.2 PC6305.2 PC6306.2 PC6307.2 PC6308.2 PC7310.2 PC7601.2 PC7602.2 PC7604.2 PC7605.2 PC7606.2 PC7801.2 PC7802.2 PC7899.2 PC8498.2 PC8499.2 PC9001.2 PC9002.2 PC9003.2 PC9416.2 PC89001.2 PC89002.2 PC89004.2 PC89005.2 PC89006.2 PC89007.2 PC89009.2 PC89011.2 PC89015.2 PC89017.2 PC89021.2 PC89022.1 PC89028.2 PC89029.2 PC89033.2 PC89035.1 PC89036.2 PC89037.2 PC90001.2 PC90002.2 PC90003.2 PC90007.2 PC90008.2 PC90009.2 PC90010.2 PC90012.2 PC90013.2 PC90018.2 PC90019.2 PC90020.2 PC90021.2 PC90100.2 PC93001.2 PC93002.2 PC93003.2 PC93007.1 PC93008.2 PC93009.2 PC93010.2 PC93012.2 PC93013.2 PC93018.2 PC93019.2 PC93020.2 PC93021.2 PC97001.2 PC97002.2 PC97003.2 PC97004.2 PC97005.2 PC97006.2 PC97007.2 PC97008.2 PC97009.2 PC97010.2 PC97011.2 PC97012.2 PC97013.2 PC97014.2 PC97015.2 PC97016.2 PC97017.2 PC97018.2 PC97019.2 PC97020.2 PC97021.2 PC97022.2 PC97023.2 PC97024.2 PC97025.2 PC97026.2 PC97027.2 PC97028.2 PC97029.2 PC97030.2 PC97031.2 PC97032.2 PC97033.2 PC97034.2 PC97035.2 PC97036.2 PC97037.2 PC97038.2 PC97039.2 PC97040.2 PC97041.2 PC97042.2 PC97043.2 PC941483.2 PC941484.2 PC941485.2 PC941488.2 PC941489.2 PC941490.2 PC941491.2 PC941492.2 PC941493.2 PC941494.2 PC941496.2 PC941497.2 PC941502.2 PC941579.2 PC941580.2 PC941582.2 PC941584.1 PC941585.1 PC941586.2 PC941587.2 PC941589.2 PC941590.2 PC941601.2 PC941602.2 PC941603.2 PC941604.2 PC941605.2 PC941608.2 PC941609.2 PC941610.2 PC941611.2 PC941612.2 PC941613.2 PC941614.2 PC941617.2 PC941618.2 PC941619.2 PC941620.2 PC941622.2 PC941623.2 PC941626.2 PC941663.2 PC941664.2 PC941665.2 PC941666.2 PC941667.2 PC941669.2 PC941670.2 PC941671.2 PCE2.2 PCE3.2 PCE4.2 PCE5.2 PCE6.2 PCE7.2 PCE9.2 PCE31.2 PCE125.2 PCE690.2 PCE97027.2 PCE97028.2 PCE97030.2 PCE97031.2 PCE97032.2 PCE97033.2 PCE97034.2 PCE97035.2 PCE97037.2 PCE97038.2 PD1.1(ANODE) PJP89002.2 PJP89004.2 PQ7.5(S2_1) PQ7.6(S2_2) PQ7.7(S2_3) PQ8.5(S2_1) PQ8.6(S2_2) PQ8.7(S2_3) PQ22.1(EMITTER1) PQ23.5(S2_1) PQ23.6(S2_2) PQ23.7(S2_3) PQ24.2(SOURCE) PQ25.2(SOURCE) PQ45.2(SOURCE) PQ101.2(EMITTER) PQ6301.2(SOURCE) PQ9823.2(SOURCE) PQ90001.9(GND(LSS)) PQ90001.11(GND(LSS)_1) PQ90001.12(GND(LSS)_2) PQ90001.13(GND(LSS)_3) PQ90001.14(GND(LSS)_4) PQ90001.15(GND(LSS)_5) PQ90001.16(GND(LSS)_6) PQ90001.17(GND(LSS)_7) PQ90001.18(GND(LSS)_8) PQ93001.5(S2_1) PQ93002.5(S2_1) PQ93008.9(GND(LSS)) PQ93008.11(GND(LSS)_1) PQ93008.12(GND(LSS)_2) PQ93008.13(GND(LSS)_3) PQ93008.14(GND(LSS)_4) PQ93008.15(GND(LSS)_5) PQ93008.16(GND(LSS)_6) PQ93008.17(GND(LSS)_7) PQ93008.18(GND(LSS)_8) PQ93010.2(SOURCE) PQ93012.2(SOURCE) PQ93018.9(GND(LSS)) PQ93018.11(GND(LSS)_1) PQ93018.12(GND(LSS)_2) PQ93018.13(GND(LSS)_3) PQ93018.14(GND(LSS)_4) PQ93018.15(GND(LSS)_5) PQ93018.16(GND(LSS)_6) PQ93018.17(GND(LSS)_7) PQ93018.18(GND(LSS)_8) PQ93030.2(SOURCE) PQ93031.2(SOURCE) PQ93040.5(S2_1) PQ93040.6(S2_2) PQ93040.7(S2_3) PR10.2 PR38.1 PR40.2 PR46.2 PR47.2 PR57.2 PR60.1 PR62.2 PR63.1 PR73.2 PR76.2 PR113.2 PR120.2 PR122.1 PR136.2 PR139.2 PR141.2 PR761.1 PR1016.1 PR7301.2 PR7602.2 PR7701.1 PR89019.2 PR89035.1 PR89036.2 PR89038.2 PR89040.1 PR89041.2 PR89046.2 PR89049.2 PR89063.1 PR89064.1 PR89065.1 PR89070.2 PR89071.2 PR89073.2 PR90008.2 PR90016.2 PR93008.2 PR93016.2 PR93024.2 PR93026.1 PR93028.2 PR93060.2 PR93062.2 PR93099.2 PR93162.1 PR93163.1 PR93164.1 PR93165.1 PRT89003.2 PRT89004.2 PT156.1 PT157.1 PT158.1 PT159.1 PT160.1 PT161.1 PT162.1 PT163.1 PU3.17(GND) PU3.18(GND2) PU3.19(GND1) PU4.21(GND0) PU4.22(GND1) PU4.23(GND2) PU4.24(GND3) PU4.25(GND4) PU5.4(AGND) PU5.12(PGND1) PU5.13(PGND2) PU5.14(PGND3) PU5.15(PGND4) PU5.19(PGND5) PU6.8(GND1) PU6.9(GND2) PU6.10(GND3) PU6.11(GND4) PU6.12(GND5) PU6.13(GND6) PU7.2(GND) PU9.1(VTTGND) PU9.3(GND1) PU9.14(PGND) PU9.21(GND2) PU9.22(GND3) PU9.23(GND4) PU9.24(GND5) PU9.25(GND6) PU10.11(GND1) PU10.15(GND2) PU30.1(REF) PU30.2(GND) PU76.2(GND) PU7601.8(GND1) PU7601.9(GND2) PU7601.10(GND3) PU7601.11(GND4) PU7601.12(GND5) PU7601.13(GND6) PU8401.11(GND1) PU8401.15(GND2) PU8402.11(GND1) PU8402.15(GND2) PU89001.53(AGND) PU89001.54(AGND1) PU89001.55(AGND2) PU89001.56(AGND3) PU89001.57(AGND4) PU90001.6(GND) PU90001.9(FLAG) PU90002.6(GND) PU90002.9(FLAG) PU93001.6(GND) PU93001.9(FLAG) PU93002.6(GND) PU93002.9(FLAG) PU93003.4(VEE) PU93004.6(GND) PU93004.9(FLAG) Q5.2(SOURCE) Q6.2(SOURCE) Q7.2(SOURCE) Q8.2(SOURCE) Q16.2(SOURCE) Q17.2(SOURCE) Q93.2(SOURCE) Q940.2(SOURCE) Q941.2(SOURCE) Q942.2(SOURCE) Q9308.2(SOURCE) Q9309.2(SOURCE) Q9346.2(EMITTER) Q9434.2(SOURCE) Q9435.2(SOURCE) Q9436.2(SOURCE) Q9437.2(SOURCE) Q9438.2(EMITTER) Q9534.2(SOURCE) Q9535.2(SOURCE) Q9537.2(SOURCE) Q9540.2(SOURCE) Q9541.2(SOURCE) Q9542.2(SOURCE) Q9543.2(SOURCE) Q9544.2(SOURCE) Q93033.1(EMITTER1) Q93035.2(EMITTER) Q93037.2(SOURCE) Q93038.2(SOURCE) R79.2 R113.2 R2103.2 R2104.2 R2343.2 R2344.2 R2347.2 R2348.2 R2351.2 R2352.2 R3106.2 R3107.2 R3110.2 R4002.2 R4006.2 R4010.2 R4816.2 R7209.2 R7213.1 R70259.1 R70261.1 R70301.1 R93100.2 R93105.1 R93108.2 R93117.1 R93118.1 R99508.2 R99511.1 R99513.1 R99516.2 R99517.1 R99523.1 R99529.2 RF3.2 RO2.2 S1C80.1 S1C81.2 SC12.2 SC13.2 SC14.2 SC15.2 SC16.2 SC17.2 SC18.2 SC19.2 SC20.2 SC21.2 SC22.2 SC23.2 SC24.2 SC25.2 SC26.2 SC27.2 SC28.2 SC29.2 SC30.2 SC31.2 SC32.2 SC52.1 SC53.2 SC72.2 SC73.2 SC83.2 SC84.2 SC85.2 SC86.2 SC87.2 SC146.2 SCB27.2 SCB68.2 SCB69.1 SCB70.1 SCB75.2 SCB119.1 SCB121.1 SCB122.1 SCB123.1 SCB124.1 SCB125.2 SCB126.2 SCB127.2 SR35.2 SR57.2 SR75.2 SR84.2 SR85.2 SR86.2 SR88.2 SR93.2 SR115.2 SR117.2 SR121.2 SR122.2 SR151.2 SR184.2 SR185.2 SR212.2 SR213.2 SR214.2 SR215.2 SR216.2 SR217.2 SR218.2 SR219.2 SR220.2 SR221.2 SR222.2 SR229.2 SR230.2 SR272.2 SR288.2 SR289.2 SR290.2 SR291.2 SR292.2 SR297.2 SR298.2 SR315.2 SR322.2 SR338.2 SR552.2 SR699.2 SR703.2 SR778.2 SR818.2 SR916.1 SR7814.1 SR7815.2 SR7816.2 SR7817.2 SR7829.2 SR7830.2 SR7831.2 SR7832.2 SR7833.2 SR7854.2 SR7868.1 SR7870.1 SR7874.1 SR7875.1 SR7876.2 SR7879.1 SR7883.1 SR7904.2 SR7914.2 SR7920.2 SR7923.2 SR7925.2 SR7932.2 SR7933.2 SR7938.2 SR7946.1 SR7947.1 SR7948.2 SR7950.2 SR7954.2 SR7983.2 SR7991.2 SR8002.1 SW10.5(P_GND1) SW10.6(P_GND2) SW10.A SW_RST1.3 SW_RST1.4 TUC23.2 TUC24.2 TUC26.2 TUC27.2 TUC30.2 TUC31.2 TUC32.2 TUC33.2 TUC34.2 TUC35.2 TUC36.2 TUC37.2 TUC38.2 U1.A2(VSS_1) U1.A3(VSS_3) U1.A4(VSS_6) U1.A5(VSS_11) U1.A8(VSS_12) U1.A28(VSS_2) U1.A33(VSS_4) U1.A37(VSS_5) U1.A45(VSS_7) U1.A46(VSS_8) U1.A47(VSS_9) U1.A48(VSS_10) U1.AA5(VSS_21) U1.AA19(VSS_13) U1.AA20(VSS_14) U1.AA25(VSS_15) U1.AA27(VSS_16) U1.AA28(VSS_17) U1.AA30(VSS_18) U1.AA31(VSS_19) U1.AA49(VSS_20) U1.AB19(VSS_22) U1.AB25(VSS_23) U1.AB31(VSS_24) U1.AC4(VSS_29) U1.AC12(VSS_25) U1.AC17(VSS_26) U1.AC33(VSS_27) U1.AC38(VSS_28) U1.AC46(VSS_30) U1.AD1(VSS_31) U1.AD2(VSS_33) U1.AD19(VSS_32) U1.AD22(VSS_34) U1.AD25(VSS_35) U1.AD49(VSS_36) U1.AE4(VSS_40) U1.AE12(VSS_37) U1.AE33(VSS_38) U1.AE38(VSS_39) U1.AE46(VSS_41) U1.AF22(VSS_42) U1.AF25(VSS_43) U1.AF28(VSS_44) U1.AG1(VSS_45) U1.AG22(VSS_46) U1.AG23(VSS_47) U1.AG25(VSS_48) U1.AG27(VSS_49) U1.AG28(VSS_50) U1.AG30(VSS_51) U1.AG49(VSS_52) U1.AH12(VSS_53) U1.AH17(VSS_54) U1.AH33(VSS_55) U1.AH38(VSS_56) U1.AJ19(VSS_57) U1.AJ20(VSS_58) U1.AJ25(VSS_59) U1.AJ27(VSS_60) U1.AJ28(VSS_61) U1.AJ30(VSS_62) U1.AJ31(VSS_63) U1.AK4(VSS_71) U1.AK19(VSS_64) U1.AK20(VSS_65) U1.AK25(VSS_66) U1.AK27(VSS_67) U1.AK28(VSS_68) U1.AK30(VSS_69) U1.AK31(VSS_70) U1.AK46(VSS_72) U1.AL12(VSS_73) U1.AL17(VSS_74) U1.AL21(VSS_75) U1.AL24(VSS_76) U1.AL26(VSS_77) U1.AL29(VSS_78) U1.AL33(VSS_79) U1.AL38(VSS_81) U1.AM1(VSS_82) U1.AM18(VSS_83) U1.AM32(VSS_84) U1.AM49(VSS_85) U1.AN12(VSS_86) U1.AN16(VSS_87) U1.AN34(VSS_88) U1.AN38(VSS_89) U1.AP4(VSS_90) U1.AP46(VSS_91) U1.AR12(VSS_92) U1.AR16(VSS_93) U1.AR34(VSS_94) U1.AR38(VSS_95) U1.AT1(VSS_96) U1.AT16(VSS_97) U1.AT18(VSS_98) U1.AT21(VSS_99) U1.AT24(VSS_100) U1.AT26(VSS_101) U1.AT29(VSS_102) U1.AT32(VSS_103) U1.AT34(VSS_104) U1.AT45(VSS_105) U1.AV11(VSS_106) U1.AV39(VSS_107) U1.AW4(VSS_109) U1.AW10(VSS_108) U1.AW40(VSS_110) U1.AW46(VSS_111) U1.B47(VSS_112) U1.B48(VSS_113) U1.B49(VSS_114) U1.BA5(VSS_118) U1.BA6(VSS_119) U1.BA12(VSS_115) U1.BA14(VSS_116) U1.BA44(VSS_117) U1.BB9(VSS_122) U1.BB41(VSS_120) U1.BB43(VSS_121) U1.BC8(VSS_133) U1.BC10(VSS_123) U1.BC13(VSS_124) U1.BC15(VSS_125) U1.BC19(VSS_126) U1.BC24(VSS_127) U1.BC26(VSS_128) U1.BC31(VSS_129) U1.BC35(VSS_130) U1.BC40(VSS_131) U1.BC45(VSS_132) U1.BD43(VSS_134) U1.BE44(VSS_135) U1.BF1(VSS_136) U1.BF2(VSS_137) U1.BF3(VSS_138) U1.BF48(VSS_139) U1.BF49(VSS_140) U1.BG2(VSS_142) U1.BG3(VSS_146) U1.BG4(VSS_149) U1.BG17(VSS_141) U1.BG22(VSS_143) U1.BG25(VSS_144) U1.BG28(VSS_145) U1.BG33(VSS_147) U1.BG37(VSS_148) U1.BG48(VSS_150) U1.C4(VSS_154) U1.C5(VSS_156) U1.C12(VSS_151) U1.C25(VSS_152) U1.C30(VSS_153) U1.C48(VSS_155) U1.D8(VSS_162) U1.D12(VSS_157) U1.D16(VSS_158) U1.D17(VSS_159) U1.D30(VSS_160) U1.D33(VSS_161) U1.E8(VSS_176) U1.E10(VSS_163) U1.E13(VSS_164) U1.E15(VSS_165) U1.E17(VSS_166) U1.E19(VSS_167) U1.E22(VSS_168) U1.E24(VSS_169) U1.E26(VSS_170) U1.E31(VSS_171) U1.E33(VSS_172) U1.E35(VSS_173) U1.E40(VSS_174) U1.E42(VSS_175) U1.F41(VSS_177) U1.F43(VSS_178) U1.F47(VSS_179) U1.G6(VSS_181) U1.G44(VSS_180) U1.H8(VSS_182) U1.J4(VSS_186) U1.J9(VSS_191) U1.J10(VSS_183) U1.J26(VSS_184) U1.J29(VSS_185) U1.J40(VSS_187) U1.J46(VSS_188) U1.J47(VSS_189) U1.J48(VSS_190) U1.K11(VSS_192) U1.K39(VSS_193) U1.M5(VSS_201) U1.M16(VSS_194) U1.M18(VSS_195) U1.M21(VSS_196) U1.M24(VSS_197) U1.M32(VSS_198) U1.M34(VSS_199) U1.M49(VSS_200) U1.N12(VSS_202) U1.N16(VSS_203) U1.N34(VSS_204) U1.N35(VSS_205) U1.N37(VSS_206) U1.N38(VSS_207) U1.P4(VSS_210) U1.P26(VSS_208) U1.P29(VSS_209) U1.P46(VSS_211) U1.R3(VSS_216) U1.R4(VSS_219) U1.R12(VSS_212) U1.R16(VSS_213) U1.R26(VSS_214) U1.R29(VSS_215) U1.R34(VSS_217) U1.R38(VSS_218) U1.T4(VSS_223) U1.T5(VSS_225) U1.T7(VSS_226) U1.T17(VSS_220) U1.T18(VSS_221) U1.T32(VSS_222) U1.T49(VSS_224) U1.U12(VSS_227) U1.U15(VSS_228) U1.U17(VSS_229) U1.U21(VSS_230) U1.U24(VSS_231) U1.U33(VSS_232) U1.U38(VSS_233) U1.V4(VSS_236) U1.V20(VSS_234) U1.V22(VSS_235) U1.V46(VSS_237) U1.W25(VSS_238) U1.W27(VSS_239) U1.W28(VSS_240) U1.W30(VSS_241) U1.Y9(VSS_247) U1.Y10(VSS_242) U1.Y12(VSS_243) U1.Y17(VSS_244) U1.Y33(VSS_245) U1.Y38(VSS_246) U6.49(GND) U6.50(GND_1) U6.51(GND_2) U6.52(GND_3) U6.53(GND_4) U6.54(GND_5) U6.55(GND_6) U6.56(GND_7) U6.57(GND_8) U6.58(GND_9) U104.1(VSS1) U104.17(VSS3) U104.18(AVSS) U104.35(VSS4) U104.40(HVSS) U104.59(VSS5) U104.66(VSS6) U104.90(VSS11) U104.117(VSS12) U114.33(GND) U114.34(GND1) U114.35(GND2) U114.36(GND3) U114.37(GND4) U114.38(GND5) U114.39(GND6) U114.40(GND7) U114.41(GND8) U131.1 U7201.16(GND_1) U7201.23(GND_2) U7201.33(GND_3) U7201.34(GND_4) U7201.35(GND_5) U7201.36(GND_6) U7201.37(GND_7) U9434.4(GND) U9435.10(GND) UB1.4(GND1) UBC1.2 UU19.2(GND) UU22.2(GND) UU64.2(GND) UU65.2(GND) UU66.2(GND) XBT1.2(-) XDP1.2(GND2) XDP1.7(GND3) XDP1.8(GND4) XDP1.13(GND5) XDP1.14(GND6) XDP1.19(GND7) XDP1.20(GND8) XDP1.25(GND9) XDP1.26(GND10) XDP1.31(GND11) XDP1.32(GND12) XDP1.37(GND13) XDP1.38(GND14) XDP1.49(GND15) XDP1.50(GND16) XDP1.59(GND17) XDP3.1(GND1) XDP3.2(GND2) XDP3.7(GND3) XDP3.8(GND4) XDP3.13(GND5) XDP3.14(GND6) XDP3.19(GND7) XDP3.20(GND8) XDP3.25(GND9) XDP3.26(GND10) XDP3.31(GND11) XDP3.32(GND12) XDP3.37(GND13) XDP3.38(GND14) XDP3.49(GND15) XDP3.50(GND16) XDP3.59(GND17) XU1.A4(VSS8) XU1.A7(VSS_6) XU1.A11(VSS_1) XU1.A13(VSS_2) XU1.A15(VSS_3) XU1.A17(VSS_4) XU1.A24(VSS_5) XU1.AA3(VSS_7) XU1.AA8(VSS_9) XU1.AA33(VSS_8) XU1.AB5(VSS_11) XU1.AB39(VSS_10) XU1.AC3(VSS_12) XU1.AC6(VSS_16) XU1.AC33(VSS_13) XU1.AC34(VSS_14) XU1.AC35(VSS_15) XU1.AD1(VSS_17) XU1.AD4(VSS_23) XU1.AD6(VSS_25) XU1.AD7(VSS_26) XU1.AD8(VSS_27) XU1.AD33(VSS_18) XU1.AD36(VSS_19) XU1.AD37(VSS_20) XU1.AD38(VSS_21) XU1.AD39(VSS_22) XU1.AD40(VSS_24) XU1.AE3(VSS_28) XU1.AE5(VSS_31) XU1.AE8(VSS_32) XU1.AE33(VSS_29) XU1.AE36(VSS_30) XU1.AF1(VSS_33) XU1.AF5(VSS_38) XU1.AF8(VSS_39) XU1.AF33(VSS_34) XU1.AF36(VSS_35) XU1.AF37(VSS_36) XU1.AF40(VSS_37) XU1.AG1(VSS_40) XU1.AG2(VSS_41) XU1.AG3(VSS_42) XU1.AG4(VSS_45) XU1.AG5(VSS_46) XU1.AG8(VSS_47) XU1.AG33(VSS_43) XU1.AG36(VSS_44) XU1.AH5(VSS_54) XU1.AH8(VSS_55) XU1.AH33(VSS_48) XU1.AH36(VSS_49) XU1.AH37(VSS_50) XU1.AH38(VSS_51) XU1.AH39(VSS_52) XU1.AH40(VSS_53) XU1.AJ1(VSS_56) XU1.AJ4(VSS_63) XU1.AJ5(VSS_64) XU1.AJ8(VSS_65) XU1.AJ24(VSS1) XU1.AJ30(VSS2) XU1.AJ31(VSS_57) XU1.AJ32(VSS_58) XU1.AJ33(VSS_59) XU1.AJ34(VSS_60) XU1.AJ35(VSS_61) XU1.AJ36(VSS_62) XU1.AK5(VSS_84) XU1.AK6(VSS_85) XU1.AK7(VSS_86) XU1.AK8(VSS_87) XU1.AK9(VSS_88) XU1.AK10(VSS_66) XU1.AK12(VSS_67) XU1.AK13(VSS_68) XU1.AK15(VSS_69) XU1.AK16(VSS_70) XU1.AK17(VSS_71) XU1.AK18(VSS_72) XU1.AK19(VSS_73) XU1.AK20(VSS_74) XU1.AK22(VSS3) XU1.AK23(VSS_75) XU1.AK25(VSS_76) XU1.AK26(VSS_77) XU1.AK27(VSS4) XU1.AK28(VSS_78) XU1.AK29(VSS_79) XU1.AK30(VSS_80) XU1.AK36(VSS_81) XU1.AK37(VSS_82) XU1.AK40(VSS_83) XU1.AL1(VSS_89) XU1.AL2(VSS_92) XU1.AL3(VSS_96) XU1.AL4(VSS_99) XU1.AL5(VSS_100) XU1.AL11(VSS_90) XU1.AL14(VSS_91) XU1.AL21(VSS_93) XU1.AL24(VSS_94) XU1.AL27(VSS_95) XU1.AL30(VSS_97) XU1.AL36(VSS_98) XU1.AM5(VSS_118) XU1.AM11(VSS_101) XU1.AM14(VSS_102) XU1.AM17(VSS_103) XU1.AM19(VSS_104) XU1.AM24(VSS_105) XU1.AM27(VSS_106) XU1.AM30(VSS_107) XU1.AM31(VSS_108) XU1.AM32(VSS_109) XU1.AM33(VSS_110) XU1.AM34(VSS_111) XU1.AM35(VSS_112) XU1.AM36(VSS_113) XU1.AM37(VSS_114) XU1.AM38(VSS_115) XU1.AM39(VSS_116) XU1.AM40(VSS_117) XU1.AN1(VSS_119) XU1.AN4(VSS_131) XU1.AN5(VSS_132) XU1.AN6(VSS_133) XU1.AN7(VSS_134) XU1.AN8(VSS_135) XU1.AN9(VSS_136) XU1.AN10(VSS_120) XU1.AN11(VSS_121) XU1.AN14(VSS_122) XU1.AN16(VSS_123) XU1.AN19(VSS_124) XU1.AN22(VSS_125) XU1.AN23(VSS_126) XU1.AN24(VSS_127) XU1.AN27(VSS_128) XU1.AN30(VSS_129) XU1.AN36(VSS_130) XU1.AP5(VSS_145) XU1.AP11(VSS_137) XU1.AP14(VSS_138) XU1.AP24(VSS_139) XU1.AP27(VSS_140) XU1.AP30(VSS_141) XU1.AP36(VSS_142) XU1.AP37(VSS_143) XU1.AP40(VSS_144) XU1.AR1(VSS_146) XU1.AR2(VSS_153) XU1.AR3(VSS_160) XU1.AR4(VSS_168) XU1.AR5(VSS_169) XU1.AR11(VSS_147) XU1.AR14(VSS_148) XU1.AR16(VSS_149) XU1.AR17(VSS_150) XU1.AR18(VSS_151) XU1.AR19(VSS_152) XU1.AR20(VSS_154) XU1.AR21(VSS_155) XU1.AR22(VSS_156) XU1.AR23(VSS_157) XU1.AR24(VSS_158) XU1.AR27(VSS_159) XU1.AR30(VSS_161) XU1.AR31(VSS_162) XU1.AR32(VSS_163) XU1.AR33(VSS_164) XU1.AR34(VSS_165) XU1.AR35(VSS_166) XU1.AR36(VSS_167) XU1.AT5(VSS_192) XU1.AT6(VSS_193) XU1.AT7(VSS_194) XU1.AT8(VSS_195) XU1.AT9(VSS_196) XU1.AT10(VSS_170) XU1.AT11(VSS_171) XU1.AT12(VSS_172) XU1.AT13(VSS_173) XU1.AT14(VSS_174) XU1.AT15(VSS_175) XU1.AT17(VSS_176) XU1.AT24(VSS_177) XU1.AT25(VSS_178) XU1.AT26(VSS_179) XU1.AT27(VSS_180) XU1.AT28(VSS_181) XU1.AT29(VSS_182) XU1.AT30(VSS_183) XU1.AT31(VSS_184) XU1.AT32(VSS_185) XU1.AT34(VSS_186) XU1.AT36(VSS_187) XU1.AT37(VSS_188) XU1.AT38(VSS_189) XU1.AT39(VSS_190) XU1.AT40(VSS_191) XU1.AU1(VSS_197) XU1.AU4(VSS_201) XU1.AU5(VSS_202) XU1.AU7(VSS_203) XU1.AU25(VSS_198) XU1.AU30(VSS_199) XU1.AU34(VSS_200) XU1.AU39(VSS7) XU1.AU40(VSS6) XU1.AV2(VSS_204) XU1.AV5(VSS_210) XU1.AV9(VSS_211) XU1.AV26(VSS_205) XU1.AV28(VSS_206) XU1.AV30(VSS_207) XU1.AV34(VSS_208) XU1.AV38(VSS_209) XU1.AV39(VSS12) XU1.AW3(VSS_212) XU1.AW5(VSS_217) XU1.AW9(VSS_218) XU1.AW30(VSS_213) XU1.AW32(VSS_214) XU1.AW34(VSS_215) XU1.AW36(VSS_216) XU1.AW38(VSS15) XU1.AY3(VSS_220) XU1.AY5(VSS_222) XU1.AY7(VSS_223) XU1.AY9(VSS_224) XU1.AY27(VSS_219) XU1.AY30(VSS_221) XU1.B6(VSS_229) XU1.B24(VSS_225) XU1.B26(VSS_226) XU1.B28(VSS_227) XU1.B30(VSS_228) XU1.B38(VSS9) XU1.C2(VSS10) XU1.C5(VSS_242) XU1.C8(VSS_243) XU1.C10(VSS_230) XU1.C12(VSS_231) XU1.C14(VSS_232) XU1.C16(VSS_233) XU1.C18(VSS_234) XU1.C20(VSS_235) XU1.C22(VSS_236) XU1.C24(VSS_237) XU1.C31(VSS_238) XU1.C33(VSS_239) XU1.C35(VSS_240) XU1.C37(VSS_241) XU1.D4(VSS_250) XU1.D7(VSS_251) XU1.D24(VSS_244) XU1.D26(VSS_245) XU1.D28(VSS_246) XU1.D30(VSS_247) XU1.D37(VSS_248) XU1.D39(VSS_249) XU1.D40(VSS11) XU1.E3(VSS_259) XU1.E6(VSS_264) XU1.E9(VSS_265) XU1.E11(VSS_252) XU1.E13(VSS_253) XU1.E15(VSS_254) XU1.E17(VSS_255) XU1.E19(VSS_256) XU1.E21(VSS_257) XU1.E23(VSS_258) XU1.E31(VSS_260) XU1.E33(VSS_261) XU1.E35(VSS_262) XU1.E37(VSS_263) XU1.F1(VSS_266) XU1.F4(VSS_272) XU1.F7(VSS_274) XU1.F10(VSS_267) XU1.F22(VSS_268) XU1.F26(VSS_269) XU1.F28(VSS_270) XU1.F30(VSS_271) XU1.F36(VSS5) XU1.F40(VSS_273) XU1.G3(VSS_281) XU1.G6(VSS_284) XU1.G8(VSS_285) XU1.G11(VSS_275) XU1.G13(VSS_276) XU1.G15(VSS_277) XU1.G17(VSS_278) XU1.G19(VSS_279) XU1.G22(VSS_280) XU1.G31(VSS_282) XU1.G33(VSS_283) XU1.H1(VSS_286) XU1.H4(VSS_295) XU1.H7(VSS_296) XU1.H9(VSS_298) XU1.H11(VSS13) XU1.H12(VSS14) XU1.H21(VSS_287) XU1.H24(VSS_288) XU1.H26(VSS_289) XU1.H28(VSS_290) XU1.H30(VSS_291) XU1.H35(VSS_292) XU1.H37(VSS_293) XU1.H39(VSS_294) XU1.J3(VSS_304) XU1.J6(VSS_307) XU1.J10(VSS_299) XU1.J12(VSS_300) XU1.J16(VSS_301) XU1.J18(VSS_302) XU1.J20(VSS_303) XU1.J32(VSS_305) XU1.J34(VSS_306) XU1.K1(VSS_308) XU1.K4(VSS_322) XU1.K7(VSS_323) XU1.K14(VSS_309) XU1.K15(VSS_310) XU1.K17(VSS_311) XU1.K19(VSS_312) XU1.K22(VSS_313) XU1.K24(VSS_314) XU1.K26(VSS_315) XU1.K28(VSS_316) XU1.K30(VSS_317) XU1.K33(VSS_318) XU1.K35(VSS_319) XU1.K37(VSS_320) XU1.K39(VSS_321) XU1.L3(VSS_326) XU1.L6(VSS_328) XU1.L9(VSS_329) XU1.L11(VSS_324) XU1.L13(VSS_325) XU1.L32(VSS_327) XU1.M1(VSS_330) XU1.M4(VSS_344) XU1.M7(VSS_345) XU1.M10(VSS_331) XU1.M12(VSS_332) XU1.M15(VSS_333) XU1.M17(VSS_334) XU1.M19(VSS_335) XU1.M21(VSS_336) XU1.M23(VSS_337) XU1.M25(VSS_338) XU1.M27(VSS_339) XU1.M29(VSS_340) XU1.M35(VSS_341) XU1.M37(VSS_342) XU1.M39(VSS_343) XU1.N3(VSS_346) XU1.N6(VSS_348) XU1.N8(VSS_349) XU1.N33(VSS_347) XU1.P1(VSS_350) XU1.P4(VSS_354) XU1.P35(VSS_351) XU1.P37(VSS_352) XU1.P39(VSS_353) XU1.R3(VSS_355) XU1.R6(VSS_357) XU1.R8(VSS_358) XU1.R33(VSS_356) XU1.T1(VSS_359) XU1.T4(VSS_363) XU1.T35(VSS_360) XU1.T37(VSS_361) XU1.T39(VSS_362) XU1.U3(VSS_364) XU1.U6(VSS_366) XU1.U33(VSS_365) XU1.V1(VSS_367) XU1.V8(VSS_371) XU1.V35(VSS_368) XU1.V37(VSS_369) XU1.V39(VSS_370) XU1.W3(VSS_372) XU1.W6(VSS_374) XU1.W33(VSS_373) XU1.Y5(VSS_377) XU1.Y35(VSS_375) XU1.Y37(VSS_376) Y18.2(GND1) Y18.4(GND2) Y4000.2(GND1) Y4000.4(GND2)
GND_AUDIO: AC12.2 AC13.2 AC85.2 AC86.2 AC87.2 AC89.2 AC90.2 AC97.2 AC98.2 AQ2.2(SOURCE) AQ3.2(SOURCE) C4301.2 C4302.2 C4303.2 C4304.2 C4305.2 C4306.2 C4307.2 C4308.2 C4309.2 C4310.2 D4301.1(ANODE) D4302.1(ANODE) D4303.1(ANODE) D4304.1(ANODE) D4305.1(ANODE) D4306.1(ANODE) D4307.1(ANODE) D4308.1(ANODE) J89.1 J89.5 J89.6 J301.6 J301.7(MS1) J301.8(MS2) MC5401.2 MC5402.2 MC8301.2 MC8302.2 MC8303.2 MC8304.2 MC8305.2 MR5401.2 MR5402.2 MR5403.2 R123.2 R124.2 R70273.2 U6.25(AVSS1) U6.38(AVSS2)
PVDD: AC93.1 AC95.1 AC96.1 L117.2 U6.41(PVDD1) U6.46(PVDD2)
V5_ALW_MON: O2Q4.3 OR152.2 R93115.1 U104.15(V5_ALW_MON)
VCC_SENSE: PR89023.1 XU1.C38(VCC_SENSE)
VCCGT_SENSE: PR89050.1 XU1.F39(VCCGT_SENSE)
VCCHDA: HR425.2 U1.BB14(VCCHDA)
VCCIO_PWRGD: PC89007.1 PR89008.2 PU3.5(LPGOOD) PU89001.2(EN) R5.1
VCCIO_PWRGD_DISCH_A: Q6.3(DRAIN) R5.2
VCCIO_SENSE: PR37.1 XU1.AF4(VCCIO_SENSE)
VCCMPHY_SENSE: R99522.2 U1.K47(VCCMPHY_SENSE)
VCCSA_PWRGD: PU3.4(PGOOD) R70296.1 R93112.2
VCCSA_PWRGD_LED_B: Q93036.1(BASE) R93112.1
VCCSA_PWRGD_LED_C: Q93036.3(COLLECTOR) R93111.2
VCCSA_PWRGD_LED_E: CR6.1(ANODE) Q93036.2(EMITTER)
VCCSA_PWRGD_R: C941488.1 Q9438.1(BASE) R6501.2 R70295.2 R70296.2
VCCSA_PWRGD_R_C: Q9438.3(COLLECTOR) R70297.2 R70298.1
VCCSA_SENSE: PR45.2 XU1.AD5(VCCSA_SENSE)
VCCSA_SENSE_R: PC36.1 PC37.1 PR41.2 PR43.1 PR44.2 PR45.1
VCCST_PWRGD: HC31.1 HR93.1 R4.1 R99528.2 XU1.U2(VCCST_PWRGD)
VCCST_PWRGD_DISCH_A: Q5.3(DRAIN) R4.2
VCCST_PWRGD_R: HR93.2 HR374.2 HR392.2 XDP1.39(HOOK0)
VDDQ_EN: APR129.2 APR130.1 APR131.2 PQ25.1(GATE)
VSS_AL37: SR35.1 U1.AL37(VSS_80)
VSS_SAIO_SENSE: PR6802.1 XU1.AE4(VSS_SAIO_SENSE)
VSS_SAIO_SENSE_R: PR42.2 PR46.1 PR6802.2
VSS_SENSE: PR89028.1 XU1.D38(VSS_SENSE)
VSS_SENSE_R: PC89016.2 PC89019.1 PR89028.2 PR89029.1 PR89032.2
VSSGT_SENSE: PR89053.1 XU1.F38(VSSGT_SENSE)
VSSGT_SENSE_R: PC89027.2 PC89031.1 PR89053.2 PR89054.1 PR89056.2
VSSMPHY_SENSE: R99521.2 U1.K46(VSSMPHY_SENSE)
VSSMPHY_SENSE_R: PR109.2 PR7301.1 R99521.1
1P2V_DUAL_EN: APR131.1 PC124.1 PQ24.3(DRAIN) PR131.2 PU9.8(S5)
1P2V_DUAL_PWRGD: ECR154.1 ECR155.1 PC128.1 PQ93031.3(DRAIN) PR123.1 PR135.2 PU9.10(PGOOD) R93102.1
2P5VPP_PG: APR129.1 PR116.2 PU6.1(POK)
65W_ADP_R: SR7838.1 U1.AV44(GPP_F19/EDP_VDDEN)
4125_INT: SR50.2 SR7815.1 U1.AH41(GPP_E0/SATAXPCIE0/SATAGP0) XDP3.4(OBSFN_C0)
4125_INT_OPTION: R2346.2 R2348.1 U1.BF9(GPP_G3/SD_D2)
4125_SW_WP: SR53.2 SR155.1 SR7817.1 U1.AK47(GPP_E2/SATAXPCIE2/SATAGP2)
4125_SW_WP_OPTION: R2342.2 R2344.1 U1.BE9(GPP_G1/SD_D0)
+0P95V_CPUIO: AR43.2 C941631.1 C941632.1 C941633.1 C941634.1 HR9.1 HR10.1 HR12.1 HR365.1 PC31.1 PC33.1 PCE2.1 PJP6801.2 PQ5.1(S_1) PQ5.2(S_2) PQ5.3(S_3) PR40.1 R69683.1 R93119.2 XU1.AJ23(VCCIO_1) XU1.AK11(VCCIO_2) XU1.AK14(VCCIO_3) XU1.AK24(VCCIO_4) XU1.M8(VCCIO_5) XU1.P8(VCCIO_6) XU1.T8(VCCIO_7) XU1.U8(VCCIO_8) XU1.W8(VCCIO_9)
+0P95V_DISCH_A: Q9540.3(DRAIN) R69683.2
+1P2V_DUAL: C8309.1 C8310.1 C8311.1 C8312.1 D4C9.1 D4C20.1 D4C26.1 D4C27.1 D4C31.1 D4C32.1 D4CB1.1 D4CB2.1 D4CB3.1 D4CB4.1 D4CB5.1 D4CB6.1 D4CB7.1 D4CB8.1 D4CB9.1 D4CB10.1 D4CB11.1 D4CB12.1 D4CB13.1 D4CB14.1 D4CB15.1 D4CB16.1 D4CB17.1 D4CB18.1 D4CB19.1 D4CB20.1 D4CB21.1 D4CB22.1 D4CB23.1 D4CB24.1 D4CE1.1 D4CE2.1 D4R2.1 D4R8.1 D4R14.1 D4R19.1 DIMM1.12(DM0_N/DBI0_N) DIMM1.33(DM1_N/DBI_N) DIMM1.54(DM2_N/DBI2_N) DIMM1.75(DM3_N/DBI3_N) DIMM1.96(DM8_N/DBI_N/NC) DIMM1.111(VDD1) DIMM1.112(VDD2) DIMM1.117(VDD3) DIMM1.118(VDD4) DIMM1.123(VDD5) DIMM1.124(VDD6) DIMM1.129(VDD7) DIMM1.130(VDD8) DIMM1.135(VDD9) DIMM1.136(VDD10) DIMM1.141(VDD11) DIMM1.142(VDD12) DIMM1.147(VDD13) DIMM1.148(VDD14) DIMM1.153(VDD15) DIMM1.154(VDD16) DIMM1.159(VDD17) DIMM1.160(VDD18) DIMM1.163(VDD19) DIMM1.178(DM4_N/DBI4_N) DIMM1.199(DM5_N/DBI5_N) DIMM1.220(DM6_N/DBI6_N) DIMM1.241(DM7_N/DBI7_N) DIMM2.12(DM0_N/DBI0_N) DIMM2.33(DM1_N/DBI_N) DIMM2.54(DM2_N/DBI2_N) DIMM2.75(DM3_N/DBI3_N) DIMM2.96(DM8_N/DBI_N/NC) DIMM2.111(VDD1) DIMM2.112(VDD2) DIMM2.117(VDD3) DIMM2.118(VDD4) DIMM2.123(VDD5) DIMM2.124(VDD6) DIMM2.129(VDD7) DIMM2.130(VDD8) DIMM2.135(VDD9) DIMM2.136(VDD10) DIMM2.141(VDD11) DIMM2.142(VDD12) DIMM2.147(VDD13) DIMM2.148(VDD14) DIMM2.153(VDD15) DIMM2.154(VDD16) DIMM2.159(VDD17) DIMM2.160(VDD18) DIMM2.163(VDD19) DIMM2.178(DM4_N/DBI4_N) DIMM2.199(DM5_N/DBI5_N) DIMM2.220(DM6_N/DBI6_N) DIMM2.241(DM7_N/DBI7_N) HR63.1 O2Q3.4 O2R22.1 PC25.1 PC126.1 PC941484.1 PCE9.1 PJP9.1 PL14.2 PQ5.5(D) PR139.1 PR141.1 PR93028.1 PU9.19(VLDOIN) R661.1 SR265.1 XU1.AT18(VDDQ_1) XU1.AT21(VDDQ_2) XU1.AU13(VDDQ_3) XU1.AU15(VDDQ_4) XU1.AU19(VDDQ_5) XU1.AU23(VDDQ_6) XU1.AV11(VDDQ_7) XU1.AV17(VDDQ_8) XU1.AV21(VDDQ_9) XU1.AW10(VDDQ_10) XU1.AW14(VDDQ_11) XU1.AW25(VDDQ_12) XU1.AY12(VDDQ_13) XU1.AY16(VDDQ_14) XU1.AY18(VDDQ_15) XU1.AY23(VDDQ_16)
+1P2V_DUAL_A_CS: PR93026.2 PU9.13(CS)
+1P2V_DUAL_A_FB_A: PC130.2 PR214.1 PR93024.1 PU9.6(FB)
+1P2V_DUAL_A_S3: PC120.1 PR128.2 PR129.2 PU9.7(S3)
+1P2V_DUAL_A_TON: PR126.2 PU9.9(TON)
+1P2V_DUAL_A_V5IN: PC117.1 PR124.2 PR7702.1 PU9.12(VDD)
+1P2V_DUAL_A_VOUT_R_A: PC130.1 PC941483.1 PJP9.2 PR214.2 PU9.5(VDDQ)
+1P2V_DUAL_BST: PR125.1 PU9.18(BOOT)
+1P2V_DUAL_BST_RC: PC118.2 PR125.2
+1P2V_DUAL_DISCH_A: Q9543.3(DRAIN) R661.2
+1P2V_DUAL_HG: PR127.1 PU9.17(UGATE)
+1P2V_DUAL_HG_IN: PC123.1 PQ23.1(G1) PR127.2 PR130.1
+1P2V_DUAL_LG: PR134.1 PU9.15(LGATE)
+1P2V_DUAL_LG_R_D: PC129.1 PQ23.8(G2) PR134.2 PR136.1
