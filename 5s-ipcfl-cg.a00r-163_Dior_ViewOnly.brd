# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3P3V_DEBUG: length 9.8
  TOP w0.508: 3.43,126.63 3.43,128.74 3.26,128.91 CB4152.1 4.27,131.33 v1(5.41,130.19)
  BOTTOM w0.508: v1(5.41,130.19) 6.53,130.19 v2(6.68,130.04) Q9433.3
+3P3V_DISCH_A: length 2.8
  BOTTOM w0.254: v2(129.67,26.84) 129.06,27.45 R658.2 128.47,28.11 128.46,28.12 Q9542.3
+3P3V_DPC: length 23.7
  TOP w0.635: 112.5,163.54 113.1,164.15 114.58,164.15 115.11,164.68 119.58,164.68 120.72,165.83 129.06,165.83 131.01,163.87 v1(131.01,163.69)
  BOTTOM w0.635: J302.20 129.37,163.69 v1(131.01,163.69)
+3P3V_DPC_SW: length 5
  TOP w0.254: Q93041.3 103.34,162.77 v2(103.12,162.55)
  TOP w0.711: M1F2.1 105.87,164.58 105.64,164.35 104.52,164.35 104.11,163.95 Q93041.3
+3P3V_HDD: length 0.8
  BOTTOM w0.635: 42.71,126.65 P110.P3
+3P3V_L: length 0.9
  BOTTOM w0.457: v2(24.43,134.97) v1(23.52,134.97)
+3P3V_LDOOUT:
  vias: v2(105.22,28.8)
+3P3V_LED_R: length 9.2
  TOP w0.254: v1(161.29,32.35) 162.54,33.6 R4816.1 166.62,33.6 CR7.2
  BOTTOM w0.254: v1(161.29,32.35) 161.29,32.32 160.61,31.65 v2(160.03,31.65)
+3P3V_MSATA: length 116.5
  TOP w0.254: v1(10.32,69.59) 8.86,68.13 8.86,66.82 8.46,66.42 8.46,66.01 8.6,65.88 8.6,58.65 9.59,57.66 9.59,54.89 6.63,51.93 v1(6.63,50.19) ; v1(28.19,59.17) 28.07,59.05 28.07,56.6 28.48,56.19 R70290.2 ; v1(17.3,106.37) 17.72,106.37 X3R14.1 ; SR416.2 28.69,65.23 v1(28.37,64.91)
  TOP w1.016: 8.6,111.57 9.78,112.75 12.28,112.75 12.57,113.05 14.98,113.05 15.2,113.26 22.03,113.26 22.33,112.97 23.86,112.97
  TOP w2.54: 2.44,95.59 2.44,103.32
  IN1 w0.254: v1(28.19,59.17) 24.54,59.17 23.06,60.65 22.5,60.65 21.76,61.38 20.82,61.38 v1(19.43,62.78) 19.43,63.62 16.02,67.03 16.02,70.62 15.36,71.27 15.1,71.27 14.59,71.78 11.44,71.78 10.69,71.04 10.69,69.95 v1(10.32,69.59)
  BOTTOM w0.254: v1(28.37,64.91) 28.37,64.87 27.25,63.75 24.95,63.75 24.55,63.35 22.64,63.35 22.48,63.52 20.17,63.52 v1(19.43,62.78) ; v1(6.63,50.19) 6.63,47.59 5.1,46.07 5.1,43.86 ; v1(17.3,106.37) 17.83,106.37 18.39,106.92 v1(21.49,106.92)
  BOTTOM w2.54: 7.06,41.79 18.49,41.79 19.25,41.02 23.05,41.02
  vias: v2(27.41,39.49) v3(3.61,45.18) v3(3.63,44.29) v3(3.63,43.4) v3(3.63,42.51)
+3P3V_MSATA_DISCH_A: length 3.5
  BOTTOM w0.254: Q942.3 34.8,35.65 34.62,35.83 34.62,36.67 v2(34.24,37.05) 33.76,37.05 33.69,36.99 R934.2
+3P3V_MSATA_EN: length 5.6
  TOP w0.102: v1(45.57,42.99) 45.57,42.15 46.1,41.62 PR93155.1
  BOTTOM w0.102: v1(45.57,42.99) 45.43,42.99 PC8498.1 44.52,43.9 v2(43.92,43.9) 43.25,43.9 43.13,43.78 PU8401.3
+3P3V_WLAN: length 42.7
  TOP w0.254: v1(58.62,48) 57.53,49.09 APR137.1
  TOP w0.305: J218.2 34.95,51.1 ; J218.4 35.45,51.13
  TOP w0.381: 54.68,50.51 54.68,49.94 54.95,49.67 SR7885.1 SR7886.1
  IN1 w0.381: 56.95,46.17 56.95,44.74 56.16,43.96 53.95,43.96 53.49,44.41 53.22,44.41 53.73,44.92 53.87,44.92 55.57,46.62 56.74,46.62
  IN1 w0.762: 53.22,44.41 52.13,44.41 51.81,44.73 51.07,44.73 50.72,44.38 46.63,44.38 45.97,45.04 45.29,45.04 44.74,44.48 43.82,44.48 43.08,43.73 38.72,43.73 38.34,44.11 37.6,44.11 36.26,45.46 36.17,45.46
  BOTTOM w0.432: R3136.1 53.39,50.99 v1(53.47,50.92)
  BOTTOM w0.508: R932.1 58.2,48.62 58.62,48.2 v1(58.62,48)
  BOTTOM w1.524: 66.93,51.09 69.04,51.09 70.11,50.02 70.11,48.49
  vias: v2(66.68,51.01) v3(34.72,48.15) v3(55.65,50.89) v3(55.68,51.78) v3(64.77,50.99) v3(65.66,51.18)
+3P3V_WLAN_DISCH_A: length 5.4
  BOTTOM w0.254: Q940.3 54.74,49.16 55.19,48.71 56.22,48.71 R932.2 56.86,49.54 57.45,50.13 57.94,50.13 v2(58.22,50.41)
+3P3VA: length 805.6
  TOP w0.254: v1(68.91,135.52) 69.16,135.27 SR7998.1 ; v1(79.86,112) 79.86,112.18 80.11,112.44 80.11,113.58 80.24,113.71 80.24,114.1 79.93,114.4 79.51,114.4 79.48,114.37 HR379.1 ; v1(31.95,69.92) 33.25,68.62 33.25,64.66 33.5,64.4 34.92,64.4 35.37,64.85 SR7922.1 36.02,65.66 36.02,66.72 36.52,67.22 37.78,67.22 SR255.1 39.86,66.54 v1(39.98,66.65) ; v1(88.57,74.59) 86.54,74.59 86.33,74.39 83.93,71.98 83.93,71.98 82.32,70.37 v1(82.32,69.76) ; v1(67.74,133.42) 66.27,133.42 65.9,133.05 61.68,133.05 60.79,132.16 60.27,132.16 59.32,131.21 56.11,131.21 55.6,131.71 v1(55.6,131.88) ; 69.86,44.92 69.86,46.56 70.84,47.54 70.84,49.34 76.81,55.31 v1(76.81,56.5) ; v1(32.61,74.12) 32.68,74.12 33.15,74.59 33.15,75.02 32.79,75.38 32.79,76.69 SR254.1 32.16,77.32 SR252.1 32.16,78.6 32.27,78.72 SR253.1 32.62,79.47 32.62,79.48 33.11,79.96 SR251.1 33.69,80.63 v1(33.69,80.79)
  TOP w0.432: v1(25.96,140.32) 25.86,140.43 25.86,144.73 24.11,146.47 22.92,146.47 SR817.1
  TOP w0.508: v1(35.86,138.8) 35.86,138.65 38.66,135.85 38.66,134.8 v1(40.41,133.05) 42.44,131.02 42.74,131.02 43.25,130.51 45.15,130.51 45.63,130.04 53.67,130.04 v1(53.69,130.06) ; v1(18.82,110.78) 18.31,111.29 15.11,111.29 14.17,110.35 11.02,110.35 v1(10.57,110.8) ; v1(4.95,114.01) 4.99,113.97 6.41,113.97 7.06,113.32 v1(8.13,113.32) ; v1(31.95,69.92) 31.19,69.15 31.19,68.12 31.12,68.05 R99515.1 ; v1(36.07,21.9) 34.76,20.59 32.76,20.59 32.15,19.98 AR17.1 ; v1(7.01,18.15) 6.89,18.27 R182.1 ; v1(15.42,91.57) v1(12.99,91.57) 12.84,91.42 11.74,91.42 v1(10.78,90.46)
  TOP w1.524: 104.6,37.12 105.13,36.59 107.59,36.59 108.56,37.56 110.33,37.56 v1(113.91,33.97) 118.21,29.67 118.21,27.85
  IN1 w0.254: v1(33.69,80.79) 33.54,80.94 31.25,80.94 30.98,80.67 29.78,80.67 28.71,81.74 28.71,88.9 29.07,89.26 v1(29.07,92.08) ; v1(88.57,74.59) 88.73,74.75 88.73,76.32 90.03,77.62 90.03,94.92 89.77,95.18 87.04,97.91 82.83,97.91 81.16,99.57 81.16,102.83 80.78,103.22 78.32,103.22 77.62,103.91 77.62,104.82 78.1,105.3 79.02,105.3 79.55,105.83 79.55,106.44 79.86,106.75 v1(79.86,112) ; v1(76.81,56.5) 76.81,59.5 v1(79.02,61.71) ; v1(55.6,131.88) 55.59,131.88 53.77,130.06 v1(53.69,130.06)
  IN1 w0.508: 9.87,129.42 11.96,131.51 13.3,131.51 14.26,130.55 17.45,130.55 25.14,138.24 25.14,139.51 v1(25.96,140.32) ; v1(7.01,18.15) 6.17,18.99 6.17,24.62 8.45,26.9 9.79,26.9 10.33,26.36 16.95,26.36 19.73,29.14 21.73,29.14 22.5,29.91 22.72,29.91 23.73,30.93 25.92,30.93 28.29,28.55 29.25,28.55 29.83,27.97 31.87,27.97 34.54,30.64 v1(34.54,31.25) ; v1(103.43,36.82) 102.79,36.18 96.76,36.18 93.89,33.32 93.89,32.16 93.06,31.33 93.06,27.73 90.78,25.44 90.78,23.97 91.11,23.64 91.11,18.84 95.22,14.73 95.22,13.45 96.05,12.63 96.05,8.84 96.35,8.54 96.45,8.54 v1(96.49,8.5)
  IN1 w0.635: v3(5.23,91.17) 4.77,91.63 v1(4.77,93.61) 3.95,94.44 3.95,96.77 4.5,97.32 4.69,97.32 ; 4.69,97.32 2.97,99.05 2.97,106.64 4.63,108.31 4.63,111.39 3.94,112.08 3.94,113.38 4.57,114.01 ; 4.69,97.32 v1(4.75,97.32) ; 4.57,114.01 v1(4.95,114.01) ; 4.57,114.01 3.94,114.65 3.94,126.01 7.34,129.42 9.87,129.42
  IN2 w0.508: v1(107.45,34.44) 113.44,34.44 v1(113.91,33.97) 121.87,33.97 122.7,33.15 128.45,33.15 129.74,34.44 v1(129.74,36.52) 130.98,37.75 134.85,37.75 135.45,37.15 v1(135.45,37.13) ; v1(10.57,110.8) 9.94,110.8 9.27,111.47 9.27,112.82 8.76,113.32 v1(8.13,113.32) ; v1(25.96,140.32) 26.02,140.26 27.86,140.26 28.77,139.35 30.15,139.35 30.43,139.07 34.07,139.07 34.61,138.53 35.6,138.53 v1(35.86,138.8) ; v3(53.26,39.46) 53.26,39.46 53.03,39.69 43.38,39.69 v3(43.28,39.79)
  IN2 w0.635: v3(5.23,91.17) 5.15,91.1 5.15,79.01 7.85,76.31 v3(7.85,74) 7.85,72.81 8.07,72.59 8.07,71.15 7.39,70.47 7.39,66.72 6.89,66.22 6.89,65.05 8.36,63.58 8.36,58.77 6.57,56.98 6.57,55.68 7.17,55.07 7.17,51.56 8.09,50.65 8.09,50.38 12.79,45.67 21.57,45.67 21.99,45.25 24.82,45.25 25.96,44.11 30.38,44.11 v3(31.24,44.98)
  IN2 w0.762: v3(31.24,44.98) 32.46,43.76 38.26,43.76 40.73,41.29 41.78,41.29 v3(43.28,39.79)
  IN2 w1.524: 116.67,25.3 105.49,25.3 104.91,24.71 99.97,24.71 96.94,27.74 95.55,27.74 92.75,30.55 86.92,30.55 85.4,29.02 69.59,29.02 68.83,29.79 68.83,36.24
  BOTTOM w0.191: 17.02,91.43 17.51,91.92 U104.45 ; U104.77 7.02,99.16 6.91,99.06 ; O2CB5.1 18.98,111.39 19.3,111.07 19.3,109.86 19.11,109.68 U104.120 ; O2CB17.1 11.23,110.42 11.91,109.74 12.13,109.74 12.71,109.16 U104.104 ; 25.4,98.9 24.86,98.36 U104.22 ; U104.65 7.03,94.36 ; 11.51,91.95 U104.60 ; U104.32 24.53,94.36 24.76,94.12 24.76,93.63 ; O2CB2.1 13.23,91.05 13.51,91.33 U104.55
  BOTTOM w0.203: 11.51,91.95 11.51,91.54 O2CB3.1 ; 17.02,91.43 16.77,91.43 O2CB6.1
  BOTTOM w0.254: PR132.1 134.77,35.57 135.45,36.26 v1(135.45,37.13) ; v1(29.07,92.08) 28.83,92.32 27.6,92.32 O2CB20.1 26.92,91.98 26.92,92.3 26.45,92.78 26.44,92.78 26.42,92.79 25.56,92.79 24.76,93.59 24.76,93.63 ; SR256.1 20.48,73.83 20.24,73.59 18.05,73.59 16.74,74.89 8.74,74.89 v3(7.85,74) ; P466.3 38.8,54.03 38.3,54.52 37.21,54.52 36.85,54.89 35.66,54.89 35.52,54.75 35.52,53.66 34.8,52.94 33.56,52.94 31.3,55.2 31.3,56.03 32.89,57.63 32.89,58.51 36.67,62.3 37.46,62.3 38.84,63.67 38.84,65.65 39.84,66.65 v1(39.98,66.65) ; 35.36,26.48 35.36,27.63 34.57,28.41 34.57,30.88 34.54,30.9 v1(34.54,31.25) 34.54,31.84 34.25,32.13 R933.1 ; v1(31.95,69.92) 31.95,71.62 33.11,72.77 33.11,73.62 v1(32.61,74.12) ; v1(67.74,133.42) 67.74,134.36 v1(68.91,135.52)
  BOTTOM w0.381: v1(40.41,133.05) R99536.1 R99535.1
  BOTTOM w0.406: v1(10.57,110.8) 10.68,110.8 10.99,110.49 O2CB17.1 ; v1(79.02,61.71) 80.36,61.71 82.32,63.67 v1(82.32,69.76)
  BOTTOM w0.432: v1(107.45,34.44) PR58.1
  BOTTOM w0.457: O2CB3.1 11.07,90.75 v1(10.78,90.46) ; v1(12.99,91.57) 12.99,91.15 O2CB2.1 ; v1(53.69,130.06) 55.03,128.72 58.47,128.72 59.2,128 59.2,126.96 58.13,125.9 56.46,125.9 55.54,124.97 45.87,124.97 43.31,122.41 40.37,122.41 39.21,121.25 36.68,121.25 35.18,119.75 35.18,118.4 34.16,117.38 34.16,115.02 34.15,115.01 34.15,112.63 34.62,112.16 34.62,109.72 35.86,108.47 35.86,107.36 36.79,106.43 37.61,106.43 39.5,104.54 39.5,103.22 40.09,102.62 40.09,102.13 39.74,101.78 39.21,101.78 39.01,101.58 39.01,101.36 38.4,100.74 37.76,100.74 36.67,101.83 34.82,101.83 PC760.1 34.05,101.99 PU76.1 33.21,101.13 32.53,100.45 30.97,100.45 29.82,99.29 29.21,99.29 28.84,99.67 26.81,99.67 26.35,99.21 O2CB1.1 25.4,98.9 ; v1(4.77,93.61) 5.66,93.61 6.12,94.07 O2CB4.1 7.02,94.37 7.03,94.36 ; v1(18.82,110.78) 18.82,110.79 O2CB5.1 ; 6.91,99.06 O2CB16.1 AC47.1 6.35,97.9 5.76,97.32 v1(4.75,97.32) ; SR7877.1 63.21,44.5
  BOTTOM w0.508: v1(129.74,36.52) 129.74,36.53 127.14,39.14 R663.1 ; P466.3 38.8,51.94 37.69,50.84 33.04,50.84 31.52,49.32 31.52,45.25 v3(31.24,44.98) ; R931.1 55.74,46.5 55.32,46.5 ; v3(5.23,91.17) 4.71,90.65 4.71,89.17 4.56,89.02 4.56,88.37 4.97,87.96 5.71,87.96 7.22,89.47 7.94,89.47 8.93,90.46 v1(10.78,90.46) ; PR8402.1 48.54,46 47.93,46.61 47.93,49.4 46.49,50.84 45.95,50.84 45.55,51.25 45.4,51.25 44.86,51.25 44.86,51.25 44.54,51.25 43.88,51.91 P466.7 ; O2CB6.1 15.67,90.77 15.42,91.02 v1(15.42,91.57) ; v1(96.49,8.5) 96.32,8.5 96.06,8.24 PR8405.1
  BOTTOM w0.762: 36.14,26.41 36.14,32.22 36.52,32.6 36.52,35.83 35.91,36.44 35.91,37.71 36.55,38.34 37.9,38.34 38.2,38.04 41.53,38.04 v3(43.28,39.79)
  vias: v1(103.29,38.15) v1(103.92,38.12) v1(104.56,38.12) v3(67.79,38.93) v3(67.79,38.04) v3(67.79,37.15) v3(67.79,36.26) v3(70.48,39.11) v3(70.46,38.14) v3(71.4,39.08) v3(71.4,38.14) v3(72.36,39.08) v3(72.41,38.14) v3(117.94,25.35) v3(118.83,25.35)
+3P3VA_BST: length 1.4
  BOTTOM w0.254: PR65.1 v2(111.49,32.61)
+3P3VA_BST_RC: length 1.6
  BOTTOM w0.254: PR65.2 v2(111.73,34.34)
+3P3VA_CS: length 4.9
  BOTTOM w0.203: 106.16,29.97 106.37,29.75 PU4.5
  BOTTOM w0.254: PR63.2 105.67,31.07 105.42,31.33 105.42,32.48 105.17,32.73 v2(104.72,32.73)
  BOTTOM w0.432: PR63.2 106.03,30.1 106.16,29.97
+3P3VA_EN: length 7.2
  BOTTOM w0.203: v2(104.37,34.46) 104.95,33.87 106.06,33.87 PR74.2 PC73.1 106.58,31.58 107.64,30.52 PU4.6
+3P3VA_FB: length 6.1
  BOTTOM w0.203: PU4.4 106.43,29.35
  BOTTOM w0.254: v2(103.02,30.05) PR76.1 103.36,30.98 103.45,31.07 PR75.2 PC74.2 105.47,30.4 105.47,29.87 105.98,29.35 106.43,29.35
+3P3VA_FB_RC_A: length 46.1
  TOP w0.254: PJP7.2 67.91,33.53 68.68,32.76 68.68,30.17 69.24,29.61 84.15,29.61 v1(85.22,30.67)
  IN2 w0.254: v1(85.22,30.67) 87.92,33.38 103.34,33.38 v1(103.81,32.91)
  BOTTOM w0.254: v1(103.81,32.91) v2(102.97,32.91) 102.97,32.47 103.02,32.43 PC75.1 103.39,32 103.48,31.91 PR75.1 PC74.1
+3P3VA_HG: length 30.2
  TOP w0.635: v1(97.66,29.76) 94.82,29.76 92.86,27.8 89.64,27.8 88.29,29.15 88.29,31.16 89.17,32.04 90.78,32.04 v3(90.8,32.02)
  IN2 w0.635: v3(109.64,31.16) 109.18,30.71 102.61,30.71 102.21,30.3 98.2,30.3 v1(97.66,29.76)
  BOTTOM w0.508: v2(90.98,31.13) 90.98,31.84 v3(90.8,32.02)
  BOTTOM w0.635: PR67.1 v3(90.8,32.02)
+3P3VA_HG_R:
  vias: v2(86.18,31.23)
+3P3VA_LG: length 23.6
  TOP w0.635: v3(90.86,34.26) 90.94,34.18 93.35,34.18 93.36,34.19 99.38,34.19 99.97,33.59 104.21,33.59 104.7,34.08 106.16,34.08 106.86,33.39 108.61,33.39 v3(110.84,31.16)
  BOTTOM w0.508: v2(91.67,34.02) 91.43,34.26 v3(90.86,34.26)
  BOTTOM w0.635: PR71.1 90.76,34.25 90.76,34.26 v3(90.86,34.26)
+3P3VA_LG_R_D: length 2.6
  BOTTOM w0.635: v2(87.86,36.85) 88.09,36.62 88.09,34.36
+3P3VA_PHASE: length 26.4
  TOP w0.635: 82.83,32.68 86.08,32.68 86.84,33.44 93.65,33.44 93.66,33.45 99.07,33.45 100.61,31.91 v3(108.23,31.91)
  vias: v2(86.61,33.72) v3(78.51,36.01) v3(78.48,34.66) v3(78.48,32.6) v3(79.93,37.71) v3(79.88,32.58) v3(81.1,37.68) v3(81.71,32.58) v3(82.19,37.66)
+3P3VA_SN_C: length 2.7
  BOTTOM w0.254: 83.84,40.05 84.3,40.5 85.57,40.5 v2(86.16,39.92)
+3P3VEN: length 4.4
  TOP w0.254: ECR154.2 43.53,41.48 v2(43.53,41.77) 43.53,42.15 44.04,42.66 v1(44.4,42.66)
  BOTTOM w0.254: v1(44.4,42.66) 44.23,42.83 PC8499.1 43.59,42.97 42.68,42.97 PU8401.5
+3P3VSB: length 1262.4
  TOP w0.254: OR141.1 11.46,96.19 11.56,96.28 12.17,96.28 13.13,95.32 v1(13.42,95.32) 13.84,95.32 14.85,94.31 14.85,93.48 13.86,92.49 12.54,92.49 12.3,92.26 11.33,92.26 OR153.1 10.08,92 9.25,92 7.59,90.34 v1(7.39,90.34) ; R2101.1 v1(65.94,108.32) ; v1(28.46,93.88) 29.23,93.88 SR161.1 30.21,94.86 31.4,94.86 31.53,94.99 31.93,94.99 32.11,95.16 32.5,95.16 SR170.1 ; SR7853.1 49.08,75.81 v1(49.08,75.2) ; v1(44.27,83.99) 44.27,83.86 44.62,83.51 U1.AT44 ; v1(33.15,90.36) 33.15,90.54 SR7842.1 31.98,91.28 31.79,91.09 30.69,91.09 30.31,90.71 SR211.1 ; SR18.1 47.79,74.08 47.79,74.07 47.79,74.07 v1(48.62,74.07) ; SR7942.1 15.78,99.6 15.04,98.85 v1(14.98,98.85) ; U1.AY8 42.38,100.61 42.04,100.27 ; F3R2.2 47.9,71.05 48.53,71.68 CB4133.2 48.53,72.38 ; SR7940.1 28.54,86.16 28.57,86.12 SR7844.1 29.45,86.55 v1(29.68,86.55) 29.76,86.63 SR7871.1 30.29,85.83 30.39,85.73 SR7872.1 ; SR7930.1 65.11,75.21 v1(64.67,74.77) 64.67,74.78 SR7929.1 ; SR7930.1 66.08,74.64 SR22.1 ; SR7930.1 66.05,75.76 SR104.1 SR7956.1 66.05,78.95 66.01,78.98 SR105.1 ; R2342.1 18.55,133.09 v1(18.5,133.04) ; U1.AW9 42.04,100.27 ; 42.04,100.27 v1(42.04,100.27) ; v1(50.43,76.6) 50.93,76.6 51.64,77.31 52.35,77.31 52.84,77.8 53.58,77.8 54.43,76.95 v1(55.47,76.95) ; OR126.1 8.19,93.11 7.52,92.45 v1(7.34,92.45) ; SR211.1 29.81,90.71 29.78,90.68 SR7796.1 28.8,90.17 28.8,89.53 28.83,89.5 SR672.1 ; SR211.1 30.22,90.95 29.84,91.33 v1(29.64,91.33) 29.59,91.38 29.59,91.74 SR160.1 ; FR10.1 5.31,98.64 5.31,97.16 v1(4.63,96.48) ; U1.AN21 45.52,94.94 v1(45.52,95.29) ; v1(22.93,112.08) 22.15,112.08 21.23,111.17 19.61,111.17 18.43,112.34 v1(15.64,112.34) 15.4,112.1 v1(13.33,112.1) 13.16,111.93 10.22,111.93 9.65,111.36 9.65,110.2 v1(8.81,109.36) ; R4817.1 v1(167.62,35.94) ; OR109.2 OR111.2 OR112.2 ; OR109.2 8.96,102.66 OR119.2 ; OR109.2 8.62,103.58 8.49,103.71 7.82,103.71 OR128.1 7.12,103.42 5.94,103.42 5.69,103.16 5.69,102.33 OR129.1 4.71,101.96 v1(4.62,102.05) 4.62,101.72 OR130.1 ; CR1.1 CR2.1 165.64,24.74 v1(165.57,24.81) ; SR110.1 SR111.1 SR7862.1 29.46,82.06 29.72,81.8 v1(30.62,81.8) 30.78,81.8 SR44.2 ; SR7982.1 20.41,74.03 20.09,73.71 v1(20.09,72.65) ; U1.BB7 41.76,101.04 v1(41.83,100.97) ; HR2.1 157.96,79.26 157.96,77.31 HR1.1 156.74,74.81 156.74,73.98 160.88,69.84 160.88,51.04 163.48,48.44 163.48,45.45 162.03,43.99 162.03,40 160.31,38.28 143.72,38.28 v1(142.98,39.03) ; SR170.1 32.85,94.96 32.85,95.45 32.83,95.47 SR7934.1 SR7935.1 ; SR170.1 32.43,94.54 32.43,93.56 32.64,93.36 SR171.1 ; F3R1.2 64.87,68.66 64.87,69.27 SR404.1 65.06,69.9 65.14,69.98 SR20.1 64.64,70.87 63.74,70.87 v1(63.73,70.86) ; SR7880.1 SR7993.1 71.29,52.57 v1(71.54,52.31) ; v1(65.74,68.06) 65.85,68.06 66.3,67.61 66.3,66.25 66.66,65.89 F3R71.1 67.16,64.71 67.16,63.52 68.35,62.32 J303.2 ; U1.V23 53.01,92.86 v1(53.01,92.84) ; v1(165.86,40.88) 164.51,40.88 164.11,40.48 164.11,38.71 161.19,35.79 146.39,35.79 145.66,36.53 144.08,36.53 143.78,36.22 v1(143.72,36.17) ; v1(52.09,151.58) 50.62,151.58 49.76,150.71 49.76,146.59 SR41.1 SR123.2 ; v1(67.79,146.24) 67.51,145.96 67.51,143.4 68.45,142.46 SR3701.1
  TOP w0.305: F3R1.2 65.47,68.06 v1(65.74,68.06)
  TOP w0.381: OR127.1 6.67,91.77 v1(7.34,92.45) ; 13,73.14 13,72.11 R7210.1 ; v1(70.28,109.01) 69.52,109.77 69.52,110.07 67.73,111.85 67.73,115.45 65.97,117.21 SR267.1 65.97,120.86 65.02,121.81 65.02,125.74 63.91,126.86 62.34,126.86 61.59,127.6 v1(60.93,127.6)
  TOP w0.457: v1(13,73.19) 13,73.14 13.08,73.22 13.7,73.22 R7215.1 13.79,73.13 R99514.1 ; v1(5.46,29.86) 5.4,29.92 R56.1
  TOP w0.508: v1(60.93,127.6) 60.93,127.75 58.96,129.72 v1(57.43,129.72) ; v1(97.71,28.68) 95.31,28.68 93.67,27.04 88.16,27.04 v1(87.07,28.13) ; R70297.1 v1(27.91,32.04) ; 53.06,73.52 53.58,74.04 54.21,74.04 54.56,74.39 U9434.8 ; 53.06,73.52 53.06,73.09 v1(53.44,72.71) ; 53.06,73.52 52.6,73.98 E61.2 ; 48.53,72.38 CB4134.2 48.53,73.29 48.62,73.39 v1(48.62,74.07) ; v1(142.98,39.03) 142.42,38.47 116.33,38.47 115.06,39.74 112.9,39.74 111.7,40.95 105.65,40.95 v1(105.21,41.39) ; R93111.1 159.98,29.23 159.94,29.2 v1(159.8,29.2) ; v1(5.61,64.51) 5.78,64.34 5.78,61.53 5.17,60.92 v1(5.15,60.92) ; v1(55.48,27.87) 55.47,27.88 v1(55.47,36.34) ; v1(141.04,35.89) 142.05,35.89 151.46,26.48 v1(160.04,26.48) 160.27,26.26 R4814.1 ; v1(9.09,62.25) 9.34,62.25 10.7,60.88 10.7,54.43 v1(8.53,52.26) ; v1(42.5,130.22) 42.47,130.22 42.47,130.22 39.06,130.22 38.38,129.53 35.64,129.53 35.49,129.68 34.34,129.68 34.21,129.56 23.5,129.56 21.47,131.59 v1(17.42,131.59)
  TOP w2.032: 72.9,47.13 72.9,49.37 78.33,54.8 78.33,57.91 76.66,59.59 76.66,61.97
  IN1 w0.254: v1(80.52,105.48) 79.81,105.48 v1(78.31,103.98) ; v1(21.51,60.89) 18.55,60.89 16.91,62.52 15.64,62.52 v1(15.09,61.97) ; v1(165.86,40.88) 168,38.74 168,36.32 v1(167.62,35.94) ; v1(51.91,87.27) 51.91,87.31 51.46,87.76 48.63,87.76 46.56,89.83 ; 45.9,88.15 45.03,87.29 45.03,86.2 45.55,85.69 45.55,84.88 44.98,84.3 44.58,84.3 v1(44.27,83.99) 44.4,83.86 44.4,82.85 41.31,79.76 40.57,79.76 39.69,78.87 39.31,78.87 38.71,78.27 38.71,77.9 38.28,77.47 37.86,77.47 37.82,77.51 36.63,77.51 35.8,76.67 v1(35.8,76.67) ; v1(30.62,81.8) 29.68,82.75 v1(29.68,86.55) 29.06,87.16 29.06,88.75 29.43,89.12 29.43,91.12 v1(29.64,91.33) 29.64,92.21 29.28,92.57 28.83,92.57 28.78,92.52 28.37,92.52 28,92.89 28,93.43 28.45,93.88 v1(28.46,93.88)
  IN1 w0.508: v1(159.8,29.2) 160.04,28.95 v1(160.04,26.48) ; v1(46.74,141.9) 46.41,142.23 45.69,142.23 44.37,140.91 44.37,137.68 42.49,135.8 42.49,130.22 v1(42.5,130.22) 42.49,130.21 42.49,129.08 42.98,128.59 53.1,128.59 54.9,130.39 56.75,130.39 v1(57.43,129.72) ; v1(73.38,43.42) 75.08,41.72 77.01,41.72 77.95,40.78 84.8,40.78 86.71,38.87 86.71,28.49 v1(87.07,28.13) ; v1(100.43,42.5) 101.03,41.9 104.7,41.9 v1(105.21,41.39) ; v1(24.69,140.35) 24.51,140.17 24.51,138.65 18.89,133.04 v1(18.5,133.04) 18.5,132.46 17.63,131.59 v1(17.42,131.59) 17.02,131.18 14.49,131.18 13.55,132.12 11.71,132.12 9.68,130.09 7.04,130.09 v1(5.87,128.92) ; v1(55.48,27.87) 53.06,30.29 50.34,30.29 47.22,33.41 35.67,33.41 34.9,32.64 28.51,32.64 v1(27.91,32.04) 27.58,32.37 22.22,32.37 20.56,34.04 v1(19.99,34.04) 19.32,34.04 15.67,37.69 8.69,37.69 v1(7.21,36.21) 5.38,38.04 3.4,38.04 2.29,39.15 2.29,58.06 v1(5.15,60.92)
  IN2 w0.254: 46.94,94.25 46.94,93.82 47.19,93.56 48,93.56 48.51,93.06 48.51,91.07 48.78,90.8 49.46,90.8 50.72,92.06 52.24,92.06 v1(53.01,92.84) ; v1(21.51,60.89) 21.49,60.89 20.53,61.85 20.53,63.24 20.23,63.54 20.23,68.09 19.57,68.75 19.57,70.25 20.09,70.77 v1(20.09,72.65) ; v1(46.99,102.63) 47,102.63 46.53,102.16 46.53,100.37 46.99,99.91 46.99,98.24 ; v1(18.42,115.18) 18.42,115.12 v1(15.64,112.34) ; v1(13.33,110.98) v1(13.33,112.1)
  IN2 w0.508: v1(8.53,52.26) 8.76,52.02 8.76,50.66 13.07,46.34 22.09,46.34 22.51,45.92 25.1,45.92 26.24,44.78 28.35,44.78 28.8,45.24 v1(28.8,45.46) ; v1(52.09,151.58) 53.3,151.58 54.29,152.56 59.75,152.56 61.26,151.04 63.6,151.04 v1(64.06,150.59) ; v1(97.71,28.68) 99.2,28.68 99.57,29.05 101.85,29.05 102.21,28.69 105.69,28.69 106.62,27.76 109.24,27.76 109.49,28.01 109.95,28.47 112.29,30.81 117.79,30.81 119.43,29.16 127.47,29.16 134.19,35.89 v1(139.09,35.89) v1(141.04,35.89) ; v3(72.64,44.85) 72.64,44.62 71.02,42.99 69.03,42.99 62.38,36.34 v1(55.47,36.34)
  IN2 w2.032: 70.78,87.4 73.72,87.4 76.33,84.8 76.33,75.61 77.13,74.81 77.13,70
  BOTTOM w0.191: 25.16,96.36 U104.27
  BOTTOM w0.203: SR72.1 57.58,81.79 58.38,81.79 58.52,81.93 ; 58.52,81.93 58.52,81.57 58.42,81.47 SR23.1 ; 58.52,81.93 58.52,82.29 58.56,82.32 SR7951.1 ; 58.52,81.93 59,81.93 59.09,81.84 59.48,81.84 59.57,81.93 60.49,81.93 SR50.1 ; O2CB11.1 26.53,96.48 25.28,96.48 25.16,96.36 ; SR7878.1 38.26,79.12 38.02,79.36 38.02,80.2 38.38,80.56 38.46,80.56 38.9,81 39.4,81 39.71,81.32 SR7944.1
  BOTTOM w0.254: 18.3,70.35 R7211.1 17.17,73 16.37,73.8 15,73.8 R99512.1 14.02,72.82 13.37,72.82 v1(13,73.19) ; v1(22.93,112.08) 22.5,112.51 22.5,113.41 OR29.1 ; 4.16,92.45 v1(7.34,92.45) OR125.1 5.99,90.89 5.52,90.43 5.52,89.95 5.86,89.61 6.37,89.61 7.06,90.3 7.35,90.3 v1(7.39,90.34) 7.61,90.55 OR124.1 ; v1(48.62,74.07) 48.62,74.08 49.08,74.54 v1(49.08,75.2) 49.08,75.21 49.07,75.22 SR403.2 ; SR912.1 34.03,91.19 33.37,91.19 33.27,91.09 31.34,91.09 31.1,91.33 v1(29.64,91.33) ; PR131.1 139.05,35.84 139.09,35.88 v1(139.09,35.89) ; v1(5.61,64.51) 5.61,63.67 6,63.28 6,62.53 6.28,62.25 v1(9.09,62.25) ; SR7931.1 61.23,77.57 60.58,76.93 60.13,76.93 60.1,76.89 58.81,76.89 58.18,76.25 57.62,76.25 ; SR7931.1 61.23,78.22 60.97,78.48 60.46,78.48 60.12,78.82 60.12,79.53 SR9.1 60.65,80.04 60.65,80.24 SR7850.2 61.15,81.27 SR50.1 61.31,82.12 61.31,83.86 60.18,84.99 60.18,86.08 59.92,86.35 59.56,86.35 58.79,87.12 57.95,87.12 57.35,87.72 56.23,87.72 55.99,87.48 55.99,85.4 55.97,85.37 SR73.1 55.43,84.32 55.09,84.32 54.74,83.96 54.74,83.68 54.38,83.33 54.38,82.59 54.7,82.27 SR103.1 ; SR7931.1 61.99,77.21 62.9,77.21 ; SR7851.2 51.08,85.79 51.69,85.79 SR112.1 ; O2R25.2 20.6,72.23 20.5,72.23 v1(20.09,72.65) ; 4.11,104.94 5.23,104.94 OR120.2 ; SR673.1 36.14,88.6 36.14,88.25 36.83,87.57 SR25.1 37.73,87.96 38.52,87.96 39.15,88.59 39.99,88.59 40.42,88.15 42.12,88.15 SR7945.1 42.64,88.03 42.64,88.32 42.71,88.39 SR17.1 43.21,89.21 44.23,89.21 HR74.1 45.49,88.88 v1(45.49,88.66) 45.49,88.45 SR897.1 SR406.1 ; SR673.1 35.22,88.83 35.11,88.72 SR7873.1 33.78,89.41 SR169.1 SR168.1 33.27,90.49 v1(33.15,90.36) ; SR673.1 35.88,88.86 35.88,89.3 35.88,89.31 SR909.1 35.88,90.19 35.89,90.19 SR7882.1 ; v1(160.04,26.48) 163.45,26.48 165.12,24.81 v1(165.57,24.81) ; v1(41.48,95.57) 41.16,95.89 SR226.1 40.4,95.89 40.24,96.04 SR7843.1 SR228.1 SR7939.1 37.27,96.04 37.06,96.26 36.83,96.26 36.71,96.38 35.41,96.38 35.24,96.22 34.63,96.22 34.33,96.52 34.33,96.75 34.31,96.76 34.31,96.78 SR7941.1 33.34,96.76 33.14,96.76 SR410.1 ; SR112.1 51.91,86.1 v1(51.91,87.27) ; SR112.1 52.45,85.56 52.45,85.51 SR118.1 53.14,84.83 SR7955.1 52.79,83.84 51.94,83.84 51.56,83.45 R99519.1 ; SR402.2 48.72,76.17 SR403.2 ; O2CB11.1 27.56,96.64 27.56,95.29 28.19,94.66 28.19,94.41 28.46,94.14 v1(28.46,93.88) ; SR52.1 55.61,78.51 55.4,78.3 SR277.1 54.9,77.87 54.96,77.8 54.96,77.28 55.29,76.95 v1(55.47,76.95) 55.6,76.82 55.6,75.71 55.85,75.45 56.73,75.45 SR346.1 57.53,76.81 SR7949.1 ; PR135.1 140.32,35.37 140.84,35.89 v1(141.04,35.89) ; SR403.2 49.51,75.82 50.29,76.6 v1(50.43,76.6) ; v1(15.64,112.34) 15.33,112.02 OR137.2 ; SR774.1 80.22,105.18 v1(80.52,105.48) ; OR135.2 14.18,110.98 v1(13.33,110.98) ; R2102.1 62.8,108.81 63.45,108.17 64.72,108.17 64.87,108.32 v1(65.94,108.32) 66.39,107.86 67.28,107.86 68.43,109.01 v1(70.28,109.01) 70.28,108.04 69.35,107.11 69.35,106.3 69.98,105.68 74.85,105.68 75.49,105.04 77.25,105.04 v1(78.31,103.98) ; R99530.1 107.12,42.26 R99532.1 ; v1(13.42,95.32) 13.16,95.32 12.77,95.7 12.77,96.33 13.06,96.62 13.74,96.62 14.12,96.24 14.53,96.24 14.93,96.65 14.93,98.77 14.98,98.82 v1(14.98,98.85) ; v1(167.62,35.94) 168,35.56 R4815.1 ; SR411.2 37.07,99.7 37.06,99.68 v1(36.7,99.68) 36.63,99.68 36.44,99.87 HR67.1 35.2,99.87 34.85,100.22 33.86,100.22 33.6,99.96 31.14,99.96 29.92,98.75 29.75,98.75 R60.1 ; v1(13.33,112.1) 13.21,112.22 13.21,112.76 OR133.2 OR132.2 ; SR7928.1 46.23,103.53 46.99,102.77 v1(46.99,102.63) ; 65.14,69.55 SR420.2 65.74,68.12 v1(65.74,68.06) 65.44,67.76 SR237.1 ; SR7878.1 37.68,78.43 36.76,78.43 SR7857.1 35.8,77.46 v1(35.8,76.67) ; 6.17,110.33 6.6,109.9 6.83,109.9 7.37,109.36 v1(8.81,109.36) ; OR142.1 4.68,96.24 ; R2346.1 21.39,115.88 20.51,115.88 19.81,115.18 v1(18.42,115.18) 18.42,114.48 18.53,114.38 OR22.2
  BOTTOM w0.305: 63.52,70.59 63.18,70.93 62.27,70.93 R38.2 SR46.1 61.68,73.33 61.03,73.98 60.88,73.98 60.7,74.16 60.7,74.84 60.21,75.34 PR93083.2 58.53,75.34 57.62,76.25 SR346.1 ; SR401.2 62.8,74.5 62.86,74.44 63.45,74.44 64.21,75.2 ; 64.21,75.2 64.24,75.2 v1(64.67,74.77) 64.86,74.58 SR7852.2 SR400.2 SR7803.1 64.86,70.11 ; 64.21,75.2 SR21.1 64.21,76.5 64.04,76.67 64.02,76.67 63.68,77.02 ; 63.68,77.02 64.07,77.41 64.58,77.41 65.41,76.58 65.9,76.58 66.27,76.95 66.27,77.8 SR7849.1 ; 63.68,77.02 63.49,77.21 62.9,77.21 ; v1(53.44,72.71) 53.63,72.52 53.63,71.76 53.79,71.61 53.86,71.61 ; 53.86,71.61 53.63,71.38 53.63,70.61 53.54,70.53 53.54,70.11 53.05,69.63 HR61.1 ; 53.86,71.61 55.26,71.61 55.91,72.25 SR53.1
  BOTTOM w0.432: R7218.1 6.01,64.9 v1(5.61,64.51) ; 4.09,107.29 OR123.2 5.29,106.99 5.62,106.66 OR122.2 ; 58.75,69.87 58.49,70.13 58.49,71.91 58.04,72.37 SR342.1 57.19,72.37 57.07,72.25 SR53.1 ; 58.75,69.87 59.37,69.87 59.6,69.65 SR343.1 60.93,69.65 SR407.1 62.42,69.65 62.8,69.27 63.84,69.27 64.08,69.51 64.48,69.51 ; 58.75,69.87 58.75,69.65 SR669.2
  BOTTOM w0.457: APR128.2 27.7,46.04 28.34,46.04 28.8,45.58 v1(28.8,45.46) ; 55.98,122 55.58,122 UBC1.1 54.98,121.27 54.51,120.8 53.89,120.8 53.71,120.62 UB1.1 UB1.8 ; PR96.1 72.49,62.75 HT47.1 73.27,61.97 74.37,61.97 75.33,62.93 v3(75.33,63.03) ; 18.57,68.93 18.82,68.67 19.91,68.67 20.18,68.4 20.18,65.83 19.19,64.84 16.33,64.84 ; v1(100.43,42.5) 100.73,42.8 PR116.1 ; R181.1 24.29,32.52 22.77,34.04 v1(19.99,34.04) ; PR7609.1 69.1,54.93 PR93166.1 69.26,54.92 69.56,54.92 70.82,53.66 70.82,53.04 v1(71.54,52.31) 71.98,52.31 72.85,51.45 72.85,45.63 72.82,45.61
  BOTTOM w0.508: v1(5.87,128.92) 3.97,127.02 3.97,113.38 5.15,112.2 5.15,111.57 ; SR116.1 67.79,146.14 v1(67.79,146.24) 67.32,146.71 67.32,147.59 64.96,149.95 64.65,149.95 64.06,150.54 v1(64.06,150.59) ; v1(78.44,69.89) 77.23,68.68 69.52,68.68 69.19,68.35 68.19,68.35 66.35,70.2 66.01,70.2 ; 33.27,51.93 32.93,52.27 32.93,52.89 30.82,55 30.82,56.23 32.41,57.83 32.41,58.73 32.67,58.99 36.09,62.41 36.1,62.41 36.52,62.83 37.31,62.83 38.35,63.87 38.35,65.93 40.25,67.82 E16.6 ; 33.27,51.93 33.72,51.48 35.75,51.48 36.26,51.98 P466.1 ; 33.27,51.93 30.91,49.57 30.91,45.97 30.4,45.46 v1(28.8,45.46) ; v1(6.85,21.05) 6.63,21.28 6.63,22.62 6.18,23.07 6.18,28.93 5.46,29.66 v1(5.46,29.86) 5.46,34.2 7.21,35.96 v1(7.21,36.21) ; 55.98,122 58.11,122 59.6,123.5 59.6,124.87 60.98,126.25 60.98,127.55 v1(60.93,127.6) ; v1(142.98,39.03) 143.72,38.28 v2(143.72,37.91) v1(143.72,36.17) 141.32,36.17 v1(141.04,35.89) ; 74.37,105.68 74.37,104.97 74.87,104.47 74.87,103.69 74.51,103.33 74.51,101.03 73.13,99.65 73.13,97.4 72.51,96.79 70.14,96.79 68.72,95.37 v1(68.02,95.37) ; 3.55,90.1 3.26,89.8 3.26,68 4.24,67.02 5.02,67.02 5.61,66.43 v1(5.61,64.51) ; R99532.1 105.88,41.39 v1(105.21,41.39) ; v1(9.09,62.25) 9.1,62.23 9.82,62.23 10.35,61.7 14.82,61.7 v1(15.09,61.97) ; v1(44.77,90.87) 44.75,90.86 44.75,90.59 44.69,90.53 HR74.1 ; v1(46.74,141.9) 49.79,144.96 49.79,150.93 50.57,151.71 51.96,151.71 v1(52.09,151.58)
  vias: v1(44.02,95.28) v1(44.79,96.36) v1(73.07,45.56) v3(72.29,45.71) v3(75.64,64.02) v3(76.22,63.29)
+3P3VSB_LAN: length 375.7
  TOP w0.254: v1(26.59,130.96) 26.35,130.72 23.6,130.72 21.84,132.48 21.11,132.48 20.85,132.73 20.85,133.54 20.32,134.08 20.32,135.5 ; v1(36.17,157.61) 36.7,157.61 37.04,157.27 37.15,157.27 LR10.1
  TOP w0.508: v1(34.01,153.81) 34.01,153.46 30.69,150.14 30.69,147.14 29.84,146.29 29.84,143.22 27.74,141.11 27.74,140.05 v1(27.2,139.51)
  IN1 w0.229: v1(26.59,130.96) 25.68,130.96 23.74,129.03 23.74,124.17 24.67,123.23 24.67,119.82 25.91,118.59 25.91,118.07 26.73,117.24 26.73,115.86 26.26,115.39 26.26,112.6 26.21,112.55 26.21,110.39 28.28,108.32 28.28,107.58 28.56,107.3 28.56,106.03 28.56,105.44 28.17,105.05 28.17,104.12 28.89,103.39 28.89,101.92 28.62,101.65 28.62,101.16 29.07,100.71 29.23,100.71 29.57,100.37 29.77,100.37 30.06,100.09 30.06,98.9 29.7,98.54 29.7,96.47 30.33,95.84 31.3,95.84 31.55,95.59 31.55,94.98 31.24,94.68 31.24,93.46 v1(31.39,93.32)
  IN1 w0.254: v1(31.39,93.32) 31.9,92.81 31.9,92.21 32.07,92.05 32.07,91.38 31.73,91.04 31.73,89.97 31.29,89.53 31.29,88.36 31.43,88.22 31.43,87.31 32.03,86.71 32.03,86.23 32.03,85.32 33.94,83.42 34.8,83.42 35.52,82.7 35.52,81.49 36.03,80.98 36.03,80.98 36.32,80.69 36.32,80.69 36.35,80.66 36.75,80.66 v1(36.99,80.42)
  IN1 w0.508: v1(57.63,21.38) 58.27,20.74 58.27,20.22 60.59,17.9 65.73,17.9 v1(66.34,17.29) ; v1(24.99,37.89) 25.19,37.89 25.64,37.43 29.49,37.43 30.26,36.65 33.59,36.65 34.14,37.2 36.47,37.2 v1(36.81,37.55)
  IN2 w0.508: v1(13.44,147.94) 12.91,148.47 12.91,150.11 14.86,152.06 16.94,152.06 18.16,150.84 31.32,150.84 34.01,153.53 v1(34.01,153.81) 34.07,153.87 34.07,154.41 35.84,156.19 35.84,157.28 v1(36.17,157.61) ; v1(21.87,136.89) 21.16,136.18 v1(16.1,136.18) 13.32,136.18 8.85,131.71 8.23,131.71 6.09,129.58 5.65,129.58 4.67,128.6 4.67,118.75 5.24,118.18 5.24,117.45 5.04,117.25 5.04,115.98 5.94,115.08 5.94,113.15 5.65,112.85 5.65,105.47 5.41,105.23 5.41,93.36 4.48,92.43 4.48,78.72 5.48,77.71 5.48,75.31 6.01,74.79 6.01,73.66 6.31,73.36 6.31,67.67 5.82,67.17 5.82,66.28 6.22,65.88 6.22,64.77 7.43,63.57 7.43,61.51 6.92,61 6.92,58.42 5.9,57.4 5.9,55.4 6.5,54.79 6.5,51.29 7.42,50.37 7.42,50.1 12.64,44.87 19.24,44.87 21.01,43.1 22.41,43.1 25.13,40.38 25.13,39.23 24.99,39.09 v1(24.99,37.89) ; v1(21.87,136.89) 22.4,136.89 25.02,139.51 v1(27.2,139.51) ; v1(21.87,136.89) 21.06,137.71 21.06,140.54 v1(20.57,141.03) ; v1(66.34,17.29) 66.98,16.65 71.75,16.65 72.43,17.33 76.1,17.33 76.83,18.06 v1(76.83,18.79)
  BOTTOM w0.221: 16.42,137.44 16.67,137.69 U114.11
  BOTTOM w0.222: U114.32 v1(21.87,136.89)
  BOTTOM w0.254: SR164.1 32.87,93.07 32.83,93.11 SR163.1 32.26,93.61 31.96,93.32 v1(31.39,93.32) ; v1(27.2,139.51) 25.93,139.51 25.33,140.11 R4005.1 ; v1(36.99,80.42) 37.21,80.42 37.35,80.56 37.36,80.56 37.36,80.57 37.39,80.57 37.68,80.86 37.68,80.89 SR911.1
  BOTTOM w0.457: R4004.1 21.06,142 20.62,141.57 ; 16.42,137.44 15.71,136.73 C4004.1 C4005.1 15.78,135.92 16.05,136.18 v1(16.1,136.18) ; v1(13.44,147.94) 13.41,147.92 LR9.1
  BOTTOM w0.508: 94.21,8.5 93.45,7.74 89.96,7.74 87.4,10.3 87.4,15.76 85.37,17.8 77.82,17.8 v1(76.83,18.79) ; v1(36.81,37.55) 37.69,36.67 v2(37.69,36.03) 37.69,32.25 37.17,31.72 37.17,23.49 41.14,19.52 47.03,19.52 51.94,24.42 57.02,24.42 57.63,23.82 v1(57.63,21.38)
+3P3VSB_LAN_EN: length 22.6
  TOP w0.102: v1(98.53,10.28) 98.96,10.28 ECR157.2 99.21,9.64 98.91,9.34 PC9416.1 ECR156.2
  IN1 w0.102: v1(92.73,24.7) 92.73,18.91 98.53,13.12 v1(98.53,10.28)
  BOTTOM w0.102: v1(92.73,24.7) 93.37,24.07 v2(93.75,24.07) ; PU8402.5 98.2,10.61 v1(98.53,10.28)
+3P3VSB_LED: length 2.9
  TOP w0.508: CR23.1 166.37,34.63 166.63,34.9 R4817.2 166,35.94 v2(165.64,36.29)
+ADP_19V: length 398
  TOP w0.254: v1(37.57,120.16) 37.57,123.88 36.64,124.81 31.9,124.81 31.22,124.12 31.22,123.13 29.34,121.25 26.7,121.25 26.47,121.02 ; v1(96.06,169.81) 95.71,169.81 95.3,169.41 PR89005.1
  TOP w0.457: v1(140.31,169.12) 138.41,167.22 136.52,167.22 134.86,165.56 R93098.1
  TOP w0.508: 119.87,40.72 v1(118.68,39.53)
  TOP w1.524: 37.72,152.95 37.72,149.19 34.81,146.28 34.81,142.28 32.64,140.11 32.64,136.08 32.35,135.79 32.35,133.12
  TOP w1.778: 160.87,45.49 159.98,44.6 159.92,44.6 159.8,44.48 155.18,44.48 154.07,43.37 139.37,43.37 136.92,40.92 133.56,40.92 131.25,43.23 128.71,43.23 125.61,40.12 120.47,40.12 118.82,41.77 116.35,41.77 113.97,44.15 94.6,44.15 94.2,44.55 90.35,44.55 87.6,47.3 87.6,49.59 83.87,53.32 83.87,57.6 82.85,58.61 82.85,59.65 81.63,60.87 81.63,62.6
  IN1 w1.626: 97.08,169.13 98.7,167.5
  IN1 w2.54: 163.11,41.29 163.11,37 163.32,36.79 163.32,24.48 159.23,20.39 ; 164.03,66.72 164.03,53.61 166.06,51.58 166.06,47.96 164.26,46.17 164.26,46.14 163.22,45.1 ; 162.05,85.16 164.08,83.12 164.08,70.6
  IN2 w0.508: v1(158.93,166.92) 156.31,169.53 155.01,169.53 154.61,169.13
  IN2 w1.524: 161.95,151.2 161.95,157.62 159.31,160.26 158.56,160.26 157,161.83 157,162.27 154,165.27 154,167.4 ; 37.69,156.63 37.69,160.29 38.38,160.98 38.38,161.36 46.23,169.2 81.68,169.2
  IN2 w2.54: 163.1,40.11 163.1,35.92 163.32,35.7 163.32,24.5 159.23,20.41 ; 162,85.18 164.08,83.1 164.08,70.62 ; 163.22,45.15 165.96,47.89 165.96,51.68 164.03,53.61 164.03,66.79
  BOTTOM w0.254: v1(118.68,39.53) 118.41,39.26 R93106.1 119.13,37.87 v2(119.25,37.99) ; R93116.2 37.09,113.34 37.04,113.39 M1R16.1 35.89,117.39 37.57,119.07 v1(37.57,120.16)
  BOTTOM w0.508: PU93003.8 36.2,146.75 36.49,147.04 PC6301.2 36.49,151.18 37.95,152.64 v3(37.95,154.29)
  BOTTOM w1.524: 110.78,168.13 110.78,169.42 111.73,170.37 126.39,170.37 ; 23.72,128.01 25.01,129.3 31.62,129.3 32.39,130.07
  vias: v1(25.77,120.28) v1(26.14,121.25) v1(26.31,120.62) v1(109.09,167.02) v1(109.75,167.02) v1(110.36,167.22) v1(139.93,10.63) v1(139.93,10) v1(139.93,9.36) v1(141.27,10.43) v1(141.27,9.79) v1(153.72,168.56) v1(154.25,168.91) v1(154.8,168.6) v3(32.49,131.31) v3(33.4,131.31) v3(37.44,155.06) v3(82.52,169.64) v3(83.49,169.64) v3(131.49,20.06) v3(131.49,19.17) v3(131.49,18.28) v3(131.49,17.39) v3(131.49,16.5) v3(160.35,95.37) v3(160.37,93.72) v3(160.88,149.62) v3(160.87,148.68) v3(160.87,147.79) v3(160.87,146.9) v3(161.06,47.26) v3(161.49,145.56) v3(161.52,85.13) v3(161.64,95.14) v3(161.72,150.13) v3(161.72,149.21) v3(161.72,148.3) v3(161.72,147.39) v3(161.72,146.47) v3(162.1,47.24) v3(162.36,83.99) v3(163.04,85.28)
+BATT: length 157.6
  TOP w0.254: v1(17.78,146.7) 17.94,146.87 19.45,146.87 19.51,146.93 19.54,146.93 R80.1 R71.1 20.89,149.24 C49.1 20.91,150.03 22.17,150.03 22.64,149.56 D3.3 ; v1(27.71,64.91) 27.74,64.89 27.74,64.71 28.14,64.3 v2(29.79,64.3) 29.98,64.3 30.24,64.56 30.24,65.34 SR257.1 30.5,66.7 30.5,68.11 30.71,68.32 30.71,69.35 31.46,70.1 31.46,70.12 31.59,70.25 C2715.1 32.36,71.4 C2726.1 33.25,72.29 33.25,72.56 33.83,73.14 34.87,73.14 36.29,74.56 36.29,76.85 36.65,77.21 37.03,77.21 37.29,77.46 38.27,77.46 38.68,77.88 38.68,78.58 40.32,80.21 U1.BD49 U1.BC49
  IN1 w0.254: v1(17.78,146.7) 17.32,146.24 15.92,146.24 13.84,144.16 13.84,143.04 14.22,142.66 14.22,136.31 14.4,136.13 14.4,134.05 14.07,133.73 12.07,133.73 9.17,130.83 6.79,130.83 3.19,127.22 3.19,111.69 3.87,111.01 3.87,109.55 2.22,107.9 2.22,64.72 v1(5.15,61.79)
  BOTTOM w0.254: v1(27.71,64.91) 26.91,64.11 24.72,64.11 24.32,63.71 22.82,63.71 22.66,63.87 19.82,63.87 18.79,62.84 18.79,62.63 18.38,62.22 16.58,62.22 15.47,61.11 8.77,61.11 8.24,61.65 5.29,61.65 v1(5.15,61.79)
+BATT_SIO: length 100.2
  TOP w0.254: v1(26.74,140.88) 26.3,141.33 26.3,144.91 24.29,146.92 24.09,146.92 23.95,147.06 23.95,148.17 24.09,148.31 24.09,148.31 24.61,148.83 24.61,150.08 24.59,150.1 24.59,150.11 24.37,150.33 23.65,150.33 23.43,150.55 D525.3 ; v1(6.73,96.48) 7.35,97.11 9.66,97.11 10.06,96.71 13.5,96.71 14.24,97.46 17.59,97.46 18.67,96.39 18.67,96.24 R93118.2 19.9,95.84 v2(20.13,96.07) 21.28,97.22 21.28,97.73 21.92,98.36 21.92,99.51 22.63,100.22 23.34,100.22 23.74,100.62 24.28,100.62 24.53,100.37 24.53,99.61 24.26,99.33 O2CB7.1 23.16,98.47 v1(22.71,98.47)
  IN1 w0.254: v1(26.74,140.88) 24.28,140.88 21.82,138.42 21.79,138.42 20.72,137.35 20.72,137.04 17.06,133.37 15.26,133.37 14.92,133.04 v1(12.11,133.04)
  IN2 w0.254: v1(6.73,96.48) 6.59,96.62 6.59,101.17 6.09,101.66 6.09,104.4 6.59,104.89 6.59,109.38 7.38,110.16 7.38,110.61 7.07,110.91 6.6,110.91 6.15,111.37 6.15,112.67 6.43,112.95 6.43,117.68 5.15,118.95 5.15,127 11.19,133.04 v1(12.11,133.04)
  BOTTOM w0.178: U104.21 23.13,98.76 22.84,98.47 v1(22.71,98.47)
+USB3_FRONT0: length 47.3
  TOP w0.457: C941647.1 v1(50.79,17.01)
  TOP w0.508: SC53.1 70.07,22.53 ; SC53.1 70.07,24.69 ; SC53.1 71.16,23.62 ; SC53.1 69.09,23.62
  IN1 w0.762: v3(53.69,20.39) 57,20.39 61.05,16.33 64.68,16.33 64.79,16.45 71.09,16.45 71.42,16.78 72.06,16.78 72.5,16.34 v3(72.5,16.26)
  IN2 w0.254: v1(71.78,15.94) 64.06,15.94 63.4,16.6 58.32,16.6 57.08,17.83 52.25,17.83 v1(51.42,17.01)
+USB3_P7: length 9.1
  BOTTOM w1.524: 61.09,154.32 60.24,155.16 56.62,155.16 55.27,156.5 ; 61.09,154.32 62.77,152.63 ; 61.09,154.32 v2(61.09,154.32)
+USB3_P8:
  vias: v2(41.98,166.94)
+USB3_P56: length 93.6
  TOP w0.254: v1(68.76,151.93) 68.76,148.54 68.31,148.09 68.31,147.47 67.05,146.22 67.05,140.22 67.82,139.46 67.82,137.23 65.33,134.74 62.23,134.74 62,134.51 60.65,134.51 v1(59.76,133.62) ; v1(32.36,109.06) 32.4,109.06 SR698.1
  IN1 w0.254: v1(68.76,151.93) 69.95,153.13 75.06,153.13 75.31,153.38 v1(77.39,153.38)
  IN2 w0.254: v1(51.87,132.68) 53.11,132.68 53.35,132.92 53.92,132.92 54.19,133.18 57.96,133.18 58.39,133.62 v1(59.76,133.62)
  BOTTOM w0.254: v1(32.36,109.06) 33.32,110.02 33.73,110.02 34.11,110.4 34.11,111.75 33.69,112.17 33.69,115.2 33.7,115.21 33.7,117.57 34.72,118.59 34.72,119.94 36.62,121.84 39.16,121.84 40.18,122.86 43.12,122.86 45.68,125.43 55.35,125.43 56.27,126.35 57.94,126.35 58.74,127.15 58.74,127.81 58.28,128.27 54.75,128.27 53.08,129.94 v2(53.08,130.83) 53.08,131.46 v1(51.87,132.68)
+VCORE: length 71.2
  TOP w0.356: XU1.F37 XU1.E36
  TOP w0.635: 102.2,140.81 PCE97027.1 ; PCE97027.1 103.13,141.73 ; PCE97027.1 104.06,140.81 ; PCE97027.1 103.13,139.88 ; 133.75,140.71 PCE97031.1 ; PCE97031.1 135.61,140.71 ; PCE97031.1 134.68,139.78 ; PCE97028.1 141.06,140.56 ; PCE97028.1 141.06,138.8 ; PCE97028.1 139.3,138.8 ; PCE97028.1 139.3,140.56 ; 145.85,138.88 PCE97037.1 ; PCE97037.1 145.85,140.73 ; PCE97037.1 144.92,139.81
  IN1 w0.152: 117.08,121.14 116.61,121.14
  IN1 w0.635: PCE97031.1 133.81,140.71 ; PCE97031.1 135.56,140.71 ; PCE97031.1 134.68,139.83 ; 140.93,140.43 PCE97028.1 139.43,140.43 ; PCE97027.1 102.28,140.81 ; PCE97037.1 145.1,139.06
  IN2 w0.635: 135.61,140.71 PCE97031.1 ; PCE97031.1 134.68,139.78 ; PCE97031.1 133.75,140.71 ; PCE97027.1 103.13,141.73 ; PCE97027.1 104.06,140.81 ; PCE97027.1 103.13,139.88 ; PCE97027.1 102.2,140.81 ; 139.43,140.43 PCE97028.1 ; PCE97028.1 140.93,138.93 ; PCE97028.1 139.43,138.93 ; PCE97028.1 140.93,140.43 ; 144.92,139.81 PCE97037.1 145.85,140.73
  BOTTOM w0.127: 120.01,123.18 120.01,123.59 ; 122.73,124.51 122.73,124.08 ; 121.82,123.61 121.82,123.18 ; 120.9,123.18 120.9,123.61 ; 122.73,125.96 122.73,126.34 ; 115.72,126.61 116.05,126.61 ; 118.43,124.78 118.86,124.78 ; 120.9,122.72 120.9,122.24 ; 122.73,125.4 122.73,124.97 ; 122.06,124.78 122.49,124.78 ; 117.24,126.37 117.24,125.94 ; 121.82,122.72 121.82,122.29 ; 119.34,125.67 119.77,125.67 ; 124.59,127.79 124.59,128.17 ; 122.95,124.78 123.38,124.78 ; 122.57,122.97 120.23,122.97 ; 119.99,122.72 119.99,122.27 ; 124.59,126.88 124.59,127.26 ; 116.65,126.58 116.98,126.58 ; 114.76,126.58 115.16,126.58 ; 115.42,127.14 115.42,126.76 ; 118.43,125.67 118.86,125.67 ; 120.01,124.54 120.01,124.11 ; 117.24,124.56 117.24,124.13 ; 117.24,123.64 117.24,123.1 ; 119.07,126.34 119.07,125.91 ; 119.1,124.54 119.1,124.11 ; 119.1,127.26 119.1,126.82 ; 122.97,125.69 123.4,125.69 ; 119.1,125.4 119.1,124.97 ; 119.1,128.21 119.1,127.78 ; 120.9,124.54 120.9,124.11 ; 121.82,124.54 121.82,124.11 ; 116.58,125.71 116.99,125.71 ; 125.47,127.79 125.47,128.17 ; 118.4,126.61 118.83,126.61 ; 120.23,125.67 120.66,125.67
  BOTTOM w0.254: v1(138.17,132.37) PJP89001.2
  BOTTOM w0.508: v1(129.03,104.29) 129.03,105.34 v2(129.14,105.45)
  BOTTOM w0.635: 144.88,140.77 PCE97037.1 144.88,138.84 ; PCE97028.1 141.15,138.72 ; PCE97028.1 141.15,140.65 ; PCE97028.1 139.22,138.72 ; PCE97028.1 139.22,140.65 ; PCE97027.1 104.1,139.84 ; PCE97027.1 104.1,141.77 ; PCE97027.1 102.17,141.77 ; PCE97027.1 102.17,139.84 ; 135.64,139.74 PCE97031.1 133.71,139.74
  vias: v1(116.63,114.99) v1(116.63,114.36) v1(116.63,113.72) v1(116.63,112.96) v1(116.63,112.2) v1(116.63,111.44) v1(116.75,118.03) v1(116.81,116.78) v1(119.62,108.76) v1(120.46,121.6) v1(120.56,106.48) v1(121.37,121.6) v1(121.45,117.53) v1(121.45,116.01) v1(121.45,114.61) v1(121.45,113.21) v1(121.45,111.82) v1(121.45,110.42) v1(121.45,109.15) v1(124.12,125.23) v1(124.12,123.4) v1(124.12,121.6) v1(124.29,107.49) v1(125.03,125.23) v1(125.03,123.4) v1(125.03,121.6) v1(126.16,117.53) v1(126.16,116.01) v1(126.16,114.61) v1(126.16,113.21) v1(126.16,111.82) v1(126.16,110.42) v1(126.16,109.15) v1(126.84,127.08) v1(126.84,125.23) v1(126.84,123.4) v1(126.84,121.6) v1(127.29,132.67) v1(127.29,131.86) v1(127.54,116.13) v1(127.54,114.73) v1(127.54,113.59) v1(127.57,117.7) v1(127.75,131.04) v1(127.76,128.84) v1(128.67,132.78) v1(128.66,131.86) v1(128.66,128.89) v1(128.66,127.08) v1(128.66,125.23) v1(128.66,123.4) v1(128.66,121.6) v1(128.82,118.8) v1(130.47,132.67) v1(130.47,131.04) v1(130.47,128.89) v1(130.47,127.08) v1(130.47,125.23) v1(130.47,123.4) v1(130.47,121.6) v1(131.43,131.86) v1(131.43,120.67) v1(132.58,132.67) v1(132.58,131.04) v1(132.58,128.89) v1(132.58,127.08) v1(132.58,125.23) v1(132.58,124.29) v1(132.58,123.4) v1(132.58,121.6) v1(133.62,128.89) v1(133.62,127.08) v1(133.62,125.23) v1(133.71,130.93) v1(133.84,133.73) v1(134.54,131.86) v1(134.54,129.8) v1(134.52,121.61) v1(135.42,132.67) v1(135.42,131.04) v1(135.42,128.89) v1(135.42,127.08) v1(135.4,125.23) v1(135.51,120.66) v1(136.37,131.86) v1(136.35,129.8) v1(137.14,130.93) v1(137.23,128.89) v1(137.23,127.08) v1(138.29,129.54) v2(119.62,107.9) v2(128.85,140.1) v3(93.27,141.04) v3(93.27,140.15) v3(93.27,139.26) v3(97.84,141.37) v3(97.86,139.54) v3(98.86,141.39) v3(98.88,139.54) v3(99.9,139.51) v3(100.94,139.49) v3(101.98,139.49) v3(103,139.49) v3(104.06,139.54) v3(105.21,140.22) v3(105.21,139.21) v3(106.35,140.22) v3(106.35,139.21) v3(111.07,140.17) v3(127.05,137.12) v3(127.29,135.91) v3(127.29,134.79) v3(127.96,137.12) v3(128.18,135.91) v3(128.18,134.79) v3(129.09,135.91) v3(129.09,134.79) v3(129.65,139.19) v3(129.65,138.07) v3(130.54,139.19) v3(130.54,138.07) v3(131.17,135.91) v3(131.17,134.79) v3(131.45,139.19) v3(131.45,138.07) v3(132.06,135.91) v3(132.06,134.79) v3(132.95,139.04) v3(132.95,137.92) v3(132.98,135.91) v3(132.98,134.79) v3(133.84,139.04) v3(133.84,137.92) v3(134.76,139.04) v3(134.76,137.92) v3(135.16,135.94) v3(135.16,134.82) v3(136.05,135.94) v3(136.05,134.82) v3(136.61,139.01) v3(136.61,137.89) v3(136.97,135.94) v3(136.97,134.82) v3(137.5,139.01) v3(137.5,137.89) v3(138.41,139.01) v3(138.41,137.89) v3(138.97,135.94) v3(138.97,134.82) v3(139.86,135.94) v3(139.86,134.82)
+VTT_A_DDR_VTTSNS: length 1.8
  BOTTOM w0.457: PR93029.1 134.64,28.91 135.34,28.22 v2(135.34,27.91)
+VTT_A_REF: length 1.2
  BOTTOM w0.457: v2(135.62,29.71) 134.93,30.4 PC941488.1
+VTT_DDR: length 68.4
  TOP w0.254: 91.62,59.85 DIMM2.258
  TOP w0.305: DIMM1.258 91.63,50.38 v3(91.54,50.47)
  IN2 w0.762: v3(85.62,61.56) 87.32,59.86 87.32,57.35 88.93,55.75 89.9,55.75 92.43,53.22 92.43,52.57
  BOTTOM w0.457: PR93029.2 132.93,29.46
  BOTTOM w1.778: 91.77,45.56 92.12,45.2 130.04,45.2 133.13,42.11 133.13,36.85 132.43,36.16 132.43,32.76
  vias: v2(132.43,26.79)
A20GATE: length 4.9
  BOTTOM w0.102: OR22.1 18.25,112.75 18.25,110.57 18.71,110.11 v2(18.71,110.07) U104.119
ACPRESENT: length 10.4
  TOP w0.102: 35.89,81.94 36.19,82.24 36.4,82.24 37.11,82.95 37.54,82.95 38.75,84.16 U1.BG42
  TOP w0.127: SR253.2 33.62,79.62 34.15,79.62 34.74,79.03 35.74,79.03 36.07,79.35 36.07,79.97 v2(35.71,80.33) 35.89,80.51 35.89,81.94
ADAPTOR_PSID: length 153.1
  TOP w0.102: v1(27.68,90.94) 27.89,90.94 28.52,90.32 28.52,89.45 28.5,89.45 28.41,89.35 28.41,88.98 28.11,88.68 27.74,88.68 27.48,88.94 26.12,88.94 25.4,88.22 25.4,88.11 24.2,86.9 24.2,86.3 22.22,84.33 22.22,78.37 18.77,74.92 18.77,72.39 19.84,71.31 21.31,71.31 21.96,70.67 21.96,69.77 22.32,69.41 22.55,69.41 22.87,69.09 22.87,68.4 22.62,68.15 22.62,66.28 v1(22.4,66.06)
  IN1 w0.102: v1(58.11,63.85) 58.11,63.9 57.63,64.38 57.4,64.38 56.39,63.36 55.38,63.36 54.55,62.52 51.79,62.52 51.31,62.04 50.46,62.04 49.87,61.45 45.04,61.45 44.36,60.77 37.78,60.77 37.21,61.34 27.04,61.34 22.82,65.56 22.82,65.64 v1(22.4,66.06)
  IN2 w0.102: v1(106.53,42.48) 103.88,45.13 94.96,45.13 90.02,50.07 90.02,51.55 88.62,52.95 88.62,54.41 85.49,57.54 85.49,58.31 v1(84.61,59.2)
  BOTTOM w0.102: v1(106.53,42.48) 107.3,43.25 v2(107.64,43.25) R93109.2 108.53,42.54 R99530.2 R93110.2 108.02,40.53 D521.3 ; v1(84.61,59.2) 83.22,57.81 77.34,57.81 75.71,59.44 71.73,59.44 67.98,63.19 67.98,64.52 67.77,64.73 66.44,64.73 65.89,64.18 65.2,64.18 64.49,64.89 64.49,65.14 64.24,65.39 58.13,65.39 57.8,65.06 57.8,64.47 58.11,64.15 v1(58.11,63.85) ; SR7888.2 35.73,91.18 34.6,91.18 34.32,90.91 33.48,90.91 33.39,90.81 33.39,90.81 31.23,90.81 31.1,90.93 30.21,90.93 30.13,90.85 29.02,90.85 28.73,90.55 28.38,90.55 27.99,90.95 27.68,90.95 27.68,90.94 v1(27.68,90.94)
ADAPTOR_PSID_B11: length 9.5
  TOP w0.102: U1.AP29 44.5,89.73 v1(44.02,89.73)
  BOTTOM w0.102: SR7888.1 37.67,91.56 v2(37.79,91.43) 38.92,91.43 39.33,91.02 39.97,91.02 40.75,90.24 40.75,90.21 41.02,89.94 42.34,89.94 42.35,89.95 42.69,89.95 43.15,89.49 43.78,89.49 v1(44.02,89.73)
AMP3_1: length 8.2
  BOTTOM w0.635: AR31.1 164.97,47.08 165.5,47.61 165.5,49.43 ; 165.47,51.49 165.47,53.04 166.5,54.07 P6.1
AMP3_2: length 10.9
  BOTTOM w0.635: P6.2 167.09,58.3 167.73,57.66 167.73,53.65 166.46,52.38 166.46,51.54 ; HC6.1 R203.1 166.43,47.93 166.75,47.61 AR30.1
APS_PIN4: length 14.8
  BOTTOM w0.127: APR127.1 APR128.1 29.81,44.88 v2(29.95,44.74) 30.27,44.42 33.58,44.42 35.03,45.87 36.23,45.87 37.06,46.7 38.3,46.7 38.8,47.19 P466.4
AQ2_1: length 7
  TOP w0.254: AQ3.3 28.6,16.68 29.02,17.09 AQ2.1 31.63,17.09 v1(32.15,17.62) AR17.2
  BOTTOM w0.102: v1(32.15,17.62) 32.15,17.52 31.6,16.96 v2(30.58,16.96)
AQ3_1: length 14.8
  TOP w0.102: v1(23.82,20.18) 23.82,18 24.72,17.11 AQ3.1
  BOTTOM w0.102: v2(28.59,17.06) 28.43,17.21 AR29.2 AR19.2 26.08,17.21 25,18.29 25,20.67 24.69,20.98 24.28,20.98 23.99,20.69 AC53.1 22.93,20.44 23.19,20.18 v1(23.82,20.18)
AQ20_PIN2: length 4.4
  TOP w0.102: AQ20.2 69.82,138.09 69.98,138.24 70.31,138.24 70.47,138.07 AQ20.3 70.47,136.25 v2(70.48,136.24) 70.42,136.17 SR7998.2
AQ20_PIN5: length 3.4
  TOP w0.102: AQ20.5 69.82,140.82 SR7999.2 71.54,141.68 v2(71.73,141.87)
BATLOW_N: length 9.9
  TOP w0.127: U1.BF44 39.19,83.33 38.81,83.33 37.95,82.47 37.95,81.92 37.69,81.65 37.69,80.77 37.48,80.56 37.48,80.29 35.98,78.8 34.2,78.8 v2(33.93,79.06) 33.88,79.06 SR252.2
BOARD_ID0: length 13.4
  TOP w0.089: 38.55,86.61 38.57,86.62 39.09,86.62 39.39,86.45 39.45,86.44 39.46,86.43 40.27,86.43 U1.BD38
  TOP w0.102: SR7862.2 30.66,82.44 30.78,82.31 SR7868.2 31.68,81.78 32.19,81.78 32.74,82.32 32.74,82.73 v2(32.82,82.81) 33.09,83.07 34,83.07 34.88,83.95 34.88,84.9 35.1,85.12 35.98,85.12 36.19,85.33 36.48,85.33 37.29,86.14 37.29,86.29 37.53,86.54 38.18,86.54 38.25,86.61 38.55,86.61
BOARD_ID1: length 9.2
  TOP w0.089: 36.99,87.5 37.04,87.56 37.46,87.56 37.49,87.59 39.48,87.59 39.55,87.52 U1.BF35
  TOP w0.102: SR7871.2 31.44,86.63 31.6,86.48 SR7870.2 32.35,86.92 35.09,86.92 35.19,86.82 36.31,86.82 36.99,87.5
BOARD_ID2: length 11.7
  TOP w0.089: 37.4,87.36 37.53,87.36 37.57,87.4 39.42,87.4 39.5,87.32 39.6,87.28 39.8,87.28 39.93,87.41 39.95,87.46 40.11,87.62 40.32,87.62 U1.BD34
  TOP w0.102: v2(31.22,84.5) 31.23,84.51 SR7872.2 31.23,85.7 31.55,86.02 32.69,86.02 32.7,86.01 34.42,86.01 SR7874.2 35.02,86.61 36.39,86.61 37.14,87.36 37.4,87.36
BOARD_ID3: length 7.2
  TOP w0.089: U1.BE34 39.86,87.89 39.76,87.78 37.4,87.78
  TOP w0.102: 37.4,87.78 37.26,87.78 37.23,87.76 36.36,87.76 36.26,87.66 35.91,87.66 v1(35.49,87.24) 35.39,87.34 SR7875.2
  BOTTOM w0.102: SR7873.2 35.37,87.89 v2(35.43,87.95) 35.49,87.89 v1(35.49,87.24)
BOARD_ID4: length 6
  TOP w0.102: U1.L47 56.11,81.18 56.11,80.78 56.11,80.77 56.11,79.75 v1(56.69,79.16)
  BOTTOM w0.102: SR7949.2 57.3,78.25 57.43,78.37 57.43,78.76 57.35,78.83 SR7948.1 ; v2(58.27,78.86) 57.92,79.2 SR7948.1 ; SR7948.1 56.88,79.2 56.84,79.16 v1(56.69,79.16)
BOARD_ID5: length 3.7
  TOP w0.102: v1(56.9,82.88) 56.9,82.75 56.49,82.34 U1.L46
  BOTTOM w0.102: v1(56.9,82.88) 57.56,82.88 v2(57.63,82.95) 58.13,83.44 SR7951.2 58.57,83.84 58.65,83.91 SR7950.1
BT_DISABLE#_R: length 24.9
  TOP w0.102: R3109.1 59.56,54.56 59.35,54.34 59.35,51.92 59.21,51.78 59.21,50.05 58.86,49.71 APD1.1 58.32,49.02 58.22,49.13 58.22,49.64 58.04,49.82 57.14,49.82 APR137.2 56.69,48.99 56.55,48.85 56.03,48.85 55.55,48.36 55.55,47.28 v2(55.45,47.18) 54.89,47.74 53.78,47.74 53.32,48.2 51.77,48.2 50.91,47.34 49.07,47.34 48.74,47.66 48.74,48.72 48.17,49.29 48.17,51.23 47.95,51.45 J218.54
CAP1: length 6.5
  BOTTOM w0.191: U104.128 22.31,107.78 22.55,107.53 23.16,107.53 24.23,108.6
  BOTTOM w0.254: 24.23,108.6 25.07,109.44 v2(25.07,110.61) 25.05,110.62 C85.1
CATERR#: length 215.2
  TOP w0.102: v1(114.96,127.02) 114.96,127.06 XU1.D13
  TOP w0.127: v1(103.13,127.21) 103.13,127.67 102.19,128.61 102.19,129.8 99.36,132.63 99.36,133.72 98.16,134.93 93.03,134.93 92.42,135.54 89.12,135.54 88.7,135.12 88.09,135.12 87.67,135.54 87.67,136.85 87.49,137.03 HR30.2 ; Q9346.1 164.86,39.48 164.67,39.28 164.67,38.56 161.4,35.3 146.18,35.3 145.44,36.03 v1(144.46,36.03)
  IN1 w0.127: v1(103.13,127.21) 103.8,127.21 104.45,127.87 109.01,127.87 109.62,128.48 109.62,128.67 110.02,129.06 110.02,129.08 110.27,129.33 111.55,129.33 113.87,127.02 v1(114.96,127.02)
  IN2 w0.127: v1(114.96,127.02) 115.39,126.58 116.04,126.58 116.34,126.28 116.34,125.09 116.6,124.83 117.81,124.83 118.12,124.52 118.12,123.22 117.86,122.96 115.73,122.96 115.39,122.62 115.39,121.47 115.07,121.15 113.01,121.15 112.35,120.48 112.35,111.68 109.7,109.03 98.26,109.03 90.47,101.24 90.47,96.45 90.98,95.94 90.98,77.28 90.68,76.98 90.68,66.16 91.08,65.75 91.08,63.3 93.26,61.13 94.49,61.13 95.5,60.11 95.5,58.64 98.4,55.74 98.4,54.27 101.17,51.5 101.17,50.69 103.1,48.76 107.36,48.76 110.72,45.41 116.99,45.41 v1(118.97,43.42) ; v1(129.75,41.58) 130.6,40.73 138.56,40.73 140.74,38.55 141.95,38.55 144.46,36.04 v1(144.46,36.03)
  BOTTOM w0.127: v1(129.75,41.58) 128.16,43.17 v2(123.29,43.17) 119.23,43.17 v1(118.97,43.42)
