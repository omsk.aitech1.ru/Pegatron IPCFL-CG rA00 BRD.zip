# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_PP3_B1: length 75
  TOP w0.102: U1.K3 57.04,103.2 56.86,103.38 56.86,105.39 57.35,105.89 57.35,106.05 57.31,106.09 57.31,106.42
  TOP w0.127: 57.66,107.69 57.66,109.67 58.06,110.07 58.65,110.07 59.05,110.48 59.05,111.14 v1(59.46,111.55) ; 57.66,107.69 v2(57.39,107.69) ; 57.66,107.69 57.66,106.76 57.31,106.42 ; RN95.3 62.67,160.48 62.61,160.42 62.35,160.42 62.27,160.33 62.27,157.87 58.83,154.42 55.25,154.42 54.23,153.4 54.23,151.35 53.67,150.79 53.67,145.19 53.26,144.78 53.26,144.49 v1(52.84,144.07)
  IN1 w0.127: v1(52.84,144.07) 52.93,144.16 53.59,144.16 55.06,142.69 55.07,142.69 55.45,142.31 57,142.31 58.09,141.22 58.09,139.69 58.93,138.85 58.93,134.75 58.27,134.09 58.27,132.76 58.84,132.18 60.39,132.18 62.22,130.36 62.22,126.92 60.7,125.41 60.7,123.56 58.93,121.78 58.93,120.49 59.83,119.59 59.83,111.64 59.69,111.5 59.51,111.5 59.46,111.55 v1(59.46,111.55)
USB_PP3_B1_R: length 27.2
  TOP w0.127: RN95.4 62.67,162.31 62.46,162.52 62.46,164.76 62.87,165.18 62.87,167.98 62.26,168.58 62.26,168.95 D3602.1 62.26,169.31 62.26,169.83 62.4,169.97 66.47,169.97 68.96,167.47 68.96,161.53 70.03,160.47 70.03,159.9 70.73,159.2 71.17,159.2 71.26,159.11 71.26,158.76 71.13,158.63 J12.12
USB_PP4_B2: length 95.1
  TOP w0.127: v2(61.21,158.94) 60.93,158.94 ; 60.93,158.94 60.93,157.67 58.44,155.18 54.23,155.18 53.22,154.17 53.22,151.44 52.81,151.02 52.81,149.85 52.55,149.6 52.55,148.81 v1(52.75,148.61) ; 60.93,158.94 60.93,160.57 61.13,160.76 RN89.3 ; v1(56.23,100.7) 56.57,100.36 U1.L9
  IN1 w0.127: v1(56.23,100.7) 55.87,100.7 55.79,100.79 55.79,100.89 56.03,101.13 56.03,101.77 56.49,102.23 56.49,103.95 56.58,104.04 56.58,107.05 55.73,107.9 55.73,108.93 56.49,109.69 56.49,113.21 56.1,113.59 54.29,113.59 52.49,115.39 52.49,122.66 48.89,126.26 43.68,126.26 43.18,126.76 39.87,126.76 39.45,127.18 39.45,127.78 41.51,129.84 41.51,137.94 41.76,138.18 41.76,142.36 41.26,142.85 41.26,145.97 43.44,148.15 46.63,148.15 47.09,147.69 47.09,146.93 47.47,146.55 51.46,146.55 52.42,147.51 52.42,148.28 v1(52.75,148.61)
USB_PP4_B2_R: length 26.7
  TOP w0.127: RN89.4 61.13,162.36 60.93,162.55 60.93,164.69 60.36,165.26 60.36,166.05 D3602.4 60.36,166.41 60.36,167.88 60.97,168.48 60.97,170.05 61.65,170.73 66.95,170.73 71.5,166.18 71.5,162.37 70.96,161.83 J12.3
USB_PP7_B3: length 69.3
  TOP w0.089: U1.L3 56.38,103.26 56.28,103.36 56.28,103.92 56.08,104.13 56.08,104.15
  TOP w0.127: v1(44.37,145.66) 42.92,145.66 42.26,146.32 42.26,148.29 40.59,149.96 40.59,152.48 40.4,152.68 RN80.1 ; v1(58.53,111.41) 58.32,111.62 57.43,111.62 56.87,111.06 56.87,107.58 56.56,107.28 56.56,105.63 56.08,105.15 56.08,104.15
  IN1 w0.127: v1(58.53,111.41) 58.95,111.83 58.95,116.42 58.41,116.97 58.41,121.98 59.83,123.4 59.83,125.35 61.7,127.22 61.7,130.11 60.24,131.56 58.74,131.56 57.76,132.54 57.76,134.3 58.42,134.96 58.42,138.64 57.48,139.58 56.78,139.58 52.72,143.64 48.7,143.64 47.26,145.09 44.71,145.09 44.37,145.43 v1(44.37,145.66)
USB_PP7_B3_R: length 31
  TOP w0.127: RN80.2 40.4,154.46 40.61,154.68 40.61,155.06 40.86,155.3 40.86,155.84 D3702.1 40.86,156.2 40.86,157.1 40.25,157.71 40.25,159.62 42.29,161.66 45.84,161.66 47.24,163.06 52.66,163.06 53.72,161.99 53.72,157.01 52.89,156.17 51.61,156.17 50.62,157.17 J13.7
USB_PP8_B4: length 69.2
  TOP w0.102: 58.67,105.18 58.69,105.16 58.13,104.6 58.13,104.01 58.32,103.81 58.32,103.57 58.38,103.51 58.38,102.7 58.47,102.61 U1.G5
  TOP w0.127: v1(59.88,108.3) 60.09,108.08 60.09,106.6 58.67,105.18 ; v1(44.55,147.3) 43.46,148.39 43.46,149.6 42.14,150.91 42.14,152.46 41.92,152.68 RN86.1
  IN1 w0.127: v1(44.55,147.3) 46.18,145.66 47.64,145.66 48.08,145.22 53.63,145.22 55.38,143.46 57.18,143.46 58.86,141.78 58.86,140.01 59.7,139.17 59.7,136.68 60.43,135.96 60.43,133.58 62.73,131.27 63.24,131.27 64.08,130.43 64.08,127.25 64.82,126.51 64.82,124.37 61.38,120.93 61.38,120.22 61.38,111.43 59.54,109.59 59.54,108.86 59.88,108.51 v1(59.88,108.3)
USB_PP8_B4_R: length 20.1
  TOP w0.127: J13.3 51.37,160.7 51.49,160.57 51.49,159.84 51.03,159.37 49.88,159.37 49.5,159.76 49.5,161.41 48.61,162.3 47.75,162.3 46.35,160.9 43.28,160.9 42.76,160.38 42.76,159.1 D3702.4 42.76,158.74 42.76,157.84 42.15,157.23 42.15,154.69 41.92,154.46 RN86.2
USB_PP14_M.2_BT: length 120.3
  TOP w0.102: U1.F6 59.09,101.65 59.42,101.65 v1(59.61,101.46)
  TOP w0.127: L8.4 30.52,54.42 30.32,54.21 30.32,53.8 30.57,53.55 30.74,53.55 v5(31.04,53.25)
  IN2 w0.127: v1(59.61,101.46) 59.97,101.46 60.13,101.3 60.13,100.68 62.22,98.59 65.33,98.59 67.42,96.5 68.19,96.5 72.29,92.4 72.29,91.28 73.14,90.43 73.14,90.07 78.8,84.41 78.8,80.77 79.12,80.45 79.12,70.96 80.19,69.89 80.19,68.8 79.57,68.19 79.57,64.6 79.08,64.11 79.08,63.89 76.51,61.32 70.91,61.32 70.14,60.56 67.83,60.56 66.84,59.57 66.84,58.99 67.41,58.41 67.41,56.96 66.41,55.96 65.46,55.96 64.87,55.37 64.87,54.15 63.1,52.38 62.62,52.38 61.81,51.56 61.2,51.56 60.46,50.82 60.46,47.6 59.65,46.79 57.49,46.79 56.46,45.76 56.46,44.67 55.26,43.46 53.85,43.46 53.47,43.08 52.6,43.08 52.24,43.44 48.58,43.44 47.87,44.15 47.28,44.15 43.1,48.33 42,48.33 41.35,48.99 39.5,48.99 38.99,49.49 38.41,49.49 37.72,50.19 36.51,50.19 35.49,51.2 33.46,51.2 32.73,51.93 31.42,51.93 30.24,53.12 30.24,53.39 30.38,53.53 30.73,53.53 30.99,53.28 31.01,53.28 v5(31.04,53.25)
USB_PP14_M.2_BT_R: length 9.8
  TOP w0.127: J218.3 35.2,56.12 34.92,55.84 34.14,55.84 32.28,57.7 31.31,57.7 30.52,56.91 L8.3
V_IN: length 6.9
  TOP w0.457: v2(18.34,91.18) 18.34,91.76 17.82,92.28 O2R24.2 O2R22.2 16.81,91.18 16.55,90.91 O2CB19.1
  TOP w0.508: O2CB19.1 v1(16.08,91.56)
  BOTTOM w0.191: U104.46 17.11,91.95 16.9,91.73
  BOTTOM w0.203: v1(16.08,91.56) 16.25,91.73 16.9,91.73
V_SA0_DIMM0_CHA: length 14.8
  TOP w0.102: DIMM2.256 92.12,62.16 91.69,62.6 91.29,62.6 89.08,64.81 89.08,66.74 86.84,68.98 86.84,69.25 D4R5.2 D4R10.1 86.51,71.41 v2(86.92,71.82)
V_SA0_DIMM0_CHB: length 8.6
  TOP w0.102: DIMM1.256 92.13,50.18 92.11,50.21 92.11,51.23 91.71,51.63 v1(91.44,51.63)
  BOTTOM w0.102: v2(93.09,53.1) 93.09,52.45 D4R16.2 ; D4R16.2 91.53,51.54 v1(91.44,51.63) ; D4R16.2 92.18,51.31 92.01,51.15 91.44,51.15 90.93,50.64 90.93,50.07 D4R21.1
V_SA1_DIMM0_CHA: length 14.2
  TOP w0.102: DIMM2.260 91.12,62.38 88.8,64.71 88.8,66.59 86.76,68.63 D4R11.1 D4R6.2 85.18,69.15 84.46,69.15 84.35,69.26 84.35,69.76 v2(83.82,70.3)
V_SA1_DIMM0_CHB: length 6.1
  TOP w0.102: v1(90.48,50.38) 90.55,50.38 91.13,49.8 DIMM1.260
  BOTTOM w0.102: v2(88.85,53.13) 90.16,51.82 90.16,51.26 90.28,51.14 D4R17.2 90.64,50.54 v1(90.48,50.38) 90.42,50.32 D4R22.1
V_SA2_DIMM0_CHA: length 8.1
  TOP w0.102: DIMM2.166 114.62,63.01 113.61,64.02 v1(113.23,64.02)
  BOTTOM w0.102: D4R7.2 111.97,61.93 111.97,63.3 v2(112.5,63.82) 112.27,64.05 112.27,64.39 D4R12.1 113.14,64.02 v1(113.23,64.02)
V_SA2_DIMM0_CHB: length 3.8
  TOP w0.102: DIMM1.166 114.63,50.19 v1(114.39,50.44)
  BOTTOM w0.254: v1(114.39,50.44) 113.89,50.93 113.89,51.3 v2(113,52.19)
VCORE1_CSP1_A: length 6.1
  TOP w0.254: PR89016.2 86.36,157.22 86.37,157.23 v2(86.79,157.23) 87.06,157.23 PR89007.1 87.87,156.95 PC89008.1 87.87,158.14 88.19,158.46 88.19,158.87 88.31,158.99 v1(88.31,159.17)
  BOTTOM w0.229: PU89001.39 89.39,159.77 89.25,159.63 88.72,159.63 88.31,159.22 v1(88.31,159.17)
VCORE2_CSP2_A: length 5.2
  BOTTOM w0.229: PU89001.41 88.6,160.8 88.21,160.42 88.21,160.26 87.81,159.86 87.67,159.86 PC89010.1 PR89017.1 85.89,159.54 85.8,159.63 PR89010.2 85.33,160.28 v2(85.07,160.53)
VCORE3_CSP3_A: length 9.6
  TOP w0.254: PR8901.2 PR89022.2 PR89021.1 86.19,157.93 86.84,157.93 87.53,158.61 v2(87.53,159.02) 86.96,159.02 PC89014.1 86.52,159.49 87.48,160.44 v1(87.48,160.96)
  BOTTOM w0.229: v1(87.48,160.96) 87.77,160.96 88.41,161.6 PU89001.43
VCORE_+19V: length 134.3
  TOP w0.254: v1(93.04,130.52) 93.71,130.52 96.54,127.69 97.7,127.69 99.79,125.59 99.79,119.92 98.53,118.66 93.88,118.66 92.59,117.38 92.59,110.15 91.27,108.83 91.27,102.09 92.05,101.31 92.05,96.72 90.69,95.37 83.51,95.37 82.75,96.13 76.41,96.13 v1(75.82,95.53) ; 90.14,154.04 89.43,153.33 89.43,147.82 91.54,145.71 v1(91.54,143.37)
  IN1 w0.762: 121.61,154.42 114.43,154.42
  IN1 w1.422: 118.74,158.21 115.97,158.21 ; 119.11,158.27 119.1,158.26
  IN2 w0.254: v1(93.04,130.52) 92.62,130.94 92.62,134.99 91.54,136.07 v1(91.54,143.37)
  BOTTOM w0.254: PR112.1 73.68,90.72 74.14,91.18 74.14,92.84 74.78,93.47 74.79,93.51 74.85,93.65 74.9,93.73 74.9,94.62 v1(75.82,95.53)
  BOTTOM w1.27: 168.07,125.44 168.2,125.31 168.2,114.9 168.07,114.77
  BOTTOM w1.524: 168.07,114.77 167.03,113.73 167.03,112.89 ; 168.07,125.44 166.85,126.66 163.27,126.66 159.43,130.5
  BOTTOM w1.651: 159.43,130.5 159.43,135.45 159.89,135.91
  vias: v1(128.7,152.21) v1(133.07,149.9) v2(108.33,159.17) v3(106.22,163.06) v3(106.22,161.79) v3(107.11,163.06) v3(107.11,161.79) v3(108.05,163.06) v3(108.05,161.76) v3(108.94,161.76) v3(108.96,163.06) v3(129.49,152.26) v3(131.42,149.75) v3(132.31,149.75) v3(147.75,152.54) v3(147.75,151.63) v3(148.69,152.54) v3(148.69,151.6) v3(151.92,148.63) v3(151.92,147.72) v3(155.51,148.88) v3(155.51,147.98) v3(155.51,147.02) v3(155.51,146.13) v3(155.52,145.18) v3(156.34,149.29) v3(156.34,148.35) v3(156.34,147.44) v3(156.34,146.52) v3(156.37,145.58) v3(167.56,109.39) v3(167.56,108.45) v3(168.45,109.36) v3(168.45,108.42)
VCORE_ALERT: length 3.3
  BOTTOM w0.127: PU89001.4 90.59,166.09 89.89,166.79 89.64,166.79 v2(89.3,167.14) 89.28,167.16 PR89014.1
VCORE_COMP: length 6.1
  BOTTOM w0.229: PU89001.48 88.46,163.6 88.39,163.67 87.7,163.67 87.57,163.54 86.22,163.54 85.85,163.91 PC89013.1 85.46,163.91 85.37,163.82 PC89003.1
  BOTTOM w0.254: PC89003.1 84.44,163.29 v2(83.29,163.29)
VCORE_COMP_R: length 2.2
  BOTTOM w0.229: 84.14,164.3 PC89003.2
  BOTTOM w0.254: 84.14,164.3 PR89012.2 83.53,165.45 v2(83.21,165.45)
VCORE_CSCOMP: length 63.9
  TOP w0.229: v1(87.22,163.06) 86.5,162.33 PC89018.1 PC89020.1
  TOP w0.254: v1(87.22,163.06) 86.7,163.06 86.22,163.54 86.22,163.95 PR89025.1 85.46,164.71 83.75,164.71 PR89030.2 ; PRT89001.1 121.51,146.71 120.42,145.62 v1(120.42,145.18)
  IN1 w0.203: v1(87.22,163.06) 86.38,162.22 86.38,161.66 86.69,161.36 86.69,160.77 87.44,160.02 96.61,160.02 100.38,156.25 100.38,156 100.38,154.29 99.44,153.36 99.44,148.96 100.15,148.25 100.15,147.59 101.68,146.07 106.4,146.07 106.93,145.53 110.29,145.53 111.76,147.01 115.26,147.01 116.28,145.99 119.35,145.99 120.17,145.18 v1(120.42,145.18)
  BOTTOM w0.229: PU89001.47 88.39,163.2 88.26,163.34 87.83,163.34 87.55,163.06 v1(87.22,163.06)
  BOTTOM w0.254: v1(120.42,145.18) 120.42,146.8 v2(120.83,147.21)
VCORE_CSCOMP_R: length 56.7
  TOP w0.254: PR89026.1 85.09,164.24 PR89025.2 85.19,163.07 v1(85.19,162.98) ; PRT89001.2 121.03,145.14 121.03,144.8 120.78,144.54 v1(120.42,144.54)
  IN1 w0.203: v1(85.19,162.98) 85.19,162.42 86.38,161.23 86.38,160.64 87.31,159.72 96.48,159.72 100.07,156.12 100.07,154.57 99.13,153.63 99.13,148.81 99.82,148.12 99.82,147.31 101.42,145.71 106.09,145.71 106.7,145.1 110.51,145.1 112.11,146.7 115.14,146.7 116.16,145.68 119.18,145.68 120.32,144.54 v1(120.42,144.54)
  BOTTOM w0.254: v2(121.23,145.48) 121.23,145.23 120.55,144.54 v1(120.42,144.54)
VCORE_CSN1_A: length 69.6
  TOP w0.203: v1(126.97,142.24) 126.85,142.12 PJP90002.2
  TOP w0.229: v1(88.95,159.15) 88.95,158.8 PC89002.1 ; v1(84.42,156.53) 84.52,156.63 86.77,156.63 87.16,156.24 87.25,156.24 87.28,156.2 87.97,156.2 88.44,156.67 PR89007.2
  TOP w0.254: PR89007.2 88.44,157.33 PC89008.2 88.71,158.03 88.66,158.08 PC89002.1
  IN1 w0.203: v1(126.97,142.24) 125.97,141.24 117.17,141.24 116.58,141.82 105.71,141.82 104.19,143.35 100.44,143.35 100.41,143.37 100.4,143.37 99.01,144.77 94.56,144.77 89.64,149.7 89.64,155.11 89.03,155.72 89.03,156.1 88.37,156.76 86.71,156.76 86.71,156.76 84.99,156.76 84.76,156.53 v1(84.42,156.53)
  BOTTOM w0.229: PU89001.38 89.79,159.61 89.48,159.3 89.1,159.3 v1(88.95,159.15)
  BOTTOM w0.254: v2(84.85,155.9) 84.85,156.09 v1(84.42,156.53) 83.97,156.97 83.97,158.7 83.39,159.29 83.39,161.93 PR89034.2
VCORE_CSN2_A: length 47.4
  TOP w0.254: PJP90004.2 107.86,142.56 106.58,142.56 106.22,142.92 v1(106.22,143.2)
  IN1 w0.203: v1(106.22,143.2) 105.26,144.16 100.79,144.16 99.34,145.61 94.9,145.61 90.45,150.06 90.45,154.17 91.67,155.39 91.67,156.25 90.02,157.9 86.96,157.9 84.88,159.98 v1(83.88,159.98)
  BOTTOM w0.229: PR89037.2 v1(83.88,159.98) 83.88,159.43 84.19,159.12 84.85,159.12 PC89011.1 85.83,158.61 85.91,158.7 PR89017.2 PC89010.2 87.83,159.18 87.83,159.37 88.54,160.09 88.54,160.26 88.68,160.4 PU89001.40
  BOTTOM w0.254: v2(85.36,157.67) PC89011.1
VCORE_CSN3_A: length 38.6
  TOP w0.254: PR89021.2 86.15,158.81 86.15,158.99 PC89014.2 85.38,159.76 85.38,160.58 v1(85.69,160.89) 86.29,160.89 v2(86.51,160.67) ; PJP93005.2 v1(95.55,142.74)
  IN1 w0.203: v1(95.55,142.74) 94.67,142.74 94.11,143.31 94.11,143.88 88.82,149.16 88.82,154.09 88.16,154.75 85.62,154.75 84.76,155.62 83.73,155.62 82.55,156.8 82.55,159.06 82.7,159.21 82.7,159.76 84.17,161.23 85.35,161.23 v1(85.69,160.89)
  BOTTOM w0.229: v1(85.69,160.89) 85.57,161.01 PR89039.2 86.21,161.5 PC89015.1 87.22,160.48 87.79,160.48 88.52,161.2 PU89001.42
VCORE_CSP1_A: length 64.3
  TOP w0.203: v1(126.97,142.9) PJP90001.2
  TOP w0.254: PR89016.1 84.66,157.22 84.61,157.17 v1(84.48,157.17) v2(83.59,157.17) 82.47,157.17 81.09,158.55 81.09,162.61 82.09,163.62 82.09,163.73 PR89024.2
  IN1 w0.203: v1(84.48,157.17) 88.62,157.17 89.52,156.26 89.52,155.81 90.04,155.29 90.04,149.89 94.73,145.2 99.16,145.2 100.61,143.75 104.5,143.75 106.03,142.23 116.76,142.23 117.35,141.65 125.58,141.65 126.83,142.9 v1(126.97,142.9)
VCORE_CSP2_A: length 41.1
  TOP w0.254: v1(106.88,143.2) 108.27,143.2 PJP90003.2 ; v1(84.36,160.45) 84.34,160.48 83.27,160.48 v2(83.11,160.31) 82.82,160.31 82.31,160.82 PR89027.2
  IN1 w0.203: v1(84.36,160.45) 84.98,160.45 87.11,158.33 90.17,158.33 92.07,156.43 92.07,155.16 90.85,153.94 90.85,150.23 95.06,146.03 99.5,146.03 100.96,144.57 105.51,144.57 106.88,143.2 v1(106.88,143.2)
  BOTTOM w0.254: PR89010.1 84.49,160.28 84.36,160.4 v1(84.36,160.45)
VCORE_CSP3_A: length 30.5
  TOP w0.254: PR89022.1 83.15,158.44 v1(83.02,158.31) 81.99,158.31 81.6,158.7 81.6,162.44 81.89,162.73 PR89031.2 ; PJP93006.2 94.93,143.64 v1(94.68,143.39)
  IN1 w0.203: v1(83.02,158.31) 83.02,156.9 83.9,156.02 84.96,156.02 85.83,155.16 88.37,155.16 89.23,154.29 89.23,149.47 94.68,144.02 v1(94.68,143.39)
  BOTTOM w0.254: v2(82.87,157.59) 83.02,157.73 v1(83.02,158.31)
VCORE_CSREF_A: length 5.5
  BOTTOM w0.229: PU89001.44 87.9,162 v2(87.68,161.79) 86.85,161.79 PC89022.2 86.31,162.33 PR89039.1 85.18,162.33 85.09,162.42 PR89034.1 PR89037.1
VCORE_CSSUM: length 10.2
  TOP w0.254: v2(87.91,161.81) 87.45,162.27 v1(87.15,162.27) 86.37,161.5 PC89018.2 PC89020.2 83.66,161.5 PR89027.1 PR89031.1 PR89024.1 84.03,163.95 PR89026.2
  BOTTOM w0.229: v1(87.15,162.27) 87.25,162.37 88.23,162.37 88.26,162.4 PU89001.45
VCORE_DIFFOUT: length 6.3
  BOTTOM w0.229: PU89001.50 88.33,164.4 87.79,164.94 87.66,164.94 86.92,165.68 86.92,166.7 PR89011.1
  BOTTOM w0.254: PR89018.1 85.38,165.6 v2(85.95,165.6) 86.28,165.92 86.28,166.39 PR89011.1
VCORE_DIFFOUT_R: length 1.9
  BOTTOM w0.229: v2(84.73,167.85) 84.73,167.26 PC89012.2 PR89011.2
VCORE_DRON_A: length 211.9
  TOP w0.254: PR93005.1 160.26,126.44 159.94,126.76 157.33,126.76 v1(156.56,127.52) ; v1(85.47,140.3) 85.47,139.66 85.95,139.18 86.93,139.18 PR93071.1 ; v1(88.14,153.38) 87.68,152.92 87.68,151.96 v1(88.03,151.6)
  IN1 w0.203: v1(99.24,154.63) 98.8,154.19 98.8,148.66 99.46,148 99.46,147.13 101.24,145.35 105.89,145.35 106.6,144.64 110.84,144.64 112.34,146.14 v1(114.3,146.14)
  IN1 w0.254: v1(102.35,166.05) 102.57,165.83 102.7,165.83 103.49,165.04 109.83,165.04 111.25,166.46 111.25,169.35 112.79,170.89 130.51,170.89 132.15,169.26 135.27,169.26 137.55,166.97 145.19,166.97 145.68,167.46 148.49,167.46 149.77,166.18 152.04,166.18 153.77,164.45 153.77,158.62 152.56,157.42 152.56,154.49 155.73,151.32 158.72,151.32 v1(159.87,150.18)
  IN2 w0.203: v1(88.14,153.38) 88.77,154.02 88.77,155.41 90.35,156.99 98.95,156.99 99.62,156.33 99.62,155.01 v1(99.24,154.63) ; v1(156.56,127.52) 155.85,128.23 155.85,130.5 156.54,131.18 156.54,137.21 155.73,138.03 155.73,143.12 156.28,143.68 158.47,143.68 159.79,145 159.79,150.1 v1(159.87,150.18)
  BOTTOM w0.203: PR90013.1 99.16,150.95 99.16,152.22 99.52,152.57 99.52,153.12 99.24,153.41 v1(99.24,154.63) ; PU89001.35 90.99,159.49 90.27,158.76 90.27,158.21 89.89,157.83 89.57,157.83 89.13,157.38 89.6,156.91 89.6,155.63 ; v1(88.03,151.6) 87.35,150.92 v2(87.35,150.74) 88.5,149.59 88.5,144.64 89.25,143.88 89.25,143.25 88.9,142.89 86.38,142.89 85.42,141.93 85.42,140.35 v1(85.47,140.3) ; 89.6,155.63 90.64,154.59 93.29,154.59 94.74,156.03 94.74,156.68 96,157.94 101.58,157.94 103.01,159.37 103.01,165.4 v1(102.35,166.05) ; 89.6,155.63 88.77,154.8 88.77,154.02 v1(88.14,153.38)
  BOTTOM w0.254: v1(156.56,127.52) 156.56,125.92 156.83,125.66 PR93013.1
  BOTTOM w0.279: PR90005.1 114.08,146.36 v1(114.3,146.14)
VCORE_FB: length 8.2
  BOTTOM w0.229: v2(83.03,167.25) 83.41,166.87 PC89012.1 PR89018.2 84.29,165.52 PR89012.1 85.32,164.84 85.41,164.75 PC89013.2 86.03,164.95 PR89019.1 87.11,164.61 87.65,164.61 88.26,164 PU89001.49
VCORE_ICCMAX1: length 3.5
  BOTTOM w0.203: 93.2,158.44 93.2,158.98 93.39,159.17 PU89001.29
  BOTTOM w0.254: PR89065.2 93.02,157.38 v2(93.09,157.45) 93.2,157.57 93.2,158.44
VCORE_ILIM_A: length 8.1
  TOP w0.254: PR89030.1 83.15,165.6 83.74,165.6 83.92,165.42 83.92,165.27 84.12,165.06 86.03,165.06 86.26,164.84 86.26,164.41 v2(86.79,163.88) 87.08,163.59 87.39,163.59 88.03,162.95 v1(88.03,162.86)
  BOTTOM w0.229: PU89001.46 88.09,162.8 v1(88.03,162.86)
VCORE_IMAX: length 3.9
  BOTTOM w0.203: PU89001.36 90.59,159.52 89.72,158.65 v2(89.72,158.44) 89.14,157.85 88.58,157.85 PR89040.2
VCORE_IOUT: length 4.3
  TOP w0.254: v2(89.87,163.95) 88.85,164.98 v1(88.85,165.7) 88.94,165.8 PC89021.1 PR89035.2
  BOTTOM w0.229: v1(88.85,165.7) PU89001.1
VCORE_PROG: length 4
  BOTTOM w0.229: PU89001.10 92.99,167.02 92.9,167.12 v2(92.9,167.7) 93.07,167.87 94.02,167.87 94.33,168.19 PR89036.1
VCORE_PWM1_A: length 42
  IN1 w0.203: v1(114.32,145.45) 112.28,145.45 111.07,144.24 106.42,144.24 105.69,144.97 101.17,144.97 99.11,147.03 99.11,147.81 98.5,148.42 98.5,156.2 97.23,157.47 91.75,157.47 v1(90.74,158.49)
  BOTTOM w0.203: v1(90.74,158.49) 90.74,158.73 91.39,159.38 PU89001.34
  BOTTOM w0.254: v1(114.32,145.45) 114.15,145.28 v2(113.46,145.28)
  BOTTOM w0.279: v1(114.32,145.45) 114.81,145.93 114.81,146.37 115.5,147.07 115.5,148.29 115.98,148.76 PU90001.2
VCORE_PWM2_A: length 19.9
  IN1 w0.254: v1(99.01,155.23) 99.01,156.2 97.38,157.83 91.9,157.83 91.39,158.34 v1(91.39,158.71)
  BOTTOM w0.203: v1(91.39,158.71) 91.39,158.84 91.79,159.25 PU89001.33 ; v2(99.34,148.94) 98.8,148.94 98.42,149.32 98.42,153.53 98.77,153.88 98.77,154.99 v1(99.01,155.23)
  BOTTOM w0.279: PU90002.2 100.24,149.54 99.64,148.94 v2(99.34,148.94)
VCORE_PWM3_A: length 27.6
  TOP w0.254: v1(88.06,150.84) 88.29,150.84 88.54,151.09 88.54,151.88 88.34,152.09 v2(88.34,152.39) 88.34,152.85 88.64,153.15 88.64,154.37 89.58,155.31 89.58,156.1 92.02,158.53 v1(92.02,158.79) ; PU93004.2 87.85,140.57 v1(87.45,140.17)
  BOTTOM w0.203: v1(92.02,158.79) 92.19,158.97 PU89001.32 ; v1(88.06,150.84) 88.87,150.03 88.87,144.77 89.64,144.01 89.64,143.12 89.02,142.5 86.53,142.5 85.85,141.82 85.85,140.94 86.62,140.17 v1(87.45,140.17)
VCORE_SCLK: length 3.4
  BOTTOM w0.127: PR89006.1 90.23,167.97 v2(90.4,167.81) 90.4,166.61 90.99,166.02 PU89001.5
VCORE_SDIO: length 4.1
  BOTTOM w0.127: PU89001.3 90.19,166.08 89.76,166.51 89.21,166.51 88.95,166.77 88.31,166.77 v2(87.98,167.1) 87.98,167.46 PR89004.1
VCORE_TSENSE: length 7.9
  BOTTOM w0.203: PR89068.2 86.88,154.93 v2(86.63,155.18) 86.33,155.48 86.33,156.62 PC89036.1 87.87,158.16 88.67,158.16 89.48,158.97 89.6,158.97 90.19,159.56 PU89001.37
VCORE_TSENSE_R: length 48.9
  TOP w0.254: PRT89003.1 PR89071.1 121.82,142.74 120.85,141.77 116.13,141.77 115.85,141.49 v1(115.85,140.91)
  IN1 w0.203: v1(115.85,140.91) 105.18,140.91 103.45,142.64 97.79,142.64 97.11,141.96 94.3,141.96 93.24,143.02 93.24,143.6 88.11,148.73 88.11,149.57 86.51,151.17 v1(86.51,152.39)
  BOTTOM w0.203: v1(86.51,152.39) 86.51,152.53 v2(87.03,153.05) 87.83,153.85 87.83,154.49 PR89068.1
VCORE_VBOOT/ADDR: length 3.6
  TOP w0.229: v2(92.81,158.93) v1(93.79,158.93)
  TOP w0.254: v2(92.81,158.93) 92.53,158.65 92.53,158.19 PR89038.1
  BOTTOM w0.229: v1(93.79,158.93) PU89001.28
VCORE_VBOOTA: length 3
  TOP w0.229: v1(94.35,159.25) 93.62,159.97 PR89064.2
  BOTTOM w0.229: v1(94.35,159.25) 94.19,159.4 PU89001.27
  BOTTOM w0.254: v1(94.35,159.25) 94.44,159.16 94.44,158.54 v2(94.44,158.54)
VCORE_VCC_C: length 38.7
  TOP w0.254: v1(100.4,162.82) 100.4,164.35 101,164.95 101,165.47 100.07,166.41 100.07,167.27 99.76,167.57 PC89006.1 97.52,168.9 v2(96.72,168.9) 95.91,168.9 94.75,167.74 94.15,167.74 94.03,167.86 93.49,167.86 93.16,168.19 ; v1(82.09,160.16) 82.29,160.16 83.11,159.35 PR8901.1
  IN1 w0.254: v1(82.09,160.16) 82.09,160.58 85.1,163.59 88.83,163.59 89.07,163.35 94.88,163.35 96.09,164.56 98.02,164.56 98.88,163.69 99.52,163.69 v1(100.4,162.82)
  BOTTOM w0.229: PU89001.7 91.79,166.08 91.29,166.59 91.29,167.09 91.41,167.21 91.41,167.43 v1(91.49,167.5)
VCORE_VRDY_A: length 9.9
  TOP w0.254: v2(87.65,168.32) 87.77,168.2 88.85,168.2 PR89105.2 ; PR89105.2 89.34,168.4 89.47,168.28 PR89009.2 ; PR89105.2 89.64,168.7 90.05,168.28 90.53,168.28 90.86,168.62 90.86,169.27 v1(90.7,169.43)
  BOTTOM w0.229: v1(90.7,169.43) 91.17,168.96 PC89009.1 91.17,168.28 91.01,168.11 91.01,167.27 90.96,167.22 90.96,166.45 91.39,166.01 PU89001.6
VCORE_VRMP: length 6
  TOP w0.254: v2(94.48,168.31) 94.44,168.35 v1(93.7,168.35) 93.7,168.8 93.91,169.01 PR89005.2
  BOTTOM w0.229: PU89001.9 92.59,166.91 92.34,167.16 92.34,167.94 92.93,168.53 PC89004.1
  BOTTOM w0.254: v1(93.7,168.35) 93.52,168.53 PC89004.1
VCORE_VSN: length 7.1
  TOP w0.254: v2(84.66,169.31) 85.06,168.91 85.44,168.91 85.67,168.68 85.88,168.68 PR89029.2 PC89019.2 87.63,167.25 88.21,166.66 v1(88.21,165.7)
  BOTTOM w0.229: v1(88.21,165.7) 88.21,165.6 88.61,165.2 PU89001.52
VCORE_VSP: length 7.6
  TOP w0.254: v2(88.29,164.76) 87.58,165.47 v1(87.58,165.7) 87.49,165.79 PC89017.1 86.24,165.79 85.99,165.53 PC89016.1 PR89023.2 83.86,166.18 PR89020.2
  BOTTOM w0.229: v1(87.58,165.7) 87.58,165.62 88.39,164.8 PU89001.51
VD11_1: length 3.4
  TOP w0.102: VD11.1 148.54,159.32 148.54,160.49 148.41,160.62 147.79,160.62 M1R25.2
VD11_2: length 1.8
  TOP w0.102: VD11.2 147.58,159.99 M1R26.2
VD33STB: length 9.7
  TOP w0.203: v1(13.75,21.08) 14,21.08 14.16,21.24 U6.20
  TOP w0.381: C941492.1 8.04,19.09 R182.2
  BOTTOM w0.508: v2(14.5,21.35) 14.02,21.35 v1(13.75,21.08) 12.5,21.08 12.06,20.64 9.71,20.64 v1(8.63,21.71)
VF2_1: length 2.1
  TOP w0.635: 149.17,166.13 J125.18 149.17,164.67
VGA_CABLE_DET: length 116.6
  TOP w0.102: J69.29 55.29,136.62 55.55,136.36 55.55,134.92 55.17,134.54 55.01,134.54 54.76,134.29 54.76,132.55 55.11,132.2 55.11,130.6 53.94,129.43 45.37,129.43 44.9,129.9 43.21,129.9 42.5,129.19 39.04,129.19 38.34,128.49 35.82,128.49 35.24,129.07 34.59,129.07 34.16,128.64 24.2,128.64 22.78,127.22 19.76,127.22 19.05,127.93 17.52,127.93 v2(17.35,127.75) 16.56,126.96 16.56,124.78 16.1,124.32 15.34,124.32 v1(15.19,124.48) ; v1(31.11,74.23) 31.11,74.64 31.41,74.93 SR7975.2
  IN1 w0.102: v1(15.19,124.48) 15.42,124.25 15.42,123.42 18.58,120.25 18.58,119.39 18.27,119.08 18.27,116.88 17.86,116.48 17.86,116.17 17.12,115.43 17.12,113.95 16.29,113.12 16.29,112.11 15.67,111.49 15.67,109.24 17.92,106.99 17.92,101.57 17.73,101.38 17.73,100.09 17.26,99.62 17.26,98.55 17.99,97.81 17.99,94.06 18.83,93.22 18.83,91.11 19.59,90.35 19.59,88.97 20,88.56 20,88.39 20.42,87.98 20.42,86.63 21.34,85.71 21.34,79.65 24.65,76.35 25.85,76.35 27.02,75.19 29.91,75.19 30.86,74.23 v1(31.11,74.23)
VGA_CABLE_DET_R: length 37.8
  TOP w0.102: v1(53.07,80.38) 52.58,80.38 52.22,80.74 52.22,80.77 52.15,80.85 U1.Y48 ; v2(30.99,76.16) 31.58,76.16 SR7975.1 32.61,75.14 v1(32.61,74.75)
  IN1 w0.102: v1(32.61,74.75) 33.34,74.03 34.03,74.03 34.55,74.54 35.61,74.54 35.99,74.16 37.13,74.16 38.22,75.25 40.87,75.25 40.98,75.36 43.2,75.36 47.33,71.24 48.19,71.24 49.17,72.21 50.45,72.21 53.71,75.48 53.71,78.66 53.31,79.06 53.31,80.13 v1(53.07,80.38)
  BOTTOM w0.102: v1(53.07,80.38) 53.74,81.06 53.74,81.63 53.85,81.73 54.85,81.73 SR103.2
VIDALERT#: length 140
  TOP w0.127: PR89013.2 v1(88.47,169.43)
  IN2 w0.127: v1(144.88,125.69) 145.01,125.57 150.81,125.57 153.57,128.32 153.57,150.26 151.78,152.05 151.78,157.51 152.6,158.33 152.6,160.01 151.36,161.25 150.82,161.25 149.86,162.22 149.86,166.17 147.89,168.14 145.8,168.14 144.83,167.17 139.73,167.17 138.82,166.27 136.02,166.27 135.62,165.88 133.02,165.88 132.23,166.66 129.51,166.66 128.47,167.71 118.87,167.71 118.03,166.87 116.12,166.87 115.51,166.26 114.96,166.26 114.46,165.76 105.4,165.76 104.52,166.64 104.52,167.63 103.75,168.39 101.62,168.39 100.91,167.68 99.67,167.68 98.79,168.56 95.12,168.56 94.26,169.42 93.36,169.42 92.51,168.57 89.33,168.57 v1(88.47,169.43)
  BOTTOM w0.127: HR23.1 134.29,116.93 134.29,115.97 v2(134.57,115.69) ; HR23.1 HR15.2 ; HR23.1 134.73,117.68 135.03,117.98 135.03,120.79 135.54,121.3 135.73,121.3 137.75,123.32 137.75,124.44 137.78,124.46 138.59,125.28 140.67,125.28 142.44,127.04 143.99,127.04 144.88,126.15 v1(144.88,125.69) ; PR89014.2 v1(88.47,169.43)
VIDSCLK: length 127.2
  TOP w0.127: v2(90.29,168.85) 89.71,169.43 v1(89.43,169.43) PR89002.1 ; v1(144.05,125.69) 144.05,124.97 143.47,124.39 142.15,124.39 141.87,124.67 141.87,124.87 141.54,125.19 140.98,125.19 XU1.E38
  IN2 w0.127: v1(89.43,169.43) 89.86,169 92.33,169 93.18,169.85 94.44,169.85 95.3,168.99 99.02,168.99 99.87,168.14 100.63,168.14 101.32,168.82 103.93,168.82 104.95,167.81 104.95,166.82 105.58,166.19 114.28,166.19 114.78,166.7 115.34,166.7 115.94,167.3 117.85,167.3 118.69,168.14 128.65,168.14 129.69,167.1 132.41,167.1 133.2,166.31 135.45,166.31 135.84,166.7 138.64,166.7 139.55,167.6 144.65,167.6 145.62,168.57 148.07,168.57 150.29,166.35 150.29,162.4 151,161.69 151.56,161.69 153.03,160.21 153.03,158.16 152.21,157.33 152.21,152.25 154,150.46 154,128.14 150.99,125.14 144.61,125.14 v1(144.05,125.69)
  BOTTOM w0.127: PR89006.2 v1(89.43,169.43)
VIDSOUT: length 134.3
  TOP w0.127: XU1.E40 142.78,126.16 143.83,126.16 v1(144.04,126.38) ; PR89001.2 v1(87.48,169.43)
  IN2 w0.127: v1(87.48,169.43) 88.77,168.14 92.69,168.14 93.54,168.99 94.08,168.99 94.94,168.13 98.61,168.13 99.49,167.25 101.09,167.25 101.8,167.96 103.58,167.96 104.09,167.45 104.09,166.46 105.22,165.33 114.64,165.33 115.14,165.83 115.69,165.83 116.3,166.44 118.21,166.44 119.05,167.27 128.29,167.27 129.33,166.23 132.05,166.23 132.84,165.45 135.8,165.45 136.19,165.84 139,165.84 139.91,166.74 145.01,166.74 145.98,167.71 147.71,167.71 149.43,165.99 149.43,161.94 150.54,160.82 151.15,160.82 152.17,159.81 152.17,158.51 151.34,157.69 151.34,151.87 153.14,150.08 153.14,128.5 150.64,126 145.36,126 145.08,126.28 144.14,126.28 v1(144.04,126.38)
  BOTTOM w0.127: HR14.2 v2(136.44,119.78) 137.79,121.14 137.79,121.76 139.14,123.1 139.88,123.84 140.21,123.84 140.51,124.14 140.51,124.51 140.77,124.77 141.74,124.77 143.35,126.38 v1(144.04,126.38) ; PR89004.2 v1(87.48,169.43)
VISACH1_D0: length 102.9
  TOP w0.102: U1.AJ43 48.57,83.79 v1(48.57,83.8)
  IN1 w0.102: v1(63.9,64.95) 63.64,64.69 63.64,64.26 62.05,62.67 62.05,62.34 61.68,61.97 60.24,61.97 60.01,61.74 58.62,61.74 58.29,61.41 56.14,61.41 55.34,60.61 52.59,60.61 52.09,60.11 51.25,60.11 50.64,59.5 48.92,59.5 48.19,58.77 48.19,57.86 47.95,57.61 46.96,57.61 46.56,57.2 44.95,57.2 44.21,57.94 42.58,57.94 42.29,58.23 41.23,58.23 40.65,58.81 40.65,59.29 39.85,60.09 37.49,60.09 36.92,60.66 33.2,60.66 32.3,59.76 31.52,59.76 31,60.27 v1(25,60.27)
  IN2 w0.102: v1(63.9,64.95) 63.9,69.95 64.35,70.4 64.35,71.63 64.04,71.94 64.04,73.1 62.73,74.41 59.87,74.41 58.17,76.11 56.61,76.11 56.11,76.61 56.11,76.95 v1(55.47,77.59) ; v1(48.57,83.8) 49.17,83.8 49.59,83.38 51.52,83.38 52,82.9 52.17,82.9 53.32,81.75 54.79,81.75 56.32,80.22 56.87,80.22 57.31,79.77 57.31,78.88 v1(57.01,78.58)
  BOTTOM w0.102: SR7816.1 SR52.2 ; SR52.2 55.87,77.92 55.8,77.92 v1(55.47,77.59) ; SR52.2 v1(57.01,78.58) ; SR154.1 20.24,44.47 20.67,44.47 22.22,46.03 22.22,50.18 23.39,51.35 23.39,56.68 23.72,57.01 23.72,59.55 24.44,60.27 v1(25,60.27) ; SR7917.1 66.14,64 66.11,63.97 64.88,63.97 v1(63.9,64.95) 63.3,64.34 v2(63.3,64.15)
VISACH1_D0_R: length 3.5
  BOTTOM w0.102: XDP3.9 19.65,46.63 19.82,46.46 SR154.2 20.22,45.73 v2(20.72,45.23)
VISACH1_D1_R: length 3.5
  BOTTOM w0.102: XDP3.11 19.15,46.02 SR155.2 18.38,45.73 v2(17.96,45.3)
VISACH1_D2_PCH_GPP_E_4: length 25.1
  TOP w0.102: U1.AL48 46.89,80.94 47.04,80.79 47.04,78.55 47.57,78.02 47.57,76.67 47.32,76.42 46.94,76.42 46.84,76.32 46.84,75.24 v1(47.16,74.92)
  BOTTOM w0.102: SR343.2 59.66,68.48 56.56,68.48 SR546.1 55.8,67.72 55.09,67.72 54.56,68.25 v2(54.51,68.25) 51.37,68.25 51.2,68.25 50.86,68.59 50.86,69.5 49.28,71.07 49.28,71.94 48.14,73.08 48.14,73.2 47.16,74.19 v1(47.16,74.92)
VISACH1_D2_PCH_GPP_E_5: length 20.7
  TOP w0.102: v1(47.47,87.16) 47.66,87.35 47.95,87.35 U1.AH35
  IN1 w0.102: v1(47.47,87.16) 48.5,86.13 49.8,86.13 50.7,85.23 50.7,83.92 50.55,83.76 50.55,82.64 50.9,82.29 50.9,82.03 50.58,81.71 50.58,80.28 52.42,78.44 52.42,76.22 v1(52.14,75.94)
  BOTTOM w0.102: SR7915.1 54.13,72.64 53.62,73.14 53.48,73.14 v2(53.15,73.47) 53.15,73.8 SR547.1 SR344.2 52.75,75.33 v1(52.14,75.94)
VISACH1_D2_PCH_GPP_E_6: length 21.5
  TOP w0.102: v1(48.91,85.53) 48.52,85.53 U1.AH40
  IN1 w0.102: v1(51.5,75.94) 51.5,77.53 51.28,77.76 51.28,79.3 50.38,80.2 50.38,81.24 49.55,82.07 49.55,82.52 49.5,82.57 49.5,83.01 50.5,84 50.5,85.14 50.11,85.53 v1(48.91,85.53)
  BOTTOM w0.102: v2(57.68,73.8) 57.22,74.26 56.45,74.26 SR548.1 55.73,74.07 55.59,74.07 54.88,74.78 54.08,74.78 53.12,75.73 53.01,75.73 52.39,76.35 51.92,76.35 v1(51.5,75.94) 51.81,75.63 SR345.2
VISACH1_D3_R: length 71
  TOP w0.102: v2(58.37,59.43) 58.37,58.99 58.84,58.52 v1(58.86,58.52)
  IN1 w0.102: v1(58.86,58.52) 58.86,57.64 58.77,57.55 58.16,57.55 57.19,56.57 56.12,56.57 55.87,56.32 54.83,56.32 54.69,56.46 53.36,56.46 52.77,55.87 52.59,55.87 51.68,54.96 51.68,54.61 51.26,54.19 51.26,53.59 50.4,52.74 46.26,52.74 45.84,53.15 43.18,53.15 42.45,53.88 40.29,53.88 40.06,54.1 37.2,54.1 35.44,55.86 35.44,56.51 34.72,57.23 33.68,57.23 33.36,56.91 32.75,56.91 32.47,56.63 29.98,56.63 29.8,56.81 28.57,56.81 28.26,57.12 22.98,57.12 v1(22.24,57.86)
  IN2 w0.102: v1(55.51,69.12) 56.26,68.37 56.26,62.88 58.32,60.82 58.75,60.82 58.9,60.67 58.9,58.56 v1(58.86,58.52)
  BOTTOM w0.102: v1(22.24,57.86) 22.35,57.75 22.35,52.68 22.09,52.42 21.94,52.27 20.05,52.27 19.04,51.26 18.39,51.26 17.97,50.84 17.97,49.81 17.65,49.49 XDP3.17 ; v1(55.51,69.12) 55.51,69.11 55.33,68.93 55.33,68.7 55.38,68.64 SR546.2
VISACH1_D4_R: length 84.5
  IN1 w0.102: v1(18.74,52.01) 19.25,52.01 21.56,49.7 29.24,49.7 29.37,49.57 29.37,49.57 29.69,49.25 32.96,49.25 33.52,48.69 35.63,48.69 38.37,45.96 40.63,45.96 41.57,45.01 42.85,45.01 43.86,46.02 47.01,46.02 47.47,45.56 47.91,45.56 48.7,46.36 51.96,46.36 52.17,46.15 52.17,46.14 52.42,45.89 52.76,45.89 55.57,48.7 v1(55.57,49.27)
  IN2 w0.102: v1(55.57,49.27) 55.1,49.74 55.1,51.98 55.45,52.33 55.9,52.33 57.45,53.88 57.45,54.6 59.92,57.06 59.92,57.36 60.3,57.74 60.3,61.58 60.07,61.81 60.07,62.48 58.17,64.38 57.89,64.38 57.22,65.04 57.22,69.51 57.72,70.01 57.72,71.25 56.79,72.18 56.79,72.84 56.42,73.21 55.67,73.21 54.79,72.33 54.38,72.33 53.94,72.77 v1(53.94,73.42)
  BOTTOM w0.102: v2(56.51,51.22) 56.51,50.87 56.01,50.36 56.01,49.7 v1(55.57,49.27) ; v1(53.94,73.42) 53.94,73.75 SR547.2 ; XDP3.27 15.15,49.36 17.3,51.5 18.24,51.5 v1(18.74,52.01)
VISACH1_D5: length 82.7
  TOP w0.102: v1(52.79,46.91) 53.19,46.52 v2(53.19,44.57) 53.39,44.36 v1(53.39,43.61)
  IN1 w0.102: v1(18.11,51.98) 18.11,51.78 18.3,51.59 19.29,51.59 22.25,48.63 27.13,48.63 27.69,48.07 31.32,48.07 32.15,47.23 32.34,47.23 33.17,46.4 33.17,46.15 36.22,43.1 37.92,43.1 38.47,42.55 43.33,42.55 44.19,43.41 46.22,43.41 46.28,43.35 47.65,43.35 47.9,43.09 52.87,43.09 v1(53.39,43.61)
  IN2 w0.102: v1(56.24,72.79) 56.24,72.32 57.52,71.05 57.52,70.1 56.98,69.56 56.98,63.5 58.9,61.58 59.54,61.58 60.09,61.03 60.09,59.1 59.28,58.28 59.28,57.09 58.26,56.06 57.62,56.06 57,55.44 57,53.71 55.81,52.53 55.36,52.53 54.77,51.94 54.77,50.36 52.79,48.38 v1(52.79,46.91)
  BOTTOM w0.102: SR548.2 56.83,73.38 v1(56.24,72.79) ; v1(18.11,51.98) 17.88,51.76 17.19,51.76 14.65,49.21 XDP3.29
VISACH1_D6_R: length 3.5
  BOTTOM w0.102: XDP3.33 13.65,46.08 SR624.2 14.48,45.73 v2(14.91,45.3)
VISACH1_D7_R: length 6.6
  BOTTOM w0.102: XDP3.35 13.15,46.59 13.06,46.51 SR625.2 13.51,45.28 13.51,44.67 13.69,44.49 v2(16.43,44.49)
VISACH2_CLK_PCH_GPP_F_3: length 81.9
  TOP w0.102: v2(56.82,60.24) 57.24,59.82 57.24,59.76 v1(57.59,59.4) ; v1(47.15,77.48) 47.15,78.16 46.84,78.47 46.84,80.61 46.53,80.91 46.53,81.28 U1.AM47
  IN1 w0.102: v1(17.98,59.55) 18.06,59.64 23.32,59.64 24.06,58.89 27.56,58.89 27.83,58.62 29.61,58.62 30.45,57.77 32,57.77 32.28,58.06 32.89,58.06 33.89,59.06 35.02,59.06 37.46,56.62 38.09,56.62 38.4,56.31 38.4,55.54 38.7,55.25 42.77,55.25 43.54,54.48 44.31,54.48 45.43,55.6 48.77,55.6 48.98,55.81 49.59,55.81 50.15,56.36 50.35,56.36 51.18,57.19 51.18,57.65 52.04,58.51 52.75,58.51 53.25,59.01 56,59.01 56.4,59.4 v1(57.59,59.4)
  IN2 w0.102: v1(47.15,77.48) 47.57,77.05 47.57,76.67 46.96,76.06 46.96,75.4 46.66,75.09 46.66,74.48 48.82,72.32 50.41,72.32 53.08,69.65 53.08,69.36 53.08,68.56 55.24,66.39 55.24,61.24 57.08,59.4 v1(57.59,59.4)
  BOTTOM w0.102: SR402.1 48.13,77.49 48.07,77.55 SR7832.1 47.74,78.09 47.65,77.99 47.65,77.64 47.49,77.48 v1(47.15,77.48) ; SR756.1 14.72,59.21 14.84,59.34 17.77,59.34 v1(17.98,59.55)
VISACH2_CLK_PCH_GPP_F_4: length 87.4
  TOP w0.102: v2(56.92,58.46) 57.35,58.46 v1(57.83,57.98) ; v1(46.24,78.37) 46.24,78.91 46.24,78.91 46.24,79.7 45.98,79.95 45.98,80.3 46.1,80.42 46.1,81.03 U1.AM48
  IN1 w0.102: v1(21.38,57.87) 21.79,58.28 22.41,58.28 23.37,57.33 28.34,57.33 28.65,57.01 29.89,57.01 30.06,56.84 32.39,56.84 32.67,57.12 33.28,57.12 33.6,57.43 34.81,57.43 35.65,56.59 35.65,55.94 37.28,54.31 40.15,54.31 40.37,54.08 42.56,54.08 43.29,53.36 45.93,53.36 46.34,52.94 50.32,52.94 51.05,53.68 51.05,54.27 51.48,54.7 51.48,55.04 52.51,56.07 52.68,56.07 53.29,56.68 54.09,56.68 54.66,57.25 55.74,57.25 56.14,57.65 56.67,58.18 57.48,58.18 57.63,58.18 v1(57.83,57.98)
  IN2 w0.102: v1(46.24,78.37) 46.7,77.91 46.7,75.42 46.46,75.18 46.46,74.39 48.74,72.11 50.32,72.11 52.87,69.56 52.87,69.44 52.87,68.47 55.04,66.31 55.04,61.15 57.83,58.36 v1(57.83,57.98)
  BOTTOM w0.102: v1(46.24,78.37) 46.52,78.09 SR7833.1 46.58,78.61 46.58,79.39 46.91,79.72 47.62,79.72 48.32,80.42 48.86,80.42 49.1,80.18 49.1,79.9 48.55,79.35 48.55,76.8 48.69,76.66 SR403.1 ; v1(21.38,57.87) 21.38,57.68 21.75,57.3 21.75,56.75 20.85,55.85 20.85,55.18 20.65,54.98 XDP3.6
VISACH2_D4_PCH_GPP_F_0: length 81.1
  TOP w0.102: U1.AN47 45.9,81.65 45.9,80.5 45.78,80.39 45.78,79.87 46.01,79.64 46.01,78.78 45.82,78.6 45.82,78.19 46.06,77.95 46.43,77.95 46.68,77.69 46.68,77.31 v1(47.15,76.84)
  IN1 w0.102: v1(23.11,61.2) 23.75,60.57 23.75,60.36 24.66,59.45 27.3,59.45 27.46,59.61 30.7,59.61 31.16,59.15 32.58,59.15 33.48,60.05 36.67,60.05 37.24,59.48 39.12,59.48 41.02,57.57 41.32,57.57 42.3,56.59 46.94,56.59 47.33,56.99 48.23,56.99 48.6,57.35 49.94,57.35 50.19,57.6 50.19,58.19 51.5,59.5 52.34,59.5 52.84,60 55.59,60 56.27,60.67 57.77,60.67 v1(58.06,60.38)
  IN2 w0.102: v1(54.24,68.93) 56.06,67.11 56.06,62.8 58.06,60.79 v1(58.06,60.38)
  BOTTOM w0.102: v1(47.15,76.84) 47.15,76.38 47.07,76.29 47.07,75.6 47.74,74.92 47.74,74.82 48,74.57 48,73.63 48.35,73.29 48.35,73.16 49.77,71.74 49.89,71.74 50.13,71.49 50.13,70.62 51.06,69.7 51.06,68.67 51.28,68.45 53.77,68.45 v1(54.24,68.93) 54.05,69.12 54.05,69.63 SR7829.1 54.79,69.54 55.69,69.54 56.22,69 SR669.1 ; SR753.1 17.76,58.73 18.39,58.73 20.01,60.35 21.64,60.35 v2(22.4,61.11) 22.49,61.2 v1(23.11,61.2)
VISACH2_D4_PCH_GPP_F_1: length 91.2
  TOP w0.102: v1(47.01,82.27) 46.87,82.14 U1.AM46
  IN1 w0.102: v1(62.03,63.61) 61.63,63.21 61.14,63.21 60.81,62.88 59.05,62.88 58.02,61.85 56.01,61.85 55.17,61.01 52.42,61.01 51.92,60.52 51.08,60.52 50.5,59.94 48.14,59.94 47.12,58.91 47.12,58.07 46.45,57.41 45.03,57.41 43.66,58.78 42.66,58.78 42.35,58.47 41.27,58.47 40.85,58.89 40.85,59.37 39.93,60.29 37.58,60.29 37.01,60.86 33.1,60.86 32.2,59.96 31.6,59.96 31.09,60.48 26.24,60.48 25.63,61.09 25.63,61.11 v1(24.99,61.75)
  IN2 w0.102: v1(62.03,63.61) 62.38,63.26 62.63,63.26 63.07,63.69 63.07,64.02 62.38,64.71 62.38,65.7 63.34,66.66 63.34,68.91 62.97,69.28 62.97,70.7 63.42,71.16 63.42,71.37 63.62,71.57 63.62,72.26 63.25,72.62 63,72.62 v1(62.58,73.04) 62.48,73.14 60.27,73.14 57.91,75.5 55.71,75.5 53.49,77.73 53.1,77.73 51.99,78.83 50.99,78.83 50.37,79.46 50.37,79.99 49.87,80.48 49,80.48 48.47,81.01 48.27,81.01 v1(47.01,82.27)
  BOTTOM w0.102: SR754.1 17.15,59.13 18.22,59.13 20.43,61.34 21.26,61.34 21.77,61.86 21.77,62.38 v2(22.26,62.87) 22.29,62.89 23.85,62.89 v1(24.99,61.75) ; 62.58,73.04 63,72.62 63.65,72.62 SR400.1 ; 62.58,73.04 62.11,73.51 62.11,73.65 SR7830.1 ; 62.58,73.04 v1(62.58,73.04)
VISACH2_D4_PCH_GPP_F_2: length 99.2
  TOP w0.102: v1(46.05,84.26) 46.05,84.26 46.05,84.2 U1.AM43
  IN1 w0.102: v1(62.96,57.84) 61.18,57.84 60.26,56.93 58.12,56.93 57.36,56.16 56.29,56.16 56.04,55.92 54.66,55.92 54.52,56.06 53.53,56.06 52.93,55.46 52.76,55.46 52.09,54.79 52.09,54.44 51.69,54.04 51.69,53.32 50.7,52.33 46.09,52.33 45.67,52.75 42.26,52.75 41.98,53.03 39.5,53.03 38.63,53.9 37.11,53.9 35.24,55.77 35.24,56.42 34.92,56.75 34.57,56.75 34.22,56.39 33.86,56.39 33.72,56.53 32.66,56.53 32.56,56.43 29.9,56.43 29.72,56.61 28.49,56.61 28.17,56.92 22.58,56.92 22.06,57.44 17.17,57.44 v1(15.72,58.89)
  IN2 w0.102: v1(62.96,57.84) 62.96,58.28 64.12,59.43 64.12,62.85 63.57,63.4 63.57,64.16 63.95,64.53 64.15,64.53 64.32,64.7 64.32,65.31 64.25,65.38 64.25,70.01 64.55,70.31 64.55,71.81 64.25,72.11 64.25,73.18 62.81,74.62 60.63,74.62 v1(58.95,76.29) 58.14,77.1 56.67,77.1 55.65,78.13 54.72,78.13 52.83,80.03 52.78,80.03 52.17,80.63 50.58,80.63 49.69,81.52 48.7,81.52 47.14,83.08 47.14,83.36 46.25,84.26 v1(46.05,84.26)
  BOTTOM w0.102: SR401.1 62.18,76.04 v2(62.03,76.19) 61.6,76.62 60.22,76.62 60.21,76.61 60.05,76.61 SR7831.1 59.05,76.19 v1(58.95,76.29) ; SR755.1 15.72,58.72 v1(15.72,58.89)
VISACH2_D4_R: length 5.6
  BOTTOM w0.102: XDP3.28 15.15,55.05 15.66,55.55 16.19,55.55 16.79,56.15 17.37,56.15 v2(17.79,56.57) 17.79,57.01 SR753.2
VISACH2_D5_R: length 11.2
  BOTTOM w0.102: XDP3.30 14.65,55.15 15.06,55.57 15.38,55.57 15.57,55.76 16.04,55.76 16.64,56.36 16.64,57.14 SR754.2 16.81,57.96 16.81,58.5 17.24,58.93 18.3,58.93 20.22,60.85 v2(20.67,60.85)
VISACH2_D6_R: length 5.6
  BOTTOM w0.102: SR755.2 16.04,56.72 v2(16.04,56.61) 16.04,56.57 15.24,55.77 14.2,55.77 13.65,55.22 XDP3.34
VISACH2_D7_R: length 5.3
  BOTTOM w0.102: XDP3.36 13.15,55.18 14.32,56.35 v2(14.32,56.84) 14.1,57.06 14.1,58.09 SR756.2
VR_HOT: length 5.9
  TOP w0.254: PR89066.1 96.1,167.67 95.81,167.38 v1(95.81,167.33)
  BOTTOM w0.229: PU89001.12 93.79,166.4 94.39,166.99 94.79,166.99 94.99,166.79 95.33,166.79 95.81,167.27 v1(95.81,167.33) 95.81,167.38 96.14,167.71 v2(96.14,168.7)
VREF: length 2.3
  TOP w0.203: U6.28 16.89,18.12 v2(16.97,18.05) 17,18.01 17,17.78
  TOP w0.254: 17,17.78 17,17.3 AC87.1
VREF_CA_RC: length 3.2
  TOP w0.305: HR7.1 149.5,81.02 HC1.2 149.76,81.68 v1(148.92,82.51)
  BOTTOM w0.305: v2(148.18,82.51) v1(148.92,82.51)
VRM_PWRGD: length 285.2
  TOP w0.102: PU3.15 50.52,138.01 50.52,138.01 PC21.1 49.9,139.11 49.9,140.45 PR27.2 50.75,141.3 v1(50.75,142.18) ; v1(85.41,169.42) 85.86,168.96 86.15,168.96 86.46,168.66 86.62,168.66 86.92,168.36 86.92,167.99 87.2,167.71 PR89009.1 ; v1(159.84,48.43) 157.77,46.36 154.4,46.36 153.58,45.53 118.51,45.53 118.25,45.8 95.29,45.8 94.89,46.2 91.04,46.2 89.25,47.98 89.25,50.27 85.57,53.96 85.57,59.71 84.58,60.71 v1(84.58,62.83)
  IN1 w0.102: v1(161.29,34.43) 159.84,35.88 v1(159.84,48.43)
  IN2 w0.102: v1(50.75,142.18) 51.31,142.74 52.06,142.74 52.16,142.64 52.57,142.64 52.93,142.27 54.81,142.27 55.25,142.71 58.2,142.71 58.35,142.56 64.8,142.56 66.24,144.01 70.31,144.01 73.12,146.83 76.77,146.83 78.47,145.12 v1(79.07,145.12) ; v1(82.12,147.28) 82.65,147.82 82.65,154.3 v1(83.16,154.81)
  BOTTOM w0.102: v1(161.29,34.43) 161.5,34.65 161.5,40.01 162.94,41.45 Q9309.1 ; v1(85.41,169.42) 84.6,169.42 83.87,168.68 82.41,168.68 81.24,167.52 81.24,165.75 82.18,164.81 82.18,162.6 82.65,162.13 82.65,158.87 82.38,158.6 82.38,157.18 82.93,156.63 82.93,155.03 v1(83.16,154.81) ; v1(84.58,62.83) 85.98,64.23 85.98,69.24 v2(85.68,69.53) 85.68,71.13 87.5,72.95 87.5,75.1 90.78,78.38 90.78,94 87.53,97.25 87.53,103.52 93.92,109.91 93.92,116.99 96.1,119.17 96.1,120.88 94.46,122.52 94.46,124.55 93.61,125.4 93.61,127.65 91.13,130.13 91.13,131.41 88.31,134.23 87.83,134.23 85.6,136.45 84.63,136.45 82.27,138.81 79.05,138.81 78.12,139.74 78.12,142.23 78.32,142.42 78.32,143.87 79.07,144.62 v1(79.07,145.12) 79.07,145.21 80.68,146.83 81.66,146.83 v1(82.12,147.28)
VRM_PWRGD_LED: length 25.2
  TOP w0.102: v1(168.58,24.02) 168.58,24.05 CR2.2 ; R4821.1 167.26,43.58 v1(166.85,43.17)
  IN1 w0.102: v1(168.58,24.02) 167.2,25.4 167.2,34.56 168.32,35.68 168.32,38.95 166.85,40.43 v1(166.85,43.17)
  BOTTOM w0.102: v1(168.58,24.02) v2(167.12,25.48)
VRM_PWRGD_LED_D: length 9
  TOP w0.102: v1(166.22,43.17) 166.67,43.63 166.67,43.98 167.21,44.52 167.79,44.52 167.99,44.72 R4821.2
  BOTTOM w0.102: v2(162.1,43.5) 163.2,42.4 Q9309.3 166.53,42.86 v1(166.22,43.17)
WAKE#: length 129.9
  TOP w0.127: v1(63.1,60.7) 63.54,61.13 63.54,62.82 63.09,63.26 63.09,64.02 62.74,64.38 61.06,64.38 60.27,63.59 59.1,63.59 58.42,64.28 56.95,64.28 56.21,63.54 50.04,63.54 49.57,64.01 47.64,64.01 47,64.65 v1(46.18,64.65) ; v1(17.3,104.38) 17.37,104.31 APR18.1 ; v1(39.97,65.43) 39.47,65.93 38.95,65.93 SR262.2 ; v1(59.82,57.96) 59.37,57.51 APR121.2
  IN1 w0.127: v1(32,55.23) 31.85,55.39 28.84,55.39 28.56,55.11 28.25,54.8 27.61,54.8 27.43,54.98 25.95,54.98 25.68,55.25 23.11,55.25 21.87,56.48 16.08,56.48 15.91,56.32 v1(14.93,56.32) ; v1(59.82,57.96) 60.59,58.73 61.89,58.73 62.38,59.22 62.38,60.04 63.04,60.7 v1(63.1,60.7)
  IN2 w0.127: v1(14.93,56.32) 15.24,56.62 15.24,57.67 14.35,58.56 14.35,59.83 12.04,62.14 12.04,64.22 12.58,64.76 12.58,69.39 11.72,70.25 11.72,71.47 11.02,72.17 11.02,72.54 10.35,73.21 10.35,77.04 10.03,77.37 7.45,79.95 7.45,84.59 11.25,88.39 11.25,91.95 12.72,93.43 12.72,96.33 13.4,97.01 13.4,98.68 12.79,99.29 12.79,99.65 12.93,99.79 12.93,100.75 14.1,101.92 15.29,101.92 16,102.63 16,103.57 16.55,104.12 17.04,104.12 v1(17.3,104.38)
  BOTTOM w0.127: v1(46.18,64.65) 45.77,64.24 44.8,64.24 43.82,63.26 41.4,63.26 41.2,63.46 41.2,64.63 40.4,65.43 v1(39.97,65.43) 39.22,64.68 39.22,63.34 37.49,61.61 v2(36.83,61.61) 36.57,61.61 33.21,58.25 33.21,57.49 32,56.29 v1(32,55.23)
WAKE#_R: length 6.3
  TOP w0.127: J219.54 16.94,107.33 17.22,107.05 18.08,107.05 18.75,106.38 X3R14.2 APR119.2 18.75,104.91 18.98,104.68 APR18.2 19.59,103.7 v2(19.84,103.7)
WAKE_M2_SSD_N: length 22.1
  TOP w0.127: v1(47.49,75.99) 47.49,76.24 47.81,76.57 47.81,78.09 47.26,78.64 47.26,80.98 47.21,81.02 47.21,81.44 U1.AL47
  IN2 w0.127: v1(47.49,75.99) 47.49,75.2 47.59,75.1 47.59,73.89 48.72,72.76 52.3,72.76 54.94,70.12 v1(56.64,70.12)
  BOTTOM w0.127: v2(56.03,70.49) 56.4,70.12 v1(56.64,70.12) 57.26,70.12 SR549.1 57.83,70.96 57.68,71.11 SR342.2
WAKE_WLAN#: length 14.2
  TOP w0.127: APR120.1 58.53,56.73 APR121.1 58.14,56 57.89,56.25 v2(57.53,56.25) 55.9,56.25 55.47,55.82 50.74,55.82 48.2,58.36 J218.55
WLAN_3V_EN: length 33
  TOP w0.102: v1(66.24,46.24) 66.24,47.18 65.85,47.58 C941636.1 65.38,48.17 65.07,47.87 63.85,47.87 63.59,48.14 63.59,48.96 MQ26.3 64.21,49.75 64.64,50.18 65.96,50.18 v2(66.8,51.02) 67.33,51.55 SR7880.2
  IN1 w0.102: v1(59.5,48.86) 59.5,48.36 60.37,47.49 60.37,46.46 60.61,46.23 61.87,46.23 62.56,46.92 62.56,49.6 62.82,49.86 65.57,49.86 66.24,49.19 v1(66.24,46.24)
  BOTTOM w0.102: PU10.5 66.5,45.98 v1(66.24,46.24) 65.96,46.52 64.77,46.52 64.44,46.19 64.44,45.85 SR7877.2 ; SR78.1 59.5,49.14 v1(59.5,48.86)
WLAN_CLKREQ1_N: length 39.6
  TOP w0.127: U1.BE31 40.22,89.56 v1(40.6,89.18)
  IN2 w0.127: v1(52.09,63.97) 52.09,64.05 49.62,66.53 48.49,66.53 47.44,67.58 46.94,67.58 46.65,67.87 46.65,68.62 44.41,70.86 44.41,71.27 43.62,72.06 43.62,73.01 40.26,76.37 40.26,76.88 39.65,77.49 39.65,78.28 39.6,78.32 39.6,78.68 39.75,78.83 39.75,80.43 39.2,80.98 39.2,86.62 40.6,88.02 v1(40.6,89.18)
  BOTTOM w0.127: APR75.1 v2(52.03,62.8) 52.09,62.87 v1(52.09,63.97) ; v1(40.6,89.18) 40.35,89.44 SR7895.2 39.91,89.74 39.75,89.91 38.56,89.91 38.3,90.16 37.15,90.16 SR909.2
WLAN_CLKREQ1_N_R: length 6.4
  TOP w0.127: J218.53 47.7,58.72 v1(47.75,58.67)
  BOTTOM w0.127: APR75.2 50.77,61.84 50.67,61.74 v2(50.34,61.74) 50.08,61.74 47.75,59.41 v1(47.75,58.67)
WLAN_PCIE_DE: length 67.1
  TOP w0.102: v1(45.21,83.59) 45.16,83.59 U1.AR42 ; J218.51 47.2,59.14 47.32,59.02 47.32,58.49 v1(47.78,58.03)
  IN1 w0.102: v1(47.78,58.03) 47.33,58.47 47.33,58.84 48.22,59.73 50.58,59.73 51.16,60.31 52.01,60.31 52.5,60.81 55.26,60.81 56.06,61.61 58.11,61.61 59.18,62.68 60.91,62.68 61.06,62.83 61.87,62.83 62.61,63.57 v1(62.61,63.87)
  IN2 w0.102: v1(45.21,83.59) 45.32,83.59 45.81,83.1 45.81,82.88 46.83,81.85 47.14,81.85 48.28,80.71 48.48,80.71 48.91,80.28 49.71,80.28 50.16,79.83 50.16,79.37 50.93,78.6 51.92,78.6 53.21,77.31 v1(53.28,77.31) 53.62,77.31 55.63,75.3 57.75,75.3 60.63,72.42 63.17,72.42 63.41,72.17 63.41,71.69 63.22,71.49 63.22,71.24 62.71,70.73 62.71,69.25 63.14,68.82 63.14,66.96 62.16,65.99 62.16,64.32 v1(62.61,63.87)
  BOTTOM w0.102: APR135.2 49.99,60.92 v2(49.05,59.98) 48.25,59.18 48.25,58.5 v1(47.78,58.03) ; PR93083.1 58.27,74.5 57.9,74.87 55.71,74.87 55.09,75.49 55.09,75.99 54.47,76.6 53.98,76.6 v1(53.28,77.31)
WLAN_PE1_TXN8_C: length 10
  TOP w0.127: v1(49.39,56.3) 48.98,56.71 48.54,56.71 48.29,56.46 47.44,56.46 46.97,56.94 44.88,56.94 43.7,58.12 J218.37
  BOTTOM w0.127: M1C70.2 50.04,56.52 50.04,56.66 49.91,56.78 49.45,56.78 49.34,56.67 49.34,56.35 v1(49.39,56.3)
WLAN_PE1_TXP8_C: length 10.1
  TOP w0.127: v1(48.62,56.1) 48.51,56.21 47.33,56.21 46.86,56.68 44.78,56.68 43.45,58.02 43.45,58.52 43.2,58.77 J218.35
  BOTTOM w0.127: M1C69.2 50.07,57.04 49.33,57.04 48.82,56.53 48.82,56.29 v1(48.62,56.1)
WLAN_PWR_CNL: length 47.5
  TOP w0.102: v1(66.42,56.94) 66.79,56.57 66.79,55.63 67.4,55.02 D524.2 ; U1.U48 53.81,81.12 53.81,80.98 53.61,80.78 53.61,79.26 54.82,78.04 55.62,78.04 56.34,77.32 59.21,77.32 60.01,78.12 63.35,78.12 v1(63.47,77.99) 64.16,77.31 SR7929.2
  IN2 w0.102: v1(66.42,56.94) 66.84,57.36 66.84,58.22 65.89,59.17 65.89,62.81 67.32,64.24 67.32,66.73 67.98,67.39 67.98,67.96 67.98,71.39 67.33,72.05 66.56,72.05 66.28,72.33 66.28,76.89 64.57,78.6 64.22,78.6 63.79,79.03 63.44,79.03 63.2,78.79 63.2,78.27 v1(63.47,77.99)
  BOTTOM w0.102: v2(67.74,57.06) 67.44,56.76 66.6,56.76 v1(66.42,56.94)
WLAN_RST_N: length 17.9
  TOP w0.127: J218.52 47.45,51.28 47.32,51.15 47.32,50.26 47.73,49.84 47.73,49.01 48.32,48.43 48.32,47.49 48.9,46.92 49.97,46.92 v2(50.39,46.5) 50.66,46.5 51.95,47.78 53.15,47.78 54.25,46.68 55.66,46.68 55.97,46.99 55.97,48 S1C80.2 APR123.2 APR124.2
WLAN_USB_DETECT: length 84.5
  TOP w0.102: SR404.2 62.77,68.01 v1(62.66,68.01) ; U1.AP48 45.49,81.21 45.49,80.67 45.37,80.55 45.37,79.7 45.6,79.47 45.6,78.95 45.41,78.76 45.41,77.76 v1(46.28,76.89) ; J218.1 34.7,58.67 34.7,58.67 v1(34.7,58.44)
  IN1 w0.102: v1(64.11,57.72) 62.95,56.57 58.05,56.57 57.44,55.96 57.19,55.96 55.8,54.57 55.8,54.43 54.52,53.14 53.38,53.14 53.28,53.04 52.37,52.13 46.01,52.13 45.59,52.54 42.18,52.54 41.89,52.83 39.41,52.83 38.55,53.7 37.03,53.7 34.75,55.98 v1(34.75,56.33)
  IN2 w0.102: v1(64.11,57.72) 63.47,57.09 63.47,57.01 62.97,56.5 62.46,56.5 62.2,56.76 62.2,58.16 63.6,59.55 63.6,61.42 61.61,63.4 61.61,63.78 61.96,64.14 61.96,65.64 61.61,65.99 61.61,66.96 v1(62.66,68.01)
  BOTTOM w0.102: v2(34.82,59.15) 34.7,59.02 v1(34.7,58.44) 34.68,58.42 APR134.2 34.68,56.97 34.75,56.91 v1(34.75,56.33) ; v1(62.66,68.01) 62.6,68.07 57.2,68.07 56.44,67.31 54.45,67.31 53.93,67.84 51.03,67.84 50.45,68.42 50.45,69.33 48.88,70.9 48.88,71.77 47.74,72.91 47.74,73.03 46.53,74.24 46.53,75.25 46.66,75.38 46.66,76.36 46.28,76.75 v1(46.28,76.89)
WLQ5_E: length 10.3
  IN2 w0.102: v1(24.69,143.27) 23.65,143.27 v1(21.44,145.48)
  BOTTOM w0.102: v1(24.69,143.27) 24.26,143.27 23.59,142.61 23.59,141.54 v2(23.93,141.21) 24.2,141.49 24.2,141.95 24.85,142.6 Q4001.2 ; R4007.2 21.06,145.1 v1(21.44,145.48)
WLQ5_G: length 5
  BOTTOM w0.102: Q4001.1 25.53,143.7 26.26,142.97 26.26,142.08 26.17,141.98 R4005.2 26.17,140.75 v2(26.8,140.12)
XBT1_1: length 12.5
  TOP w0.457: R70.1 26.25,148.68 28.32,148.68 33.25,153.61 33.25,154.04 33.63,154.43 XBT1.1
XCLK_BIASREF_W4S15L1000MIL: length 4.3
  TOP w0.102: U1.T3 54.61,103.5 54.61,104.21 v1(54.65,104.24)
  BOTTOM w0.127: v2(53.85,106.67) 53.85,105.88 54.49,105.23 SR315.1 54.91,104.92 54.65,104.65 v1(54.65,104.24)
XDP_DBRESET_N: length 7.1
  BOTTOM w0.127: SR759.2 8.76,58.92 8.53,58.69 SR777.2 M1C67.1 9.93,57.86 9.93,56.76 v2(10.08,56.61) 9.65,56.17 9.65,55.64 10.15,55.14 XDP3.48
XDP_PLTRST_CPU#: length 18.4
  TOP w0.127: HR343.2 85.68,135.78 v1(85.43,136.03) 84.96,136.5 v2(84.96,136.82)
  BOTTOM w0.127: v1(85.43,136.03) 87.4,134.06 87.4,133.29 87.82,132.87 87.82,132.32 87.4,131.91 87.4,130.29 88.47,129.23 88.47,128.78 89.3,127.95 89.3,124.02 88.05,122.77 87.74,122.77 HR378.1
XDP_PRS#: length 32.6
  IN1 w0.127: v1(75.54,108.09) 77.7,110.25 77.7,112.74 78.31,113.35 78.31,114.96 80.71,117.36 80.71,120.12 81.3,120.72 v1(81.3,121.55)
  BOTTOM w0.127: HR367.1 85.33,126.75 v2(85,126.42) 84.76,126.18 84.76,125.5 HR383.1 83.38,126.26 81.38,126.26 80.95,125.83 80.95,125.3 81.32,124.93 82.25,124.93 82.8,124.38 82.8,123.94 82.47,123.61 82.47,122.71 82.03,122.27 82.03,122.05 81.53,121.55 v1(81.3,121.55) ; XDP1.60 74.41,106.96 v1(75.54,108.09)
XTAL_24M_IN: length 10.6
  TOP w0.102: U1.U10 53.36,99.8 53.36,101.39 53.49,101.51 53.49,102.7 53.39,103.21 53.39,103.73 53.11,104 53.11,105.65
  TOP w0.127: F3R28.2 52.44,108.57 52.47,108.55 SC32.1 SR321.2 53.25,107.52 52.88,107.15 v2(52.88,107.08) 53.11,106.85 53.11,105.65
