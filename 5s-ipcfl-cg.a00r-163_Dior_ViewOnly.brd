# Allegro board 5s-ipcfl-cg.a00r-163_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPD_TXP3: length 88.2
  TOP w0.102: 118.4,132.41 118.51,132.29 118.51,129.01 XU1.C17
  TOP w0.127: J69.3 55.09,149.62 55.19,149.72 55.59,149.72 v1(56.04,149.27) ; v1(116.55,134.97) 117.17,134.35 117.17,133.63 118.4,132.41
  IN1 w0.127: v1(116.55,134.97) 117.22,135.63 117.22,136.18 115.29,138.11 104.06,138.11 103.69,138.48 98.41,138.48 98.14,138.22 93.03,138.22 91.74,139.51 91.74,140.68 89.43,142.99 89.43,145.48 85.62,149.29 83.71,149.29 83.28,149.72 77.85,149.72 77.01,148.88 75.75,148.88 75.1,148.24 70.05,148.24 69.7,148.58 68.37,148.58 67.92,148.12 64.06,148.12 63.26,148.92 59.4,148.92 58.71,148.23 58.71,147.11 58.46,146.85 55.44,146.85 54.62,147.67 54.62,149.43 54.97,149.79 55.61,149.79 56.04,149.36 v1(56.04,149.27)
DRAMA_RESET#: length 152.1
  TOP w0.089: 40.98,80.1 41.31,80.43 41.31,80.84 41.25,80.9 41.25,81.53 U1.BB46
  TOP w0.127: v1(40.08,77.84) 39.6,78.32 39.6,78.75 40.32,79.47 40.32,79.48 40.9,80.05 40.92,80.05 40.98,80.1 ; v1(113.43,42.15) 112.32,42.15 112.19,42.03 102.36,42.03 101.04,40.71 99.57,40.71 v1(98.11,39.25) ; v1(62.89,62.85) 62.66,63.08 38.06,63.08 SR291.1 SC26.1 36.78,65.33 v1(36.78,65.52)
  IN1 w0.127: v1(113.43,42.15) 118.44,42.15 119.68,40.91 123.34,40.91 126.77,44.34 132.97,44.34 v1(133.45,44.82)
  IN2 w0.127: v1(131.17,58.62) 130.36,57.81 130.36,51.85 130.61,51.6 130.61,50.89 130.53,50.82 130.53,49.42 131.57,48.38 131.57,46.7 v1(133.45,44.82) ; v1(98.11,39.25) 96.42,40.94 96.42,41.73 94.35,43.8 93.7,43.8 88.39,49.12 88.39,50.8 86.97,52.22 86.97,54.18 84.39,56.76 v1(81.48,56.76)
  BOTTOM w0.127: v2(135.15,44.82) SR265.2 v1(133.45,44.82) ; v1(131.17,58.62) 130.98,58.62 130.66,58.94 130.66,59.64 HR411.2 ; v1(62.89,62.85) 63.57,63.54 66.75,63.54 71.47,58.82 75.33,58.82 77.39,56.76 v1(81.48,56.76) ; v1(40.08,77.84) 40.05,77.82 40.05,76.83 37.74,74.51 37.74,66.92 37.1,66.28 37.1,65.85 v1(36.78,65.52)
DRAMB_RESET#: length 23.9
  TOP w0.127: v1(131.54,63.13) 131.11,62.7 131.11,62.15 131.12,62.13 DIMM2.108 ; DIMM1.108 v1(131.13,47.61)
  IN2 w0.127: v1(131.13,47.61) 131.13,48.18 129.74,49.57 129.74,57.87 v1(131.13,59.26)
  BOTTOM w0.127: v1(131.13,47.61) 131.33,47.42 D4C16.1 131.33,46.15 v2(131.55,45.94) ; v1(131.13,59.26) 131.43,59.26 131.75,59.58 HR411.1 CB4132.2 D4C5.1 132.6,62.07 v1(131.54,63.13)
DUAL_POWER_DISCH_G: length 26.5
  BOTTOM w0.102: Q93037.1 123.71,29.06 123.81,29.16 123.81,30.94 122.83,31.93 Q93038.1 123.7,32.41 127.18,35.88 130.38,35.88 130.82,36.32 Q9544.3 130.02,37.35 128.9,38.47 v2(128.9,39.94) 128.9,40.51 M1C44.2 R663.2 127.14,42.04 126.87,42.31 124.23,42.31 124.05,42.13 Q9543.1
E16_CLK: length 4.8
  TOP w0.127: E16.7 42.62,69.84 42.85,69.84 42.98,69.97 43.16,69.97 43.33,69.79 43.33,69.66 43.13,69.46 43.13,69.3 43.3,69.13 43.43,69.13 43.64,69.33 43.76,69.33 44.11,68.99 44.11,68.82 43.95,68.67 43.81,68.67 43.64,68.49 43.64,68.32 43.76,68.19 F3R25.2
E16_CS0#: length 4
  TOP w0.127: F3R27.2 44.26,63.72 44.13,63.59 43.76,63.59 43.61,63.74 43.61,64.68 43.36,64.94 42.97,64.94 E16.1
E16_IO2: length 13.9
  TOP w0.127: F3R26.2 43.25,71.5 43.25,71.95 43.64,72.33 43.64,73.07 42.39,74.31 41.33,74.31 41.2,74.18 39.85,74.18 39.72,74.06 39.72,73.24 39.85,73.12 40.23,73.12 40.36,73.24 40.36,73.65 40.49,73.78 40.82,73.78 40.94,73.65 40.94,73.24 41.07,73.12 41.73,73.12 41.96,73.35 42.42,73.35 42.8,72.96 42.8,72.76 E16.9
E16_IO3: length 5.1
  TOP w0.127: E16.10 41.2,71.26 42.58,71.26 F3R21.2
E16_MISO: length 2.4
  TOP w0.127: F3R20.2 43.24,67.22 E16.5
E16_MOSI: length 2
  TOP w0.127: E16.3 43.52,66.21 43.53,66.23 F3R24.2
EDP_4_HPD: length 3.1
  TOP w0.102: U1.AN6 46.05,101.24 v1(45.84,101.03)
  BOTTOM w0.102: M1R10.1 46.38,100.48 45.84,101.02 v1(45.84,101.03) 45.83,101.04 v2(45.83,102.39)
EDP_DETECT: length 3.7
  TOP w0.102: v1(53.61,82.37) 53.54,82.31 53.39,82.31 53.16,82.08 U1.V47
  BOTTOM w0.102: v1(53.61,82.37) 53.35,82.12 53.35,82.1 v2(53.01,81.75) 52.98,81.73 SR71.2 51.92,81.83 51.92,82.16 52.11,82.35 SR84.1
EDP_RCOMP_W5S20O25: length 2.5
  TOP w0.305: v1(111.35,120.69) 111.35,120.67 111.76,120.25 XU1.M9
  BOTTOM w0.508: HR10.2 112.35,120.65 v2(112.29,120.72) 112.22,120.79 111.45,120.79 v1(111.35,120.69)
EN_OK: length 10.9
  TOP w0.102: v2(30.99,27.23) Q9535.1 28.39,27.75 28.62,27.98 29.23,27.98 29.51,28.26 29.51,30.39 29.38,30.53 Q9534.1 28.28,30.53 27.86,30.95 27.86,31.41 28.17,31.71 C941489.1 28.56,32.18 28.83,32.45 R70298.2
FM_TBT_FORCE_PWR: length 5.7
  TOP w0.089: U1.BE20 40.16,94.93 39.94,95.15 39.94,95.46 40.06,95.58 40.2,95.58 40.36,95.74 40.36,95.96 40.24,96.08 39.44,96.08 39.24,95.87 38.46,95.87 38.06,96.27
  TOP w0.102: v1(37.57,96.88) 37.57,96.76 38.06,96.27
  BOTTOM w0.102: LT9.1 37.57,97.18 v1(37.57,96.88)
FM_TBT_SCI_EVENT: length 9
  TOP w0.102: U1.AW21 42.34,95.17 v1(42.34,95.77)
  BOTTOM w0.102: v1(42.34,95.77) 41.59,96.52 41.07,96.52 39.85,97.74 v2(38.76,97.74) 38.47,98.03 36.9,98.03 36.68,97.81 36.68,97.36 SR7847.2
FP_CBL_DET: length 42.3
  TOP w0.089: 38.84,95.37 39.08,95.37 39.6,94.86 39.75,94.86 39.96,94.64 arc(40.04,94.59) 40.13,94.57 40.53,94.57 U1.BD20
  TOP w0.102: SR7942.2 16.52,100.43 17.3,101.21 17.92,101.21 ECR146.1 18.46,101.75 21.86,101.75 22.29,102.19 25.39,102.19 27.68,104.49 v2(27.68,105.32) 27.96,105.6 27.96,106.29 28.38,106.71 28.38,107.6 28.45,107.66 28.45,109.27 28.8,109.62 v1(29.86,109.62) ; 38.84,95.37 38.29,95.37 37.99,95.68 37.98,95.68 37.22,96.44 36.52,96.44 35.91,97.04 35.16,97.04 v1(34.83,96.71)
  IN1 w0.102: v1(29.86,109.62) 30.1,109.38 30.1,108.27 30.94,107.43 30.94,105.3 32.85,103.38 32.85,102.87 34.63,101.1 34.63,98.88 35.37,98.14 35.37,97.45 34.83,96.92 v1(34.83,96.71)
FP_CBL_DET_SIO: length 15.4
  TOP w0.102: OR59.1 14.21,98.96 14.37,99.13 14.65,99.13 15.37,99.84 v1(15.37,99.99) 15.37,100.4 15.87,100.9 16.13,100.9 16.69,101.46 v2(16.72,101.46) 17.33,101.46 ECR146.2
  BOTTOM w0.102: U104.50 15.51,95 16.62,96.12 17.6,96.12 17.97,96.48 17.97,98 17.1,98.87 16.48,98.87 v1(15.37,99.99)
FRAME#_DEBUG: length 64.7
  TOP w0.127: ECR106.2 27.54,89.51 27.94,89.12 27.94,89.12 v1(27.94,89.12) ; v1(6.32,122.1) P12.10
  IN1 w0.127: v1(6.32,122.1) 5.54,122.88 5.54,126.9 6.42,127.78 7.7,127.78 8.06,127.42 14.71,127.42 15.19,127.9 17.2,127.9 19.3,125.8 19.3,124.53 20.24,123.59 20.77,123.59 23.35,121.01 23.35,117.6 23.93,117.03 23.93,112.13 24.61,111.44 24.61,107.99 24.38,107.76 24.38,104.3 24.24,104.16 24.24,101.36 24.36,101.24 24.36,97.75 24.67,97.43 24.67,96.54 24.86,96.35 24.87,95.83 24.87,93.63 26.7,91.79 26.7,89.94 27.53,89.12 v1(27.94,89.12)
  BOTTOM w0.127: v1(6.32,122.1) v2(6.88,121.54)
GP001: length 23.8
  TOP w0.102: v1(12.8,102.86) 12.42,102.86 12.19,102.64 12.19,102.2 11.78,101.78 10.95,101.78 10.51,102.22 9.04,102.22 8.95,102.14 OR144.2 8.38,101.74 8.14,101.98 v2(8.14,102.33) 8.14,102.78 8.16,102.81 OR128.2
  BOTTOM w0.102: v1(12.8,102.86) 13.08,103.14 13.08,104.26 13.49,104.66 14.78,104.66 15.01,104.43 16.66,104.43 17.22,103.87 17.64,103.87 19.33,102.19 20.58,102.19 22.38,103.99 22.38,105.94 22.62,106.19 22.97,106.19 23.2,105.96 U104.3
GP002: length 21.5
  TOP w0.102: OR129.2 6.53,101.59 8.04,101.59 8.33,101.3 11.58,101.3 12.51,102.22 v1(12.8,102.22) 13,102.22 13.41,101.82 13.41,101.67 v2(13.61,101.46)
  BOTTOM w0.102: v1(12.8,102.22) 12.84,102.19 16.8,102.19 17,101.98 20.66,101.98 22.78,104.1 22.78,104.82 23.13,105.16 U104.5
GP003: length 19.8
  TOP w0.102: OR130.2 6.97,101.02 v2(6.98,101.03) 11.71,101.03 12.27,101.59 v1(12.77,101.59)
  BOTTOM w0.102: v1(12.77,101.59) 12.98,101.59 13.37,101.98 16.64,101.98 16.89,101.73 18.95,101.73 18.98,101.75 20.72,101.75 22.99,104.02 22.99,104.49 23.26,104.76 U104.6
GP111: length 8.2
  BOTTOM w0.102: v2(5.26,88.66) 5.82,88.66 7.03,89.88 7.77,89.88 8.44,90.55 OR124.2 8.93,91.58 10.67,91.58 11.11,92.02 U104.61
GP112: length 6.2
  BOTTOM w0.102: U104.62 10.71,92.02 10.47,91.78 7.51,91.78 OR125.2 6.83,90.92 v2(6.09,90.19)
GP113: length 6.4
  TOP w0.102: v1(7.47,93.84) 7.51,93.89 OR126.2
  BOTTOM w0.102: v2(6.6,93.44) 7,93.84 v1(7.47,93.84) 7.62,94 10.08,94 10.31,93.77 U104.63
GP114: length 5.6
  TOP w0.102: OR127.2 v2(6.58,93.46) 7.09,93.46 v1(7.45,93.09)
  BOTTOM w0.102: v1(7.45,93.09) 8.16,93.8 9.68,93.8 9.91,93.56 U104.64
GPIO_PEG SLOT_RESET: length 12.8
  TOP w0.102: v1(44.46,80.05) 44.46,80.36 U1.AT49
  IN2 w0.102: v1(50.39,75.96) 49.71,75.96 49,76.67 48.49,76.67 48.38,76.78 48.38,77.71 46.93,79.16 46.93,80.19 46.57,80.55 46.03,80.55 45.4,79.92 44.58,79.92 v1(44.46,80.05)
  BOTTOM w0.102: SR7834.1 51.48,74.06 51.33,74.21 51.33,74.49 50.65,75.17 50.65,75.71 v1(50.39,75.96)
GPIO_WIRELESS_DISABLE1#: length 99.9
  TOP w0.089: U1.BF33 39.16,88.38 38.96,88.18 37.64,88.18 37.47,88.35
  TOP w0.102: 37.47,88.35 37.47,88.36 37.23,88.6 36.87,88.6 36.14,87.86 33.26,87.86 33.02,87.62 33.02,87.42 32.73,87.12 31.15,87.12 31.07,87.05 29.97,87.05 29.89,86.96 29.28,86.96 29.25,87 SR7940.2 27.49,87 27.28,87.21 25.66,87.21 25.01,86.55 25.01,85.96 23.04,83.99 23.04,77.98 21.35,76.29 21.35,75.88 21.59,75.63 21.98,75.63 22.22,75.87 22.59,75.87 22.83,75.63 22.83,75.15 22.59,74.91 22.59,73.51 22.79,73.31 v1(22.79,71.85) ; v1(58.93,54.4) 58.9,54.4 58.69,54.18 APD2.2 ; v1(37.45,49.36) 37.45,48.46 v2(37.69,48.23)
  IN2 w0.102: v1(58.93,54.4) 58.93,52.92 57.31,51.31 57.31,49.92 55.68,48.29 54.34,48.29 53.21,47.16 53.21,46.74 53.01,46.54 53.01,46.14 52.76,45.89 52.63,45.89 51.32,44.58 48.42,44.58 48.17,44.83 48.07,44.83 46.61,46.29 46.61,46.6 43.25,49.95 v1(43.25,50.41) ; v1(22.79,71.85) 22.79,70.26 22.91,70.14 22.91,64.66 22.55,64.3 22.55,63.92 24.57,61.9 24.57,60.11 28.93,55.75 28.93,53.35 31.11,51.17 32.41,51.17 33.14,50.44 35.18,50.44 36.25,49.36 v1(37.45,49.36)
  BOTTOM w0.102: v1(58.93,54.4) 58.93,54.04 59.03,53.94 R3108.2 ; v1(43.25,50.41) 43.25,50.46 42.95,50.77 41.76,50.77 41.6,50.61 40.06,50.61 39.51,50.06 38.21,50.06 37.51,49.36 v1(37.45,49.36)
GPIO_WIRELESS_DISABLE2#: length 72.4
  TOP w0.102: v1(41.04,91.48) 40.89,91.48 U1.BE29 ; v1(55.09,55.34) 55.65,55.34 56.03,55.72 58.07,55.72 R3109.2 59.2,55.54 59.82,55.54 ; 59.82,55.54 60.23,55.12 60.23,46.74 59.92,46.42 APD1.2 ; 59.82,55.54 59.92,55.64 v2(59.92,56.86)
  IN2 w0.102: v1(55.09,55.34) 54.93,55.34 53.73,56.53 53.73,59.49 52.82,60.4 52.82,64.02 49.24,67.6 48.63,67.6 45.49,70.75 45.49,71.09 44.11,72.47 44.11,73.21 41.4,75.92 41.4,77.27 40.46,78.21 40.46,78.67 40.05,79.07 40.05,80.43 39.45,81.03 39.45,86.27 41.6,88.43 42.02,88.43 42.94,89.35 42.94,89.7 42.9,89.74 42.9,90.09 43.38,90.56 43.42,90.56 43.66,90.8 43.66,91.15 42.91,91.9 41.47,91.9 v1(41.04,91.48)
  BOTTOM w0.102: SR7939.2 37.95,94.72 38.09,94.58 38.09,93.85 38.64,93.3 39.6,93.3 39.8,93.11 40.22,93.11 40.41,92.92 40.41,92.29 40.82,91.89 40.82,91.7 v1(41.04,91.48)
GPIO_WIRELESS_DISABLE#_R: length 21.9
  TOP w0.102: APD2.1 58.69,50.55 58.37,50.23 57.89,50.23 APR136.2 57.25,50.31 57.12,50.18 v1(56.46,50.18) 56.28,50 56.28,49.38 55.35,48.44 55.35,48.13 55.25,48.03 53.81,48.03 53.44,48.4 51.43,48.4 50.86,47.83 v2(49.27,47.83) 49.27,48.47 48.37,49.37 48.37,50.94 48.45,51.02 J218.56
  BOTTOM w0.102: v1(56.46,50.18) 57.35,51.07 57.35,52.4 57.76,52.81 58.35,52.81 58.51,52.66 R3108.1
GPP_A8: length 15.1
  TOP w0.102: v1(43.32,89.91) 43.6,89.64 U1.AV32
  BOTTOM w0.102: SR7841.2 36.64,98.24 39.64,98.24 41.15,96.73 41.68,96.73 42.06,96.34 42.37,96.34 42.76,95.95 42.76,95.51 42.71,95.46 42.71,93.54 42.98,93.27 42.98,91.93 SR7938.1 43.69,91.21 43.69,90.87 43.79,90.77 v2(43.79,90.45) 43.79,90.38 v1(43.32,89.91)
GPP_A_21: length 6.9
  TOP w0.102: U1.BA33 42.14,89.11 v1(41.9,89.35)
  BOTTOM w0.102: SR7882.2 37.79,90.64 38.22,91.06 38.69,91.06 38.99,90.77 39.5,90.77 SR7883.2 40.56,89.7 41.55,89.7 v1(41.9,89.35)
GPP_A_22: length 12.9
  TOP w0.102: U1.AW32 42.86,88.39 v1(43.13,88.12)
  IN1 w0.102: v1(43.13,88.12) 43.13,87.14 41.76,85.77 41.09,85.77 39.15,83.83 39.15,83.05 38.34,82.24 v1(37.29,82.24)
  BOTTOM w0.102: v1(37.29,82.24) 37.51,82.46 37.88,82.46 37.97,82.55 SR7947.2 SR7944.2
GPP_A_23: length 2.5
  TOP w0.102: U1.AV34 43.91,87.79 v1(44.08,87.63)
  BOTTOM w0.102: v1(44.08,87.63) 43.91,87.45 SR7946.2 42.9,87.45 SR7945.2
GPP_B4: length 9.3
  TOP w0.089: 37.45,89.2 37.46,89.2 39.07,89.2 39.46,88.82 39.67,88.82 39.69,88.79 40.4,88.79 40.5,88.69 40.6,88.69 40.64,88.65 U1.BC33
  TOP w0.102: 37.45,89.2 36.9,89.2 35.97,88.27 32.84,88.27 SR674.2
GPP_B_15: length 4.2
  TOP w0.102: U1.BB26 41.71,92.17 v1(41.71,92.42)
  BOTTOM w0.102: SR7843.2 40.64,94.39 v2(40.64,93.84) 40.64,93.74 41.71,92.67 v1(41.71,92.42)
GPP_B_16: length 8.9
  TOP w0.102: SR7842.2 32.41,89.67 v2(32.47,89.61) 32.77,89.31 35.54,89.31 35.99,89.76 35.99,89.77 36.9,90.68 37.8,90.68 38.25,90.23 38.83,90.23 39.18,90.58 U1.BF29
GPP_D_7_USB_WAKEOUT_N: length 33.3
  TOP w0.102: v1(36.85,64.33) 36.85,64.66 36.5,65.01 SR7922.2 35.32,64.12 33.37,64.12 32.97,64.53 32.97,66.53 SR7923.1 ; U1.BE41 40.58,84.67 v1(40.6,84.65)
  IN2 w0.102: v1(40.6,84.65) 39.85,83.91 39.85,81.34 41.63,79.57 41.63,79.06 v1(41.15,78.58)
  BOTTOM w0.102: v2(35.74,63.57) 36.09,63.57 v1(36.85,64.33) 37.78,65.25 37.78,66 38.7,66.92 38.7,70.81 38.42,71.09 38.42,74.23 40.75,76.56 40.75,77.37 41.15,77.77 v1(41.15,78.58)
GPP_F6: length 26
  TOP w0.102: v1(45.07,80.91) 45.07,81.38 U1.AR47
  IN2 w0.102: v1(45.07,80.91) 45.31,81.16 46.83,81.16 47.75,80.24 47.75,79.27 48.61,78.4 50.09,78.4 51.09,77.4 52.22,77.4 52.59,77.03 52.59,76.66 53.06,76.19 54.45,76.19 55.54,75.1 57.66,75.1 60.55,72.21 61.86,72.21 v1(62.58,71.49)
  BOTTOM w0.102: v1(45.07,80.91) 45.17,80.82 v2(45.17,80.08) ; SR7803.2 63.41,71.44 62.63,71.44 v1(62.58,71.49)
GPP_F7: length 13.7
  TOP w0.102: U1.AN46 45.37,82.79 v1(45.37,82.95)
  IN2 w0.102: v1(45.37,82.95) 46.67,81.65 46.95,81.65 48.18,80.42 48.18,79.56 48.9,78.84 50.4,78.84 50.87,78.37 51.85,78.37 52.86,77.37 52.86,77.1 v1(53.29,76.66)
  BOTTOM w0.102: v1(53.29,76.66) 53.59,76.36 53.9,76.36 ST34.1
GPP_F13: length 114.8
  TOP w0.089: 43.84,79.39 43.84,80.3 43.74,80.4 43.74,80.45 43.72,80.47 43.72,81.37 U1.AU47
  TOP w0.102: v2(51.1,144.69) 51.1,145.51 50.95,145.66 SR41.2 49.21,145.2 47.88,145.2 45.97,143.3 45.27,143.3 44.32,144.25 37.58,144.25 v1(37.31,144.52) ; v1(44.75,77.94) 44.75,78.21 43.84,79.13 43.84,79.39
  IN1 w0.102: v1(44.75,77.94) 44.11,77.94 43.36,77.19 40.22,77.19 40.05,77.02 37.92,77.02 37.71,77.23 37.21,77.23 36.79,76.8 v1(36.79,76.59) ; v1(35.5,84.49) 35.5,85.33 34.91,85.91 34.91,86.43 35.3,86.82 36.4,86.82 36.63,87.04 36.63,87.47 36.43,87.66 36.43,88.58 36.68,88.82 36.68,90.53 34.82,92.38 34.82,92.7 34.54,92.98 34.25,92.98 33.77,93.46 33.77,95.49 33.16,96.1 33.16,98.02 32.45,98.73 32.45,99.73 32,100.18 32,100.75 31.23,101.53 29.96,101.53 29.21,102.28 29.21,103.47 28.43,104.24 28.43,104.94 28.83,105.33 28.83,105.92 28.83,107.41 28.55,107.69 28.55,108.43 26.48,110.5 26.48,112.42 26.53,112.47 26.53,115.28 27,115.75 27,117.36 26.17,118.18 26.17,118.74 24.96,119.95 24.96,123.32 24.19,124.09 24.19,129.11 24.92,129.83 26.18,129.83 28.56,132.22 28.56,132.62 31.91,135.97 31.91,140 36.51,144.6 37.23,144.6 v1(37.31,144.52)
  IN2 w0.102: v1(36.79,76.59) 36.79,78.19 37.44,78.84 37.44,80.66 37.71,80.93 37.71,82.42 37.14,82.98 36.16,82.98 35.79,83.35 35.49,83.35 35.24,83.6 35.24,84.23 v1(35.5,84.49)
GPP_F14: length 24.1
  TOP w0.102: U1.AP41 45.04,84.54 44.78,84.79 v1(44.77,84.79)
  IN2 w0.127: v1(51.79,77.84) 51.02,77.84 50.24,78.62 48.74,78.62 47.96,79.39 47.96,80.33 46.86,81.43 46.27,81.43 44.77,82.93 v1(44.77,84.79)
  BOTTOM w0.102: SR46.2 60.84,73.28 v2(60.81,73.32) 60.35,73.78 59.97,73.78 59.54,74.21 58.27,74.21 57.82,74.67 55.62,74.67 55.1,75.19 54.3,75.19 53.3,76.2 53.17,76.2 51.79,77.57 v1(51.79,77.84)
GPP_F21: length 15.8
  TOP w0.089: 44.1,79.48 44.03,79.55 44.03,80.23 44.03,80.38 43.93,80.48 43.93,80.53 43.91,80.55 43.91,81.04 U1.AU48
  TOP w0.102: 44.1,79.48 44.1,79.18 44.47,78.81 v1(44.75,78.81)
  IN2 w0.102: v1(44.75,78.81) 46.41,78.81 47.77,77.44 47.77,76.4 48.36,75.81 48.36,75.36 48.03,75.03 48.03,74.61 48.14,74.5 48.88,74.5 v1(49.31,74.07)
  BOTTOM w0.102: v1(49.31,74.07) 48.87,73.62 48.87,73.25 49.28,72.84 49.68,72.84 v2(49.81,72.71) 50.09,72.43 50.09,72.12 50.54,71.66 50.54,71.23 SR7848.2
GPP_G0: length 12.7
  TOP w0.102: v1(41.78,97.14) 41.98,97.35 42.25,97.35 42.79,97.89 U1.AW13
  BOTTOM w0.102: v2(32.29,99.14) 32.73,98.71 R2343.1 34.82,99.21 35.76,99.21 R2341.2 36.54,98.44 39.72,98.44 41.07,97.09 41.73,97.09 v1(41.78,97.14)
GPP_G2: length 112.6
  TOP w0.102: v1(42.26,137.43) 41.98,137.71 41.98,140.4 40.63,141.76 40.63,142.17 39.96,142.84 39.06,142.84 36.57,140.35 35.79,140.35 35.56,140.12 35.3,140.12 v1(34.96,139.78) ; R2347.1 34.51,107.79 v1(34.63,107.91) 35.06,107.48 35.56,107.48 35.56,107.48 35.73,107.48 36.42,106.79 36.42,105.62 36.27,105.47 36.27,104.47 36.61,104.12 36.61,102.15 37.85,100.92 38.53,100.92 38.67,101.06 39.32,101.06 U1.BF8
  IN1 w0.102: v1(34.96,139.78) 34.72,139.78 33.17,138.23 33.17,134.19 34.34,133.02 34.34,128.03 34.54,127.83 34.54,127.19 34.12,126.77 30.91,126.77 29.07,124.93 29.07,119.43 31.2,117.3 31.2,116.66 32.57,115.29 32.57,113.51 32.37,113.3 32.37,111.93 32.58,111.72 32.58,110.91 34.63,108.85 v1(34.63,107.91) ; v1(67.89,142.3) 71.3,142.3 71.72,142.71 74.82,142.71 75.11,142.42 76.92,142.42 77.66,141.68 79.97,141.68 80.49,141.16 v1(81.53,141.16)
  IN2 w0.102: v1(67.89,142.3) 67.89,141.63 65.13,138.86 59.28,138.86 58.29,139.85 57.95,139.85 57.91,139.89 54.86,139.89 54.03,140.73 51.52,140.73 51.46,140.67 47.99,140.67 46.67,139.35 44.18,139.35 v1(42.26,137.43)
  BOTTOM w0.102: v1(81.53,141.16) 82.29,141.93 82.73,141.93 83.48,142.68 MQ27.1 ; v2(33.55,108.94) 33.82,108.68 R2345.2 34.3,107.91 v1(34.63,107.91)
GPP_G4: length 16.1
  TOP w0.102: v1(30.49,107.22) 30.98,107.22 31.28,107.52 R2351.1 31.82,107.48 32.67,107.48 32.78,107.37 34.33,107.37 34.42,107.28 35.65,107.28 36.22,106.71 36.22,105.71 36.06,105.55 36.06,104.37 36.41,104.02 36.41,102.07 37.76,100.71 38.62,100.71 38.65,100.74 U1.BG8
  BOTTOM w0.102: v2(31.24,107.66) 30.8,107.22 v1(30.49,107.22) 30.25,107.46 R2349.2
GPP_G5: length 14.9
  TOP w0.089: 39.17,100.55 39.29,100.67 39.67,100.67 39.94,100.94 U1.BE8
  TOP w0.102: R2352.1 34.49,106.87 34.69,107.08 35.26,107.08 v1(35.69,106.64) 35.99,106.35 35.99,105.78 35.86,105.65 35.86,104.29 36.21,103.94 36.21,101.98 37.71,100.48 39.09,100.48 39.11,100.49 39.17,100.55
  BOTTOM w0.102: v1(35.69,106.64) 35.23,107.1 34.06,107.1 R2350.2 33.09,106.14 v2(33.09,106.01)
GPP_H_3: length 19.5
  TOP w0.102: U1.AF48 49.43,80.91 49.43,80.91 v1(49.43,80.9)
  IN2 w0.102: v1(49.43,80.9) 49.74,80.9 50.57,80.07 50.57,79.54 51.08,79.03 52.09,79.03 53.2,77.93 53.57,77.93 55.79,75.71 58,75.71 59.7,74.01 59.87,74.01 59.87,74.01 62.25,74.01 v1(63.22,73.04)
  BOTTOM w0.102: v1(63.22,73.04) 63.19,73.07 v2(63.19,73.84) 63.28,73.93 SR7852.1
GPP_H_4: length 5
  TOP w0.102: v1(50.07,84.22) 50.47,84.22 U1.AC41
  BOTTOM w0.102: SR7851.1 50.41,84.56 50.07,84.22 v1(50.07,84.22) 50.07,83.87 49.6,83.4 49.6,82.23 48.92,81.54 v2(48.77,81.54)
GPP_H_5: length 12.9
  TOP w0.102: v1(51.32,84.89) U1.AC39
  IN2 w0.102: v1(59.16,80.46) 58.32,81.3 56.23,81.3 55.26,82.26 54.46,82.26 54.19,82.53 54.19,83.44 53,84.62 51.59,84.62 v1(51.32,84.89)
  BOTTOM w0.102: v1(59.16,80.46) 59.16,81.07 v2(59.31,81.22) 59.79,80.74 SR7850.1
GPP_H_6: length 36.9
  TOP w0.102: v1(50.08,84.97) 50.08,84.98 U1.AE39
  IN1 w0.102: v1(50.08,84.97) 50.08,84.85 49.45,84.21 48.4,84.21 47.98,83.8 47.98,80.76 45.78,78.56 45.78,76.01 v1(46.24,75.55)
  BOTTOM w0.102: v1(46.24,75.55) 46.33,75.47 46.33,75.16 46.33,75.16 46.33,74.16 47.54,72.95 47.54,72.83 48.68,71.69 48.68,70.82 50.25,69.25 50.25,68.33 50.94,67.64 53.84,67.64 54.37,67.11 56.53,67.11 56.76,67.35 57.29,67.87 62.14,67.87 62.43,67.58 63.16,67.58 v2(63.42,67.85) SR420.1
GPP_H_12: length 9.8
  TOP w0.102: U1.AB47 51.15,81.45 51.15,81.27 50.77,80.89 50.77,79.22 51.51,78.48 v1(53.26,78.48)
  BOTTOM w0.102: v1(53.26,78.48) 53.88,78.48 SR277.2 ; SR298.1 55.38,78.73 54.49,78.73 SR277.2 ; SR277.2 54.33,78.03 v2(54.33,77.41)
GPP_J_0_CNV_GNSS_PA_BLANKING: length 94.2
  TOP w0.102: v1(44.68,50.33) 44.68,50.08 45.54,49.21 45.54,48.87 45.92,48.49 45.92,47.41 45.99,47.35 R3129.1 46.39,45.21 46.3,45.13 v2(46.3,44.49) ; v1(43,101.21) 43,101.56 U1.AV6
  IN2 w0.102: v1(43,101.21) 43,102.96 42.24,103.72 42.24,104.93 41.38,105.78 40.11,105.78 39.86,105.54 38.01,105.54 37.3,106.25 36.19,106.25 35.73,105.79 34.33,105.79 32.34,103.81 31.48,103.81 31.04,103.37 30.2,103.37 27.55,100.72 27.55,100.04 26.87,99.36 26.62,99.11 26.62,95.71 26.4,95.49 26.4,94.66 26.64,94.42 26.64,93.87 25.92,93.14 25.92,92.21 25.44,91.73 25.44,90.21 25.11,89.88 25.11,88.75 25.14,88.72 25.14,85.12 24.84,84.82 24.84,83.58 25.47,82.95 25.47,81.58 24.63,80.74 24.63,79.09 25.74,77.98 25.74,75.6 26.59,74.75 26.59,73.66 25.83,72.89 25.83,71.26 25.83,69.35 25.56,69.09 25.56,65.49 26.08,64.97 26.87,64.97 28.6,63.25 28.6,61.97 31.54,59.03 32.11,59.03 33.89,57.25 34.41,57.25 35.33,56.34 35.33,55.56 37.77,53.12 39.74,53.12 41.4,51.46 43.55,51.46 v1(44.68,50.33)
GPP_J_0_CNV_GNSS_PA_BLANKING_R: length 10.3
  TOP w0.102: J218.44 45.45,51.29 45.87,50.87 45.87,48.83 46.18,48.53 46.18,48.4 R3129.2 46.75,48.19 46.81,48.12 46.81,47.02 46.67,46.88 46.67,45.76 46.8,45.63 46.8,43.82 v2(47.45,43.17)
GPP_J_8_CNV_MFUART2_RXD: length 95.3
  TOP w0.102: R3131.1 47.8,46.76 47.8,46.11 v1(47.67,45.98) 48,45.66 48.08,45.66 v2(48.74,45) ; v1(38.4,107.1) 38.84,107.53 39.99,107.53 40.45,107.07 40.45,106.84 40.7,106.59 41.76,106.59 42.95,105.4 42.95,105.06 42.94,105.05 42.94,103.77 U1.AW2
  IN2 w0.102: v1(38.4,107.1) 37.96,106.66 36.27,106.66 35.87,107.06 34.91,107.06 34.64,106.79 34.64,106.76 32.09,104.21 31.17,104.21 30.74,103.78 30.03,103.78 27.14,100.89 27.14,100.21 26.47,99.53 26.21,99.28 26.21,95.87 26,95.66 26,94.49 26.2,94.29 26.2,94.08 25.51,93.4 25.51,92.38 25.03,91.9 25.03,90.38 24.7,90.05 24.7,88.55 24.73,88.51 24.73,85.29 24.43,84.99 24.43,83.41 25.06,82.78 25.06,81.74 24.23,80.91 24.23,77.89 24.56,77.55 24.56,75.7 25.43,74.83 25.43,74.44 25.64,74.23 25.64,73.53 25.42,73.3 25.42,72.85 25.42,72.85 25.42,71.43 25.42,71.43 25.42,69.52 25.16,69.26 25.16,65.32 25.91,64.57 26.71,64.57 28.04,63.23 28.04,61.96 31.37,58.63 31.94,58.63 32.79,57.78 32.79,57.09 34.19,55.69 34.43,55.69 37.41,52.71 39.57,52.71 41.23,51.05 43.25,51.05 43.92,50.39 43.92,49.58 46.87,46.62 46.87,46.31 47.21,45.98 v1(47.67,45.98)
GPP_J_8_CNV_MFUART2_RXD_R: length 4.7
  TOP w0.102: J218.48 46.45,49.24 v2(46.57,49.12) 47.46,48.23 R3131.2
GPP_J_9_CNV_MFUART2_TXD: length 101.2
  TOP w0.102: v1(47.29,46.49) 47.2,46.4 47.2,44.73 47.34,44.59 48.09,44.59 48.17,44.52 R3130.1 48.54,43.74 48.54,43.39 48.94,42.99 v2(48.94,42.15) ; v1(43.92,101.41) 43.86,101.36 U1.AU9
  IN2 w0.102: v1(47.29,46.49) 44.13,49.65 44.13,50.47 43.34,51.26 41.31,51.26 39.65,52.92 37.5,52.92 34.52,55.9 34.36,55.9 32.99,57.26 32.99,57.86 32.02,58.83 31.46,58.83 28.29,61.99 28.29,63.26 26.79,64.77 25.99,64.77 25.36,65.4 25.36,69.17 25.62,69.43 25.62,71.35 25.62,73.22 25.84,73.44 25.84,74.32 25.63,74.52 25.63,74.92 24.76,75.79 24.76,77.64 24.43,77.97 24.43,80.82 25.27,81.66 25.27,82.87 24.64,83.5 24.64,84.9 24.94,85.21 24.94,88.61 24.9,88.65 24.9,89.96 25.24,90.3 25.24,91.81 25.72,92.29 25.72,93.27 26.44,94 26.44,94.33 26.2,94.58 26.2,95.57 26.41,95.79 26.41,99.19 26.67,99.45 27.34,100.12 27.34,100.8 30.12,103.58 30.82,103.58 31.26,104.01 32.25,104.01 34.24,106 35.65,106 36.1,106.45 37.38,106.45 38.09,105.74 39.78,105.74 40.02,105.99 41.47,105.99 42.44,105.01 42.44,103.81 43.27,102.98 43.27,101.87 43.73,101.41 v1(43.92,101.41)
  BOTTOM w0.102: v1(43.92,101.41) SR7924.1 43.92,100.37 44.47,99.81 44.47,99.46 SR7925.1
GPP_J_9_CNV_MFUART2_TXD_R: length 13.1
  TOP w0.102: v2(47.6,41.01) 47.6,41.75 48.32,42.47 48.32,43.17 47.81,43.68 47.39,43.68 47.33,43.74 R3130.2 47,44.44 47,45.71 46.87,45.84 46.87,46.8 47.01,46.94 47.01,48.28 46.67,48.63 46.36,48.63 46.07,48.92 46.07,51.02 45.95,51.14 J218.46
GPP_K5: length 63.7
  TOP w0.089: v1(55.85,82.27) 55.85,82.27 55.86,82.25 U1.N47
  TOP w0.102: v1(72.21,53.5) 72.09,53.62 v2(70.43,53.62) 68.93,53.62 68.53,53.22 65.52,53.22 65.16,52.86 MQ26.1 ; v1(65.67,64.6) 67.79,62.47 67.79,61.29 v1(67.61,61.11)
  IN2 w0.102: v1(65.67,64.6) 65.48,64.79 65.48,65.9 65.12,66.26 65.12,68.85 65.43,69.15 65.43,76.39 64.54,77.28 62.94,77.28 61.72,78.5 61.72,78.76 59.97,80.51 59.97,80.58 59,81.55 56.57,81.55 v1(55.85,82.27)
  BOTTOM w0.102: SR7953.2 SR7966.2 73.25,54.54 v1(72.21,53.5) 74.63,53.5 76.58,55.45 76.58,56.05 76.33,56.3 76.33,56.92 74.85,58.4 70.34,58.4 67.63,61.11 v1(67.61,61.11) ; SR7954.1 57.5,86.08 57.5,85.79 56.97,85.26 56.97,84.88 56.16,84.06 56.16,82.58 v1(55.85,82.27)
GSPI1_MISO: length 14.1
  TOP w0.089: U1.BD30 40.33,89.82 39.98,89.82 39.98,89.83 39.98,89.84 39.81,90 39.81,90
  TOP w0.127: SR7796.2 29.31,89.35 29.26,89.3 29.26,88.83 29.58,88.51 30.28,88.51 30.44,88.66 30.83,88.66 v2(31.11,88.94) 31.39,88.66 32.35,88.66 32.58,88.89 35.71,88.89 36.41,89.59 36.41,89.6 37.07,90.26 37.62,90.26 38.08,89.81 39.14,89.81 39.36,90.02 39.79,90.02 39.81,90
GT1_CSP1_A: length 6.7
  BOTTOM w0.229: PU89001.25 95.38,160.8 95.86,160.33 PC89026.1 PR89045.1 97.72,159.6 98.31,159.6 PR89047.2 99.27,159.6 100.33,159.6 v2(100.46,159.73)
GT2_CSN2_A: length 6.2
  BOTTOM w0.229: v2(97.94,160.34) 98.13,160.34 PR89051.1 98.79,161.41 PC89029.1 98.04,161.67 97.81,161.67 PC89030.2 PR89052.2 95.72,161.11 95.63,161.2 PU89001.24
GT2_CSP2_A: length 4.8
  BOTTOM w0.229: PU89001.23 95.99,161.6 PR89052.1 PC89030.1 97.75,162.45 PR89055.2 97.21,162.85 v2(96.93,163.13)
GT_COMPA: length 6.1
  BOTTOM w0.229: PC89024.1 99.54,163.78 v2(98.88,163.78) 98.34,164.33 97.17,164.33 PC89025.1 96.53,163.96 96.24,164.26 95.87,164.26 95.22,163.6 PU89001.18
GT_COMPA_R: length 2.7
  BOTTOM w0.229: v2(102.03,162.78) 101.91,162.65 101.51,162.65 PC89024.2 PR89043.2
GT_CSCOMP: length 66.1
  TOP w0.254: PRT89002.1 v1(132.94,145.04) ; v2(92.63,163.59) 92.63,163.35 PC89034.2 PC89032.2 94.13,163.08 94.3,163.25 PR89059.1 94.66,164.01 PR89062.2 95.8,164.01 96.06,163.75 v1(96.06,163.69)
  IN1 w0.203: v1(132.94,145.04) 132.45,144.54 130.28,144.54 129.56,143.83 122.07,143.83 120.93,144.97 120.93,145.43 120.07,146.29 116.41,146.29 115.06,147.64 111.63,147.64 109.98,145.99 107.14,145.99 106.7,146.42 101.75,146.42 100.48,147.69 100.48,148.45 99.74,149.19 99.74,153.08 100.71,154.04 102.39,154.04 103.53,155.18 103.53,156.83 100.35,160.01 99.74,160.01 v1(96.06,163.69)
  BOTTOM w0.229: v1(96.06,163.69) 95.78,163.69 95.34,163.26 95.05,163.26 94.99,163.2 PU89001.19
GT_CSCOMP_R: length 68.4
  TOP w0.254: v2(91.08,162.54) 92.07,162.54 PR89060.1 92.3,163.11 92.06,163.35 92.06,163.83 92.48,164.25 92.85,164.25 PR89059.2 94.3,164.48 96.34,164.48 96.49,164.63 97.56,164.63 97.83,164.36 v1(97.83,163.85) ; PRT89002.2 v1(132.94,145.87)
  IN1 w0.203: v1(132.94,145.87) 132.94,145.71 132.15,144.92 130.05,144.92 129.31,144.19 122.38,144.19 121.36,145.2 121.36,145.58 120.34,146.6 116.53,146.6 115.06,148.07 111.2,148.07 109.55,146.42 107.31,146.42 106.96,146.78 101.93,146.78 100.84,147.87 100.84,148.58 100.05,149.37 100.05,152.87 100.81,153.63 102.54,153.63 103.86,154.96 103.86,156.96 100.45,160.38 100.04,160.38 97.83,162.59 v1(97.83,163.85)
GT_CSN1_A: length 75.1
  TOP w0.203: PJP93002.2 145.7,147.21 v1(145.57,147.08)
  TOP w0.229: v2(94.49,160.23) PR89067.2 95.87,160.62 100.55,160.62 101.5,161.57 101.5,162.04 101.02,162.52 v1(100.96,162.52)
  IN1 w0.203: v1(145.57,147.08) 145.98,147.5 145.98,148.01 144.94,149.06 136.47,149.06 133.96,151.58 132.66,151.58 132.23,152.01 132.23,152.62 130.76,154.09 123.73,154.09 122.94,153.3 113.61,153.3 113,153.91 111.45,153.91 110.59,154.78 107.92,154.78 105.92,156.78 105.92,157.9 103.08,160.74 103.08,161.56 102.13,162.52 v1(100.96,162.52)
  BOTTOM w0.229: PR89045.2 97.32,159.17 101.06,159.17 101.55,159.66 101.55,161.61 100.96,162.2 v1(100.96,162.52) ; PU89001.26 95.17,160.4 PC89026.2
  BOTTOM w0.254: PR89045.2 PC89026.2
GT_CSN2_A: length 114.4
  TOP w0.229: v2(100.95,161.8) 100.66,161.52 v1(100.29,161.52) 99.87,161.1 PR89069.2
  TOP w0.254: PJP93004.2 v1(165.28,113.55)
  IN1 w0.203: v1(100.29,161.52) 100.54,161.52 104.67,157.39 104.67,154.47 102.23,152.03 101.4,152.03 100.89,151.53 100.89,150.43 101.29,150.03 101.78,150.03 102.18,149.62 102.18,147.94 102.46,147.67 104.85,147.67 105.84,148.66 110.29,148.66 110.63,149 119.09,149 122.17,145.92 122.17,145.66 122.81,145.02 128,145.02 130.32,147.35 132.71,147.35 133.88,146.17 133.88,145.19 134.97,144.1 140.19,144.1 140.61,143.68 145.22,143.68 145.64,144.1 149.62,144.1 150.09,143.62 152.04,143.62 153.21,142.45 153.21,140.36 157.94,135.64 157.94,124.91 159.51,123.33 160.88,123.33 163.52,120.69 163.52,114.74 164.71,113.55 v1(165.28,113.55)
  BOTTOM w0.229: v1(100.29,161.52) 99.77,161 PR89051.2
GT_CSP1_A: length 64.1
  TOP w0.203: PJP93001.2 144.91,147.21 v1(145.52,147.82)
  TOP w0.229: PR89057.2 99.01,162.6 99.18,162.43 99.5,162.43 v1(99.78,162.7)
  IN1 w0.203: v1(99.78,162.7) 100.46,162.02 102.05,162.02 102.63,161.44 102.63,160.62 105.51,157.74 105.51,156.61 107.75,154.37 110.41,154.37 111.3,153.48 111.3,151.07 111.99,150.38 113.08,150.38 115.59,152.9 123.11,152.9 123.87,153.66 130.59,153.66 131.82,152.43 131.82,151.83 132.48,151.17 133.79,151.17 136.3,148.66 144.68,148.66 v1(145.52,147.82)
  BOTTOM w0.229: v1(99.78,162.7) 99.8,162.7 100.99,161.5 v2(100.99,161.38) 100.99,161.06 100.02,160.09 PR89047.1
GT_CSP2_A: length 117
  TOP w0.254: PR89061.2 99.4,163.85 v2(99.55,163.69) 99.55,163.38 v1(99.24,163.06) ; PJP93003.2 v1(165.28,112.89)
  IN1 w0.203: v1(165.28,112.89) 164.79,112.89 163.04,114.65 163.04,120.59 160.71,122.93 159.34,122.93 157.5,124.76 157.5,135.5 152.81,140.2 152.81,142.28 151.87,143.22 149.76,143.22 149.29,143.69 145.81,143.69 145.39,143.27 140.44,143.27 140.02,143.69 134.8,143.69 133.48,145.02 133.48,146.01 132.54,146.94 130.49,146.94 128.17,144.62 122.58,144.62 121.77,145.43 121.77,145.75 118.93,148.59 110.8,148.59 110.45,148.25 106.02,148.25 105,147.23 102.23,147.23 101.78,147.69 101.78,149.27 101.42,149.62 101.13,149.62 100.48,150.27 100.48,151.78 101.14,152.44 102.06,152.44 104.27,154.65 104.27,157.22 100.65,160.83 100.21,160.83 99.24,161.81 v1(99.24,163.06)
  BOTTOM w0.229: PR89055.1 99.03,162.85 v1(99.24,163.06)
GT_CSREF_A: length 7.6
  TOP w0.229: PC89035.2 96.33,161.86 96.1,162.09 v1(95.71,162.09) ; PC89035.2 95.93,161.1 95.9,161.06 PR89067.1 95.02,161.52 v2(95.02,161.89) ; PC89035.2 97.04,161.81 98.36,161.81 98.59,161.58 PR89069.1
  BOTTOM w0.229: v1(95.71,162.09) 95.62,162 PU89001.22
GT_CSSUM: length 9.5
  TOP w0.254: PR89061.1 PR89057.1 96.52,162.6 v1(96.49,162.58) 96.48,162.59 94.79,162.59 PC89032.1 PC89034.1 PR89060.2 91.92,161.55 v2(91.92,160.92)
  BOTTOM w0.229: PU89001.21 95.33,162.4 95.51,162.58 v1(96.49,162.58)
GT_DIFFOUTA: length 5.2
  TOP w0.229: v2(97.76,167.5) 97.72,167.46 PR89042.1 97.13,166.02 PR89044.1 96.34,166.02 96.11,165.79 v1(96.11,165.19)
  BOTTOM w0.229: PU89001.16 95.07,164.4 95.86,165.19 v1(96.11,165.19)
GT_DIFFOUTA_R: length 2.6
  TOP w0.229: PR89042.2 v2(99.41,166.61) 99.41,166.19 PC89023.2
GT_FBA: length 10.2
  TOP w0.229: v1(99.12,165.09) 99.12,165.08 98.78,164.73 98.08,164.73
  TOP w0.254: 98.08,164.73 PC89023.1 97.27,165.22 97.23,165.18 PR89044.2 ; v2(100.43,165.19) 99.23,165.19 v1(99.12,165.09)
  BOTTOM w0.229: PR89043.1 99.41,164.93 99.28,164.93 v1(99.12,165.09) 98.85,165.36 98.19,165.36 PR89046.1 97.26,164.81 97.24,164.8 PC89025.2 96.73,164.8 96.52,164.59 95.74,164.59 95.15,164 PU89001.17
GT_ILIM_A: length 17.4
  TOP w0.254: v1(95.85,163.08) 95.76,163.17 PR89062.1
  IN2 w0.254: v1(95.85,163.08) 89.06,163.08 88.59,163.55 81.95,163.55 v1(81.6,163.9)
  BOTTOM w0.229: PU89001.20 95.1,162.8 95.21,162.92 95.69,162.92 v1(95.85,163.08)
  BOTTOM w0.254: v2(81.6,164.69) v1(81.6,163.9)
GT_IOUTA: length 4.8
  TOP w0.254: v2(92.43,165.62) 93.27,165.62 93.53,165.89 PR89063.2 ; PR89063.2 94.56,166.49 v1(94.59,166.51) ; PR89063.2 PC89033.1
  BOTTOM w0.229: PU89001.13 94.59,166.1 v1(94.59,166.51)
GT_PWM1_A: length 110.9
  TOP w0.254: PU93001.2 v1(161.28,124.09)
  IN1 w0.203: v1(161.28,124.09) 161.01,123.81 159.74,123.81 158.39,125.16 158.39,135.8 153.67,140.52 153.67,142.57 152.21,144.03 150.34,144.03 149.87,144.5 145.31,144.5 144.9,144.09 140.78,144.09 140.36,144.5 135.14,144.5 134.31,145.33 134.31,149.95 133.5,150.76 132.31,150.76 131.37,151.7 131.37,152.3 130.41,153.25 124.08,153.25 123.32,152.49 115.8,152.49 113.28,149.98 111.78,149.98 110.87,150.89 110.87,153.32 110.3,153.89 107.64,153.89 105.1,156.43 105.1,157.57 102.13,160.54 v1(102.13,161.27)
  BOTTOM w0.203: v1(102.13,161.27) 102.13,159.65 101.24,158.75 95.67,158.75 93.8,156.89 93.8,156.24 93.2,155.64 v2(92.66,155.64) 92.29,155.64 91.63,156.3 91.63,156.91 PR89041.1 91.71,157.93 92.25,157.93 92.9,158.58 92.9,159.41 92.99,159.51 PU89001.30
GT_PWM1_BOOT_R_C: length 2.9
  TOP w0.254: PC93005.2 166.23,126.66 v2(167.08,126.66)
  TOP w0.508: 164.48,126.03 PC93005.2
GT_PWM1_EN: length 4.4
  TOP w0.254: PR93005.2 160.74,124.6 v1(160.73,124.6) 160.73,123.84 160.98,123.59 PU93001.3
  BOTTOM w0.254: v1(160.73,124.6) 160.63,124.5 v2(160.63,123.81)
GT_PWM1_HG_D: length 44.9
  TOP w0.279: PU93001.8 164.45,124.59 v1(164.63,124.41)
  IN1 w0.508: v1(139.9,151.55) 140.51,151.55 142.11,149.95 147.21,149.95 151.3,145.86 152.97,145.86 155.08,143.75 157.73,143.75 160.4,141.09 160.4,129.15 164.63,124.92 v1(164.63,124.41)
  BOTTOM w0.254: v2(165.3,124.65) 164.87,124.65 v1(164.63,124.41)
GT_PWM1_HG_D_R:
  vias: v1(139.93,150.54) v2(139.93,149.57)
GT_PWM1_LG_D: length 7.7
  TOP w0.279: v1(164.77,121.63) 164.41,121.99 164.41,122.85 164.17,123.09 PU93001.5
  TOP w0.508: PR93007.1 166.09,122.85 165.99,122.85 v1(164.77,121.63)
  BOTTOM w0.254: v1(164.77,121.63) 164.77,121.27 v2(163.47,119.98)
GT_PWM1_LG_D_R: length 50.9
  TOP w0.508: PR93007.2 166.53,125.02 v1(166.53,124.74)
  BOTTOM w0.508: v3(138.2,142.28) 138.86,142.94 141.3,142.94 142.6,144.24 145.4,144.24 146.87,145.71 149.98,145.71 152.02,143.67 157.64,143.67 158.16,143.14 158.16,136.63 157.82,136.28 v2(157.82,129.99) 157.82,129.86 158.79,128.89 158.87,128.89 162.85,124.91 162.85,124.85 162.92,124.78 162.92,124.14 164.39,122.67 165.77,122.67 166.53,123.43 v1(166.53,124.74)
GT_PWM1_SN:
  vias: v2(131.7,148.4)
GT_PWM1_SW_S: length 45.3
  TOP w0.279: PU93001.7 164.16,124.09 164.57,123.69 v1(165.35,123.69)
  TOP w0.508: PC93005.1 165.61,123.94 v1(165.35,123.69)
  IN1 w0.508: PQ93001.10 139.52,146.12 149.53,146.12 150.8,144.85 152.55,144.85 154.56,142.84 154.56,140.73 159.38,135.91 159.38,128.49 162.61,125.26 162.61,124.55 163.9,123.26 164.92,123.26 v1(165.35,123.69)
  vias: v2(136.7,146.45)
GT_PWM1_VCC: length 4.2
  TOP w0.254: 161.78,122.55 162.01,122.79 PU93001.4
  TOP w0.508: v1(161.57,120.94) 161.78,121.15 PC93007.2 161.78,122.55
  BOTTOM w0.254: v2(162.25,121.48) 162.1,121.48 v1(161.57,120.94)
  BOTTOM w0.508: v1(161.57,120.94) 161.42,121.1 161.42,121.15 PR93002.2
GT_PWM2_A: length 137.3
  IN1 w0.254: v1(159.28,149.93) 159.28,150.12 158.53,150.87 155.54,150.87 152.11,154.3 152.11,157.61 153.31,158.81 153.31,164.27 151.85,165.72 149.58,165.72 148.3,167.01 145.87,167.01 145.38,166.52 137.36,166.52 135.08,168.8 131.96,168.8 130.32,170.44 112.98,170.44 111.71,169.16 111.71,166.27 110.02,164.58 103.3,164.58 102.51,165.38 v1(102.37,165.38)
  IN2 w0.203: v1(159.28,149.93) 159.38,149.82 159.38,145.17 158.3,144.08 156.12,144.08 155.29,143.26 155.29,137.84 156.13,137 156.13,131.49 155.34,130.7 155.34,127.57 v1(156.01,126.91)
  BOTTOM w0.203: PU89001.31 92.59,158.7 92.12,158.23 91.41,158.23 91.03,157.85 90.61,157.85 PR89049.1 90.61,156.91 v2(90.61,155.4) 90.92,155.09 93.23,155.09 94.21,156.07 94.21,156.72 95.83,158.35 101.41,158.35 102.6,159.54 102.6,165.14 v1(102.37,165.38)
  BOTTOM w0.254: v1(156.01,126.91) 156.01,125.01 156.87,124.15 157.51,124.15 158.63,123.03 PU93002.2
GT_PWM2_BOOT: length 6.9
  BOTTOM w0.127: v2(157.15,128.36) 156.56,128.36 155.52,127.32 155.52,123.59 155.68,123.43 PR93010.1
GT_PWM2_BOOT_R_C:
  vias: v2(157.1,118.63)
GT_PWM2_EN: length 5.1
  BOTTOM w0.127: v2(157.22,126.51) 157.71,126.02 157.71,125.25 PR93013.2
  BOTTOM w0.254: PR93013.2 157.44,124.65 157.65,124.65 159.13,123.17 PU93002.3
GT_PWM2_HG_D: length 35.4
  TOP w0.635: PR93011.1 167.04,98.65 167.01,98.62 v3(166.42,98.62)
  IN1 w0.635: v3(166.42,98.62) 164.35,96.55 160.64,96.55 159.52,97.67 159.52,105.56 157.88,107.2 157.88,116.3 156.26,117.92 156.26,120.03 v3(157,120.77)
  BOTTOM w0.508: v2(166.39,99.61) 166.39,98.64 v3(166.42,98.62)
GT_PWM2_HG_D_R: length 1.2
  BOTTOM w0.508: v1(168.12,101.13) 167.87,101.39 v2(166.98,101.39)
GT_PWM2_LG_D: length 29
  TOP w0.635: PR93015.1 v3(162.74,97.88)
  IN1 w0.635: v3(162.74,97.88) 162.23,98.39 162.23,106.72 161.54,107.41 159.94,107.41 159.04,108.31 159.04,116.76 157.4,118.4 157.4,119.45 158.42,120.46 159.82,120.46 v3(160.22,120.06)
  vias: v2(161.19,119.9)
GT_PWM2_LG_D_R: length 0.9
  BOTTOM w0.508: v2(162.99,100.55) v1(163.85,100.55)
GT_PWM2_SN:
  vias: v2(166.57,97.4)
GT_PWM2_SW_S: length 14.8
  IN1 w0.635: v3(159.03,119.12) 160.18,117.96 160.18,109.24 160.86,108.55 162.39,108.55 PQ93002.13
  vias: v2(159.84,118.79)
GT_PWM2_VCC:
  vias: v2(158.95,124.32)
GT_ROSC: length 3.1
  BOTTOM w0.229: PU89001.8 92.19,166.51 v2(91.85,166.86) 92,167.01 92,168.16 92.02,168.19 PR89070.1
GT_TSENSEA: length 104.4
  TOP w0.254: v1(141.6,141.52) 141.6,142.2 140.19,143.62 PR89072.2 ; v1(95.16,167.32) 94.53,167.32 v2(93.88,166.66)
  IN1 w0.203: v1(141.6,141.52) 141.6,142.33 141.15,142.79 140.35,142.79 139.87,143.27 136.65,143.27 135.23,141.85 127.38,141.85 126.36,140.83 116.86,140.83 116.28,141.42 105.47,141.42 103.95,142.94 97.66,142.94 96.99,142.27 94.52,142.27 93.58,143.21 93.58,143.83 88.42,149 88.42,149.7 87.56,150.55 87.56,151.8 87.67,151.9 87.67,154.08 87.4,154.35 85.42,154.35 85.14,154.63 84.15,154.63 81.13,157.65 81.13,160.98 85.33,165.19 88.63,165.19 89.46,164.37 94.09,164.37 94.8,165.08 94.8,165.53 95.16,165.89 v1(95.16,167.32)
  BOTTOM w0.229: 93.45,166.47 93.39,166.41 PU89001.11
  BOTTOM w0.254: v1(95.16,167.32) 95.16,167.76 95.38,167.99 95.38,168.35 PC89037.1 94.59,167.82 94.59,167.63 94.3,167.34 94.25,167.34 93.45,166.54 93.45,166.47
GT_TSENSEA_R: length 4.8
  TOP w0.254: PR89072.1 140.48,144.44 140.54,144.44 PR89073.1 141.27,143.7 141.27,143.4 141.5,143.17 PRT89004.1 v1(142.58,142.53)
  BOTTOM w0.254: v1(142.58,142.53) 142.58,142.9 142.82,143.14 v2(143.05,143.14)
GT_VSNA: length 5.9
  BOTTOM w0.127: v2(97.72,169.41) 97.37,169.05 97.37,168.42 PR89054.2
  BOTTOM w0.229: PU89001.14 94.92,165.2 95.72,166 95.99,166 96.32,166.33 96.57,166.33 96.81,166.58 PC89031.2 PR89054.2
GT_VSPA: length 9.7
  TOP w0.254: PR89048.2 100.81,166.64 v1(101.32,166.13) 101.32,165.89 PR89050.2
  BOTTOM w0.229: v1(101.32,166.13) 100.61,166.84 v2(99.74,166.84) 98.97,166.07 PC89027.1 98.49,166.44 97.23,166.44 PC89028.1 96.47,165.67 95.86,165.67 94.99,164.8 PU89001.15
H_DDR_VTT_CNTL: length 5.4
  TOP w0.254: HR2.2 157.32,78.21 v2(156.44,77.33) 155.98,77.79 HR3.1 155.98,79.29 156.1,79.41 HQ2.3
H_DDR_VTT_CNTL_R: length 4.3
  TOP w0.254: HR3.2 155.14,77.31 154.71,76.87 HQ1.1 153.89,76.48 154.33,76.04 v2(155.27,76.04)
H_PRDY#: length 116.2
  TOP w0.102: v1(68.07,128.41) 68.43,128.06 v1(69.9,128.06) ; XU1.B10 112.34,129.35 111.95,129.75 110.71,129.75 110.45,129.49 110.45,129.49 v1(110.45,128.9)
  IN1 w0.102: v1(73.51,140.99) 74.67,140.99 75.57,140.08 77.81,140.08 78.68,139.22 82.44,139.22 84.85,136.81 85.75,136.81 86.21,136.35 86.21,135.85 86.85,135.21 87.35,135.21 87.86,134.7 88.77,134.7 90.87,132.59 94.82,132.59 v1(94.83,132.58) ; v1(97.97,125.85) 101.47,125.85 101.85,126.23 102.68,126.23 103.13,126.67 103.85,126.67 104.63,127.45 109.18,127.45 110.04,128.3 110.04,128.49 v1(110.45,128.9)
  BOTTOM w0.102: HR369.2 42.92,109.32 42.92,109.96 43.96,111 44.38,111 44.91,111.52 45.33,111.52 45.63,111.82 45.63,113.63 47.83,115.83 53.72,115.83 54.15,116.26 55.79,116.26 56.23,116.7 57.8,116.7 63.2,122.1 65.19,122.1 67.38,124.29 67.38,127.73 v1(68.07,128.41) 69.11,129.45 69.11,134.36 v2(70.94,136.18) 73.1,138.34 73.1,140.58 v1(73.51,140.99) ; v1(69.9,128.06) 69.9,126.89 71.63,125.16 72.75,125.16 73.56,124.35 73.56,123.64 76.73,120.46 XDP1.5 ; v1(94.83,132.58) 94.83,130.14 97.98,127 97.98,125.85 v1(97.97,125.85)
H_PREQ#: length 96.8
  TOP w0.102: XU1.B9 111.26,128.85 v1(111.26,127.96) ; v1(43.43,109.88) 43.61,109.7 HR368.2 ; v1(98.14,125.17) 96.9,125.17 96.29,125.78 94.71,125.78 94.04,126.44 90.5,126.44 90.06,126.89 88.99,126.89 88.8,127.08 88.21,127.08 88.09,126.96 86.98,126.96 86.72,126.7 86.31,126.7 85.95,127.06 84.5,127.06 83.87,126.43 83.71,126.43 83.68,126.4 v2(82.42,126.4) 82.42,126.02 v1(82.7,125.74)
  IN1 w0.102: v1(98.14,125.17) 101.16,125.17 101.95,125.95 102.7,125.95 103.21,126.47 103.94,126.47 104.71,127.25 110.55,127.25 v1(111.26,127.96)
  IN2 w0.102: v1(82.7,125.74) 82.11,125.15 80.81,125.15 79.27,126.69 71.29,126.69 69.95,125.35 66.53,125.35 64.54,123.36 61.35,123.36 59.51,121.52 55.35,121.52 55.15,121.31 51.68,121.31 47.15,116.78 47.15,113.01 46.38,112.23 46.38,111.29 45.69,110.61 44.16,110.61 v1(43.43,109.88)
  BOTTOM w0.102: XDP1.3 79.61,120.96 79.86,120.72 HR347.2 80.87,121.14 81.48,121.14 82.27,121.93 82.27,122.2 82.69,122.62 82.69,123.52 83.02,123.85 83.02,124.47 82.34,125.15 81.41,125.15 81.16,125.39 81.16,125.74 81.47,126.05 82.4,126.05 v1(82.7,125.74)
H_PROCHOT#: length 236
  IN1 w0.127: v1(58.35,145.86) 58.35,145.3 61.9,141.75 64.63,141.75 65.41,142.53 65.91,142.53 66.6,141.85 75.54,141.85 v1(75.58,141.9) 75.84,141.64 75.84,141.21 76.12,140.93 79.01,140.93 79.88,140.07 82.88,140.07 v1(85.22,137.73) ; v1(28.34,143.05) 28.8,142.59 28.8,142.13 30.83,140.1 30.83,136.38 28.56,134.1 v1(27.89,134.1) ; v1(17.35,120.89) 17.35,119.56 17.64,119.26 17.64,118.27 17.39,118.01 17.18,118.01 16.66,117.49 16.66,116.72 15.62,115.68 15.62,114.03 14.6,113.02 14.6,108.85 16.15,107.3 16.15,104.39 15.85,104.08 15.85,93.89 18.1,91.65 18.1,89.14 18.49,88.74 19.24,88.74 19.38,88.59 19.38,87.69 19.66,87.41 v1(19.68,87.41)
  IN2 w0.102: v1(28.34,143.05) 31.13,143.05 32.4,141.79 35.65,141.79 36.03,141.4 37.05,141.4 40.95,145.3 43.99,145.3 44.05,145.24 51.55,145.24 52.12,145.81 54.41,145.81 54.61,145.61 58.1,145.61 v1(58.35,145.86)
  IN2 w0.127: v1(85.22,137.73) 89.27,133.68 89.27,130.56 89.73,130.1 90.69,130.1 92.11,128.68 94.16,128.68 95.94,130.46 v1(97.48,130.46) ; v1(105.77,107.88) 106.48,108.59 111,108.59 113.8,105.8 126.08,105.8 127.4,107.12 127.4,112.38 128.67,113.65 128.67,116.2 131.33,118.86 131.56,118.86 133.46,120.76 v1(133.46,121.33)
  BOTTOM w0.102: v1(19.68,87.41) 19.71,87.41 19.72,87.4 ECR104.2 21.25,87.4 v2(21.54,87.11)
  BOTTOM w0.127: v1(27.89,134.1) 26.78,134.1 25.62,132.95 25.62,131.78 25.14,131.29 21.88,131.29 21.51,131.66 19.94,131.66 17.39,129.1 17.39,120.93 v1(17.35,120.89) ; v1(133.46,121.33) 133.5,121.29 HR29.2 133.5,119.88 133.93,119.45 133.93,118.74 134.06,118.61 134.19,118.61 HR33.1 ; SR7995.1 76.65,143.42 MQ28.3 76.43,142.74 v1(75.58,141.9) 75.36,141.67 C83.1 ; v1(97.48,130.46) 100.1,127.84 100.1,125.98 100.25,125.83 100.25,118.94 97.49,116.17 97.49,109.68 99.13,108.03 105.18,108.03 105.33,107.88 v1(105.77,107.88)
H_SKTOCC_N: length 255.2
  TOP w0.089: v1(45.24,104.99) 45.24,103.85 45.11,103.72 45.11,103.37 45.2,103.28 U1.AP3
  TOP w0.127: v1(58.6,73.12) 57,73.12 56.69,73.42 v1(54.57,73.42) ; v1(121.21,43.73) 126.95,43.73 127.91,44.69 131.86,44.69 132.16,44.39 138.32,44.39 138.77,44.83 153.47,44.83 154.58,45.94 157.97,45.94 160.64,48.62 160.64,49.92 160.03,50.53 160.03,69.35 155.8,73.57 152.32,73.57 151.37,74.53 151.37,78.07 151.37,78.07 151.37,79.12 152.17,79.92 152.17,83.74 154.87,86.43 154.87,105.55 148.76,111.66 144.6,111.66 144.44,111.5 143.41,111.5 142.47,110.56 142.16,110.56 141.83,110.23 141.83,110.03 141.54,109.74 141.27,109.74 140.77,109.24 XU1.AC38
  IN1 w0.127: v1(83.92,61.46) 88.61,56.77 88.61,54.52 89.24,53.9 89.24,48.84 91.41,46.67 108.17,46.67 109.75,48.25 119.35,48.25 121.21,46.4 v1(121.21,43.73) ; v1(45.24,104.99) 45.24,104 45.27,103.96 45.27,103.28 45.76,102.79 45.76,101.73 46.68,100.8 46.68,99.38 46.89,99.18 46.89,98.17 47.32,97.74 47.32,96.74 47.12,96.54 47.12,94.99 48.54,93.57 48.54,90.47 49.76,89.25 50.72,89.25 51.45,88.52 52.11,88.52 52.93,87.7 52.93,87.36 53.64,86.65 53.64,84.44 54.38,83.71 54.38,82.64 55.68,81.34 55.68,79.34 55,78.67 55,73.85 v1(54.57,73.42)
  IN2 w0.127: v1(58.6,73.12) 60.35,71.36 60.35,66.98 v1(59.85,66.48)
  BOTTOM w0.127: v1(59.85,66.48) 60.08,66.24 60.52,66.24 60.68,66.08 62.91,66.08 63.12,66.28 69.75,66.28 71.17,64.86 71.17,64.43 71.8,63.79 71.8,62.59 73.04,61.36 76.94,61.36 77.15,61.14 v2(81.2,61.14) 83.6,61.14 v1(83.92,61.46) ; SR7928.2 45.29,104.94 v1(45.24,104.99)
H_TAPPWRGOOD: length 2
  BOTTOM w0.102: v2(84.68,121.81) 84.68,121.52 R93119.1 83.74,120.89 83.62,120.77 AR41.1
H_THMTRIP#: length 52.8
  TOP w0.127: HR413.1 86.31,124.97 86.31,124.7 86.05,124.45 85.1,124.45 84.99,124.34 84.99,123.7 84.18,122.9 84.18,121.83 84.58,121.44 84.58,120.52 85.01,120.09 v1(85.01,119.94)
  IN2 w0.127: v1(85.01,119.94) 84.35,119.28 81.86,119.28 81.67,119.09 77.92,119.09 76.5,120.51 70.21,120.51 v1(69.83,120.13)
  BOTTOM w0.127: SR266.2 50.24,108.13 SR259.2 50.19,108.85 50.05,108.99 50.05,110.18 49.63,110.61 49.63,111.57 50.05,112 50.05,112.59 50.05,112.95 50.85,113.75 54.49,113.75 54.66,113.58 56.41,113.58 57.38,114.54 58.77,114.54 v2(59.61,115.38) 59.61,115.58 63.77,119.74 65.78,119.74 66.47,120.43 69.52,120.43 v1(69.83,120.13)
H_THMTRIP#_CPU: length 53.5
  TOP w0.102: XU1.D11 113.94,127.87 113.94,129.55 113.69,129.79 113.53,129.79 112.76,130.57 112.76,130.79 112.54,131
  TOP w0.127: v1(103.42,125.23) 103.57,125.37 103.57,129.03 99.8,132.81 99.8,133.9 99.63,134.07 v1(99.63,135.31) 100.04,135.72 102.45,135.72 102.79,135.38 102.79,133.87 104.68,131.98 109.86,131.98 110.83,131 112.54,131 ; HR413.2 87.94,125.18 87.95,125.19 88.57,125.19 89.18,124.58 89.94,124.58 90.57,125.21 90.96,125.21 91.97,125.21 93.06,124.12 v1(93.06,123.35)
  IN2 w0.127: v1(93.06,123.35) 93.66,123.94 94.18,123.94 95.11,124.87 97.06,124.87 97.36,124.58 98.75,124.58 99.4,125.23 v1(103.42,125.23)
  BOTTOM w0.127: v2(99.11,137.78) 99.11,135.83 v1(99.63,135.31)
H_TRIGIN: length 80.6
  TOP w0.127: XU1.D1 104.45,129.87 v1(101.05,133.26)
  IN2 w0.127: v1(101.05,133.26) 101.05,132.68 97.94,129.56 96.26,129.56 94.52,127.82 91.75,127.82 90.34,129.23 89.37,129.23 88.93,129.67 87.87,129.67 87.49,129.29 87.49,122.69 87.68,122.5 87.68,122.14 87.4,121.86 86.92,121.86 85.98,120.92 85.8,120.92 85.44,120.56 85.44,119.6 84.25,118.4 83.28,118.4 82.83,117.95 79.53,117.95 78.81,118.66 77.74,118.66 76.32,120.08 70.74,120.08 70.35,119.7 69.37,119.7 v1(69.31,119.75)
  BOTTOM w0.127: v1(69.31,119.75) 69.07,119.99 66.66,119.99 65.97,119.31 64.83,119.31 61.16,115.64 61.16,115.15 59.42,113.42 v2(58.77,113.42) 57.95,113.42 57.11,112.57 57.11,111.74 55.85,110.48 55.85,109.9 55.34,109.39 54.84,109.39 52.68,107.23 52.68,106.97 51.61,105.91 51.61,104.56 50.98,103.93 R2420.2
H_TRIGOUT: length 62.9
  TOP w0.127: U1.AK2 47.55,104.55 47.78,104.78 47.78,105.43 v1(47.5,105.71) ; v1(85.78,129.53) 85.78,129.53 86.21,129.53 86.24,129.49 HR25.2
  IN2 w0.127: v1(47.5,105.71) 48.11,106.31 48.64,106.31 49.07,106.74 49.07,113.85 52.25,117.03 59.15,117.03 59.66,117.54 63.27,121.15 66.57,121.15 67.89,122.47 68.76,122.47 69.26,121.96 69.55,121.96 69.87,122.29 70.59,122.29 71.07,121.81 73.23,121.81 73.76,122.34 74.12,122.34 74.65,121.81 77.03,121.81 78.01,120.83 79.93,120.83 80.06,120.69 81.66,120.69 82.53,121.55 83.73,121.55 84.07,121.9 84.07,122.81 86.18,124.91 86.18,126.36 85.49,127.05 85.49,129.24 v1(85.78,129.53)
  BOTTOM w0.127: v2(47.83,106.39) 47.83,106.04 v1(47.5,105.71)
H_TRIGOUT_LMIL: length 23.3
  TOP w0.127: XU1.B3 105.9,128.97 v1(105.76,128.97) ; v2(85.95,130.22) 86.51,130.22 86.63,130.33 HR25.1 88.77,130.33 89.27,130.82 89.27,130.92 90.38,132.03 94.16,132.03 97.12,129.07 99.48,129.07 v1(99.64,128.91)
  IN2 w0.127: v1(99.64,128.91) 100.5,129.77 104.96,129.77 v1(105.76,128.97)
HDA_BCLK: length 91.8
  TOP w0.127: SR132.1 29.66,103.17 28.94,102.45 28.73,102.45 28.17,101.89 28.17,101.68 25.08,98.59 25.07,98.59 24.13,97.65 24.13,97.14 23.72,96.74 23.72,93.59 23.85,93.46 23.85,92.04 22.96,91.15 22.77,91.15 21.83,90.22 21.83,88.74 21.05,87.97 21.05,86.57 19.82,85.34 19.82,79.42 16.25,75.85 16.25,75.58 16.25,75.57 16.25,70.3 v2(16.89,69.66) 17.75,68.8 18.88,68.8 19.73,67.95 19.73,64.71 18.49,63.46 18.49,61.15 18.92,60.72 18.92,56.78 19.23,56.48 19.23,51.42 19.96,50.69 19.96,42.75 20.24,42.47 20.24,38.17 19.3,37.23 19.3,36.41 20.6,35.12 20.8,35.12 21.4,34.52 SR220.1 20.83,32.35 20.83,32.02 20.47,31.66 20.47,30.86 20.07,30.47 20.07,29.82 19.53,29.28 19.53,28.8 18.85,28.11 AC1.1 18.85,26.56 18.14,25.86 18.14,25.14 18.09,25.09 U6.6
HDA_BCLK_R: length 12.7
  TOP w0.102: U1.BD11 40.34,99.46 40.31,99.46 40.29,99.48 40.07,99.48 39.98,99.43 39.93,99.39 39.75,99.3 38.89,99.3
  TOP w0.127: 38.89,99.3 36.96,99.3 36.91,99.25 36.52,99.25 35.18,100.6 35.18,100.7 34.67,101.21 34.67,102.25 v2(34.52,102.4) 34.29,102.63 34.29,103.5 33.69,104.1 32.7,104.1 SC14.1 32.68,104.07 32.08,103.47 32.08,103.43 SR132.2
HDA_RST#: length 122.4
  TOP w0.127: U6.11 16.09,25.17 v1(15.86,25.4) 15.86,27.55 18.52,30.21 18.52,37.29 19.58,38.36 19.58,42.42 19.46,42.54 19.46,50.46 18.57,51.35 18.03,51.35 17.68,51.7 17.68,52.26 18.57,53.15 SR221.1 18.06,54.28 18.06,55.41 18.41,55.77 18.41,60.47 17.93,60.95 17.93,62.24 17.34,62.84 17.34,64.62 18.11,65.39 18.72,65.39 19.18,65.85 19.18,67.71 18.73,68.15 14.71,68.15 12.37,70.49 12.37,73.35 12.88,73.87 13.66,73.87 15.32,75.52 15.32,75.66 19.3,79.64 19.3,85.56 20.55,86.8 20.55,88.18 21.31,88.94 21.31,90.57 22.43,91.68 22.69,91.68 23.29,92.29 23.29,93.31 23.14,93.46 23.14,97.12 23.49,97.48 23.49,97.74 27.61,101.85 27.61,102.05 28.57,103.01 28.77,103.01 30.75,104.99 SR133.1
  IN1 w0.127: v1(30.4,22.06) 29.23,23.23 27.61,23.23 24.97,25.87 23.11,25.87 22.66,25.42 20.17,25.42 19.63,24.88 16.37,24.88 v1(15.86,25.4)
  BOTTOM w0.127: v1(30.4,22.06) 30.4,21.33 v2(29.44,20.36) 28.85,20.36 27.85,19.36 AR38.1 27.3,19.19 27.13,19.01 27.13,18.53 AR19.1
HDA_RST#_R: length 12.2
  TOP w0.089: U1.BE10 40.14,99.81 39.52,99.81 39.46,99.76 39.23,99.63
  TOP w0.102: 38.84,99.63 39.23,99.63
  TOP w0.127: 38.84,99.63 37.39,99.63 36.8,100.22 36.4,100.22 v2(35.89,100.73) 35.18,101.44 35.18,103.39 34.34,104.23 34.34,104.6 SC13.1 33.86,105.07 33.42,104.64 32.37,104.64 SR133.2
